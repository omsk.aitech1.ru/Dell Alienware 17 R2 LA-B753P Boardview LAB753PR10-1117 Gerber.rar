# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 62.23,22.63 62.23,22.25 62.74,21.74 69.6,21.74 69.85,21.49 69.85,16.66 69.53,16.35 62.55,16.35 62.42,16.47 62.42,18.51 61.91,19.01 60.33,19.01 59.91,19.43 59.91,22.98 60.01,23.08 61.79,23.08
GND on BOTTOM (solid shape): 227.6,32.36 227.97,32.36 228.03,32.3 228.03,32.16 227.3,31.43 227.18,31.43 227.07,31.54 227.08,31.7 227.07,31.78 227.07,32.36 227.21,32.5 227.46,32.5
GND on BOTTOM (solid shape): 212.95,35.68 213.34,35.68 213.68,35.34 213.72,35.34 213.74,35.33 213.88,35.19 213.88,35.03 213.64,34.8 213.12,34.8 212.78,35.14 212.51,35.14 212.35,34.98 212.15,34.98 212.06,35.07 212.06,35.22 212.17,35.33 212.25,35.33 212.63,35.71 212.92,35.71
GND on BOTTOM (solid shape): 212.55,48.03 212.55,47.59 212.87,47.27 212.87,46.92 213.3,46.49 213.3,46.27 213.23,46.2 213.01,46.2 212.54,46.68 212.31,46.68 212.08,46.91 212.08,47.05 212.07,47.05 212.07,47.39 211.89,47.57 211.56,47.57 211.4,47.73 211.4,48.07 211.6,48.28 212.31,48.28
GND on BOTTOM (solid shape): 231.97,92.67 231.97,66.91 231.5,66.44 230.76,66.44 230.47,66.72 230.47,73.12 230.06,73.54 230.06,76.3 230.37,76.6 230.37,83.04 229.94,83.46 229.94,84.86 230.76,85.67 230.76,87.68 230.06,88.37 230.06,92.63 230.37,92.93 231.7,92.93
GND on BOTTOM (solid shape): 264.49,40.02 264.49,38.3 265.43,37.37 265.43,37.3 264.68,36.55 264.68,34.46 263.96,33.73 263.81,33.73 262.51,35.03 262.51,39.9 262.77,40.16 264.35,40.16
GND on BOTTOM (solid shape): 27.81,17.81 27.81,17.66 27.07,16.92 26.92,16.92 26.74,16.73 26.74,16.03 27.47,15.29 27.47,14.18 27.4,14.11 26.95,14.11 26.87,14.19 26.87,14.87 26.5,15.25 25.75,15.25 25.17,15.83 25.17,17.44 25.32,17.58 26.99,17.58 27.4,17.99 27.62,17.99
GND on BOTTOM (solid shape): 88.33,124.82 88.73,124.82 89.63,125.73 89.87,125.73 90.52,125.07 90.52,124.57 91.63,123.46 92.15,123.46 93.54,124.85 93.76,124.85 93.9,124.71 94.22,124.71 94.82,125.31 95.37,125.31 96.25,124.44 96.25,124.21 94.43,122.39 89.15,122.39 86.52,125.02 86.52,125.39 87.08,125.95 87.2,125.95
GND on BOTTOM (solid shape): 198.44,61.01 198.47,61.01 198.67,60.95 198.86,61.01 199.37,61.01 199.54,60.83 199.54,59.79 199.27,59.53 197.46,59.53 197.34,59.65 197.34,61.09 197.44,61.19 198.26,61.19
GND on BOTTOM (solid shape): 199.51,128.82 199.51,126.38 199.51,126.38 199.51,126.32 199.64,126.2 199.64,124.44 198.97,123.77 198.78,123.77 198.78,123.75 198.3,123.75 198.27,123.78 198.27,123.82 198.17,123.91 198.17,126.3 198.43,126.56 198.43,128.82 198.61,129 199.34,129
GND on BOTTOM (solid shape): 256.47,29.82 256.47,28.57 255.39,27.49 254.55,27.49 254.39,27.33 254.39,26.34 254.3,26.24 251.81,26.24 251.57,26.49 251.57,27.96 252.15,28.55 253.05,28.55 253.05,28.55 253.36,28.55 253.39,28.58 253.39,30.29 253.32,30.36 248.99,30.36 248.97,30.38 248.97,31.25 249,31.29 255.01,31.29
GND on BOTTOM (solid shape): 21.88,27.5 22.1,27.42 22.32,27.5 23.04,27.5 23.37,27.17 23.37,24.82 22.9,24.35 21.23,24.35 20.9,24.69 20.9,25.36 20.89,25.36 20.89,27.29 21.1,27.5
GND on BOTTOM (solid shape): 199.72,58.56 200.27,57.37 201.15,56.41 201.15,54.26 200.83,53.94 198.19,53.94 196.74,55.39 196.74,58.41 196.89,58.56
GND on BOTTOM (solid shape): 21.3,18.94 21.3,17.78 21.57,17.51 22.54,17.51 22.69,17.36 22.69,14.87 21.93,14.12 21.93,13.58 21.78,13.43 17.43,13.43 17.43,13.44 17.19,13.44 17.07,13.56 17.07,14.81 17.21,14.95 18.11,14.95 18.26,15.1 18.26,16.59 18.35,16.68 19.12,16.68 20.07,17.63 20.07,19.14 20.13,19.2 21.04,19.2
GND on BOTTOM (solid shape): 147.96,134.96 147.96,131.99 147.87,131.9 146.59,131.9 146.5,131.99 146.5,135.15 146.61,135.17 146.86,135.17 146.95,135.15 147.03,135.16 147.11,135.15 147.2,135.17 147.64,135.17 147.68,135.17 147.75,135.17
GND on BOTTOM (solid shape): 120.97,129.38 120.97,126.71 121.22,126.46 121.48,126.46 121.6,126.33 121.6,123.53 120.84,122.77 119.97,122.77 119.83,122.91 119.83,123.6 119.45,123.98 119.19,123.98 118.94,124.23 118.94,127.2 119.1,127.36 119.67,127.36 119.83,127.51 119.83,127.79 119.51,128.11 117.35,128.11 117.07,127.83 116.21,127.83 116.09,127.95 116.09,129.32 116.21,129.44 120.91,129.44
GND on BOTTOM (solid shape): 198.3,67.77 199.26,67.77 199.38,67.69 199.35,67.55 199.18,67.39 197.17,67.39 197.08,67.48 197.09,67.51 197.09,67.63 197.05,67.73 197.02,67.77 197.19,67.94 197.35,67.94 197.52,67.77 197.87,67.77 198.04,67.94 198.13,67.94
GND on BOTTOM (solid shape): 112.84,129.19 112.84,127.28 113.15,126.98 113.15,123.52 112.4,122.77 111.57,122.77 111.52,122.77 111.38,122.91 111.38,123.53 110.58,124.34 110.58,127.16 110.76,127.34 110.8,127.36 111,127.36 111.01,127.35 111.19,127.31 111.37,127.35 111.38,127.36 111.44,127.36 111.57,127.49 111.57,128.04 111.51,128.11 111.51,129.44 111.57,129.5 112.52,129.5
GND on BOTTOM (solid shape): 212.1,30.93 212.1,30.19 212.97,29.32 213.53,29.32 213.64,29.22 213.64,28.99 213.47,28.83 212.77,28.83 212.35,28.9 212.16,28.51 212.17,28.48 211.62,27.93 211.3,27.93 211.15,28.08 211.15,28.98 211.53,29.36 211.53,30.89 211.64,31 212.03,31
GND on BOTTOM (solid shape): 37.42,34.94 37.42,24.65 37.21,24.44 37.21,23.08 37.11,22.98 35.88,22.98 35.75,23.11 35.75,27.97 35.63,28.09 32.79,28.09 32.53,27.84 32.53,27.26 32.34,27.07 29.58,27.07 29.41,27.24 29.41,27.66 29.3,27.78 28.39,27.78 28.07,28.09 28.07,29.05 28.45,29.43 34.36,29.43 34.99,30.06 35.69,30.06 36.07,30.44 36.07,34.83 36.2,34.95 36.22,34.98 37.39,34.98
GND on BOTTOM (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on BOTTOM (solid shape): 161.86,119.98 161.86,114.77 160.06,112.97 160.06,111.41 159.74,111.09 158.58,111.09 158.37,111.3 158.37,117.22 158.47,117.32 159.82,117.32 160.29,117.8 160.49,117.8 160.95,118.13 160.49,118.48 160.31,118.66 160.31,119.88 160.54,120.11 161.74,120.11
GND on BOTTOM (solid shape): 228.89,35.74 228.97,35.71 229.05,35.69 229.13,35.62 229.13,35.34 229.19,35.27 229.6,35.27 229.64,35.31 229.96,35.31 230.07,35.2 230.07,35.13 229.9,34.96 229.58,34.96 229.57,34.97 229.47,34.98 229.38,34.97 229.37,34.96 228.92,34.96 228.73,35.03 228.53,34.96 228.35,34.96 228.24,35.06 228.24,35.29 228.29,35.3 228.47,35.4 228.55,35.59 228.55,35.61 228.7,35.76 228.87,35.76
GND on BOTTOM (solid shape): 135.19,131.14 135.19,131.06 133.64,129.51 133.59,129.46 133.2,129.46 132.27,130.39 132.27,130.65 132.55,130.65 132.55,130.62 132.56,130.57 132.58,130.52 132.6,130.47 132.63,130.42 132.66,130.39 132.71,130.35 132.75,130.33 132.8,130.31 132.85,130.29 132.91,130.29 132.96,130.29 133.01,130.31 133.06,130.33 133.11,130.35 133.15,130.39 133.19,130.42 133.22,130.47 133.24,130.52 133.26,130.57 133.26,130.62 133.26,130.67 133.26,130.73 133.24,130.78 133.22,130.83 133.19,130.87 133.15,130.91 133.11,130.94 133.06,130.97 133.01,130.99 132.96,131 132.91,131 132.85,131 132.8,130.99 132.75,130.97 132.71,130.94 132.66,130.91 132.63,130.87 132.6,130.83 132.58,130.78 132.56,130.73 132.55,130.67 132.55,130.65 132.27,130.65 132.27,130.85 133.58,132.16 134.17,132.16
GND on BOTTOM (solid shape): 138.56,12.88 138.56,12.48 139.22,11.81 139.63,11.81 139.69,11.75 139.69,8.93 139.59,8.83 138.08,8.83 137.93,8.98 137.93,10.07 137.74,10.73 137.55,10.07 137.55,8.55 136.17,8.55 136.17,9.83 136.16,9.83 136.16,10.48 136.22,10.54 136.42,10.54 136.63,10.74 136.63,12.41 136.55,12.48 136.55,12.96 136.62,13.02 138.42,13.02
GND on BOTTOM (solid shape): 197.84,106.55 198.15,106.55 199.81,104.89 199.81,104.38 199.76,104.28 199.38,104.19 199.26,103.93 199.24,103.89 199.2,103.87 199.15,103.87 199.05,103.89 199.01,103.99 199.01,104.62 198.66,104.96 198.01,104.96 197.91,105.01 197.89,105.12 197.88,105.26 197.81,105.39 197.81,105.51 197.38,105.94 197.38,106.66 197.74,106.66
GND on BOTTOM (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on BOTTOM (solid shape): 109.03,135.31 109.04,135.28 109.06,135.23 109.08,135.21 109.08,134.81 107.14,132.88 104.53,132.88 104.23,132.57 103.94,132.57 103.68,132.83 103.68,133.27 103.74,133.29 103.79,133.32 103.83,133.35 103.86,133.38 103.89,133.42 103.92,133.47 103.93,133.52 103.95,133.57 103.95,133.62 103.94,133.67 104.16,133.89 104.19,133.91 104.24,133.95 104.28,133.99 104.3,134.02 104.57,134.3 104.61,134.32 104.65,134.36 104.69,134.4 104.71,134.44 105.09,134.81 105.41,134.81 105.41,134.76 105.42,134.71 105.44,134.66 105.46,134.61 105.49,134.56 105.52,134.53 105.57,134.49 105.61,134.47 105.66,134.45 105.71,134.43 105.77,134.43 105.82,134.43 105.87,134.45 105.92,134.47 105.97,134.49 106.01,134.53 106.05,134.56 106.08,134.61 106.1,134.66 106.12,134.71 106.12,134.76 106.12,134.81 106.12,134.87 106.1,134.92 106.08,134.97 106.05,135.01 106.01,135.05 105.97,135.08 105.92,135.11 105.87,135.13 105.82,135.14 105.77,135.14 105.71,135.14 105.66,135.13 105.61,135.11 105.57,135.08 105.52,135.05 105.49,135.01 105.46,134.97 105.44,134.92 105.42,134.87 105.41,134.81 105.09,134.81 106.63,136.36 107.98,136.36
GND on BOTTOM (solid shape): outline of 93 points within 125,122.96 130.88,131.25
GND on BOTTOM (solid shape): 197.16,101.87 197.26,101.89 197.35,101.83 197.61,101.68 197.86,101.84 198.14,101.84 198.24,101.73 198.38,101.68 198.4,101.68 198.69,101.39 198.69,101.16 198.52,100.98 197.92,100.98 197.91,100.98 197.46,100.98 197.2,101.11 196.94,100.98 196.66,100.98 196.4,101.11 196.14,100.98 195.95,100.98 195.89,101.02 195.86,101.05 195.82,101.12 195.81,101.18 195.82,101.23 195.87,101.31 195.93,101.36 195.96,101.38 196.17,101.59 196.18,101.64 196.36,101.8 196.58,101.72 196.61,101.68 196.97,101.68
GND on BOTTOM (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,145.23 137.82,145.04 137.91,144.87 137.91,143.42 138.62,142.71 138.62,139.28 137.92,138.58 135.64,138.58 134.3,139.92 132.97,139.92 132.4,139.35 132.4,137.44 131.96,137 130.56,137 130.11,137.44 130.11,140.82 130.37,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on BOTTOM (solid shape): 227.5,34.28 227.5,33.03 227.46,33 226.69,33 226.44,32.75 226.4,32.69 226.37,32.62 226.2,32.45 226.19,32.45 226.12,32.41 226.02,32.32 225.51,32.32 225.25,32.46 225.03,32.26 224.97,32.17 224.86,32.17 224.61,32.18 224.43,32.01 224.21,32.01 224.11,32.11 224.11,32.32 224.33,32.54 224.35,32.55 224.49,32.63 224.56,32.77 224.57,32.79 224.9,32.79 225.11,33 225.38,33 225.39,32.96 225.54,32.8 225.75,32.75 226.08,32.93 226.03,33.31 226,33.38 226.03,33.44 226.11,33.56 226.13,33.69 226.3,33.86 226.82,33.86 226.94,33.98 226.94,34.15 227.17,34.38 227.4,34.38
GND on BOTTOM (solid shape): 167.98,68.68 168.1,68.62 168.24,68.5 168.43,68.48 168.46,68.48 168.51,68.43 168.51,68.4 168.57,68.2 168.75,68.09 168.83,68.04 168.86,67.96 168.86,67.94 168.84,67.89 168.8,67.87 168.71,67.86 168.63,67.82 168.62,67.81 168.48,67.81 168.46,67.85 168.01,68.04 167.87,67.57 167.87,67.44 167.76,67.38 167.67,67.38 167.49,67.55 167.49,67.58 167.38,67.81 167.02,67.88 166.97,67.98 166.97,68.13 167.05,68.13 167.06,68.12 167.33,68.12 167.49,68.34 167.53,68.41 167.61,68.45 167.77,68.5 167.88,68.62
GND on BOTTOM (solid shape): 230.74,30.79 230.74,29.64 231.11,29.27 231.11,28.08 231.35,27.85 231.35,26.22 231.28,26.15 231,26.15 229.68,27.46 229.64,27.46 228.86,28.24 228.86,28.38 228.86,28.43 228.37,28.92 228.37,28.93 228.15,29.15 228.15,29.16 228.09,29.26 227.98,29.33 227.97,29.33 227.88,29.42 227.58,29.42 227.35,29.65 227.35,29.81 227.41,29.91 227.41,30.03 227.34,30.17 227.19,30.23 227.17,30.23 227.13,30.27 227.13,30.6 227.27,30.73 227.54,30.73 227.64,30.63 227.65,30.61 227.69,30.49 227.78,30.41 227.85,30.32 227.82,30.22 227.8,29.92 228.08,29.8 228.27,29.99 228.19,30.24 228.19,30.43 228.35,30.59 229.07,30.59 229.1,30.54 229.15,30.49 229.15,30.3 228.73,29.88 228.73,29.77 228.92,29.45 229.24,29.63 229.29,29.7 229.38,29.72 229.52,29.75 229.65,29.83 229.66,29.83 230.08,30.26 230.08,30.84 230.29,31.05 230.49,31.05
GND on BOTTOM (solid shape): 165.99,70.92 166.02,70.8 165.93,70.71 165.68,70.33 166.04,70.06 166.09,70.04 166.11,69.99 166.11,69.93 165.88,69.7 165.88,67.54 165.72,67.38 165.38,67.38 165.38,68.07 165.09,68.35 165.09,68.38 165.02,68.57 164.76,68.71 164.73,68.79 164.73,68.81 164.75,68.86 164.79,68.88 165.09,69.21 164.72,69.46 164.69,69.45 164.61,69.52 164.78,69.68 164.8,69.68 165.09,69.96 164.85,70.27 164.77,70.31 164.74,70.38 164.74,70.41 164.75,70.46 164.8,70.48 165.03,70.59 165.12,70.94 165.21,70.98 165.93,70.98
GND on BOTTOM (solid shape): outline of 161 points within 175.98,32.85 198.3,45.2
GND on BOTTOM (solid shape): outline of 185 points within 119.27,9.69 124.23,14.45
GND on BOTTOM (solid shape): 169.33,74.09 169.33,74.08 169.57,73.69 169.89,74.02 169.92,74.12 170.02,74.16 170.81,74.16 170.92,74.05 170.91,74.02 170.97,73.8 171.18,73.68 171.26,73.64 171.29,73.56 171.29,73.53 171.27,73.49 171.22,73.47 170.91,73.2 171.18,72.89 171.26,72.84 171.29,72.76 171.29,72.73 171.27,72.69 171.22,72.67 171.06,72.64 170.95,72.52 170.26,72.52 170.1,72.37 169.98,72.34 169.89,72.43 169.79,72.6 169.62,72.67 169.58,72.69 169.56,72.73 169.56,72.76 169.59,72.84 169.66,72.89 169.79,73.4 169.31,73.19 169.27,73.1 169.19,73.06 169.17,73.06 169.11,73.08 169.09,73.13 169.04,73.35 168.84,73.47 168.76,73.51 168.73,73.59 168.73,73.61 168.75,73.66 169.02,73.78 169.09,74.02 169.12,74.12 169.22,74.16 169.33,74.16
GND on BOTTOM (solid shape): 168.22,106.03 168.25,105.93 168.2,105.84 168.09,105.48 168.39,105.25 168.47,105.21 168.51,105.14 168.59,104.97 168.76,104.89 168.84,104.85 168.87,104.77 168.86,104.69 168.81,104.67 168.61,104.6 168.51,104.42 168.47,104.34 168.39,104.31 168.07,103.95 168.44,103.65 168.44,103.65 168.49,103.63 168.51,103.57 168.49,103.52 168.44,103.51 168.26,103.48 168.13,103.36 168.11,103.33 167.99,103.34 167.92,103.35 167.86,103.38 167.82,103.41 167.78,103.41 167.47,103.73 167.44,103.75 167.41,103.78 167.37,103.82 167.35,103.84 167.28,103.92 167.26,104.02 167.33,104.11 167.44,104.2 167.49,104.34 167.53,104.41 167.61,104.45 167.93,104.78 167.61,105.11 167.53,105.14 167.49,105.22 167.4,105.39 167.22,105.47 167.2,105.47 167.04,105.63 167.11,105.7 167.14,105.69 167.43,105.8 167.46,106.11 167.47,106.23 167.58,106.29 167.96,106.29
GND on BOTTOM (solid shape): outline of 240 points within 269.5,22 279.8,35.27
GND on BOTTOM (solid shape): 193.04,69.62 193.23,69.43 193.31,69.37 193.32,69.27 193.35,69.02 193.56,68.89 193.64,68.85 193.67,68.77 193.67,68.74 193.66,68.69 193.61,68.67 193.32,68.46 193.46,68.12 193.46,68.02 193.46,68.01 193.49,67.91 193.44,67.82 193.33,67.69 193.31,67.52 193.29,67.42 193.19,67.38 193.07,67.38 193.07,67.45 193.07,67.46 193.06,67.72 192.84,67.87 192.76,67.91 192.73,67.99 192.73,68.01 192.75,68.06 192.79,68.08 193.02,68.57 192.51,68.42 192.47,68.34 192.39,68.31 192.07,67.98 192.39,67.65 192.47,67.61 192.51,67.54 192.51,67.52 192.49,67.42 192.39,67.38 191.79,67.38 191.79,68.08 191.5,68.37 191.49,68.44 191.51,68.54 191.61,68.59 191.67,68.59 191.95,68.88 191.95,69.25 192.03,69.37 192.17,69.34 192.27,69.27 192.39,69.25 192.47,69.21 192.51,69.14 193.01,68.97 192.84,69.47 192.76,69.51 192.73,69.59 192.73,69.61 192.75,69.66 192.79,69.68 192.87,69.69 192.94,69.72 192.96,69.73 193.04,69.73
GND on BOTTOM (solid shape): 197.95,92.25 198.06,92.29 198.15,92.23 198.27,92.11 198.44,92.09 198.47,92.09 198.67,91.89 199.63,91.89 199.75,91.82 199.72,91.68 199.4,91.35 198.73,91.35 198.44,91.07 198.39,91.07 198.35,91.09 198.33,91.14 198,91.51 197.67,91.14 197.66,91.09 197.61,91.07 197.59,91.07 197.55,91.09 197.53,91.14 197.2,91.51 196.87,91.14 196.86,91.09 196.81,91.07 196.79,91.07 196.75,91.09 196.73,91.14 196.51,91.49 196.12,91.35 196.1,91.32 195.54,91.32 195.28,91.06 195.24,91.07 195.16,91.11 195.13,91.2 195.09,91.36 194.98,91.49 194.92,91.59 194.98,91.7 195.1,91.83 195.13,92.01 195.15,92.06 195.19,92.08 195.21,92.08 195.26,92.06 195.27,92.01 195.6,91.65 195.93,92.01 195.95,92.06 195.99,92.08 196.01,92.08 196.06,92.06 196.07,92.01 196.4,91.65 196.73,92.01 196.75,92.06 196.79,92.08 196.81,92.08 196.86,92.06 196.87,92.01 197.18,91.65 197.53,91.97 197.56,92.05 197.64,92.09 197.76,92.13 197.85,92.22 197.92,92.22
GND on BOTTOM (solid shape): 161.19,69.39 161.29,69.35 161.32,69.24 161.6,68.88 161.89,69.24 161.91,69.35 162.01,69.39 162.14,69.39 162.14,69.32 162.14,69.3 162.14,69.04 162.37,68.89 162.45,68.85 162.48,68.77 162.48,68.74 162.46,68.69 162.41,68.67 162.18,68.19 162.69,68.34 162.73,68.42 162.82,68.45 162.84,68.45 162.89,68.43 162.91,68.38 163.18,68.08 163.49,68.34 163.53,68.41 163.61,68.45 163.85,68.56 163.93,68.81 163.95,68.86 164,68.88 164.01,68.88 164.06,68.86 164.07,68.81 164.15,68.56 164.39,68.45 164.47,68.41 164.51,68.34 164.61,68.16 164.8,68.08 164.82,68.08 164.99,67.92 164.92,67.85 164.88,67.86 164.62,67.8 164.51,67.55 164.48,67.46 164.38,67.41 164.28,67.41 164.28,67.49 164.28,67.5 164.03,67.87 163.71,67.55 163.68,67.46 163.58,67.41 163.48,67.41 163.48,67.49 163.48,67.5 163.25,67.86 162.91,67.6 162.86,67.51 162.76,67.49 162.6,67.47 162.46,67.38 161.08,67.38 160.54,67.91 160.54,69.39
GND on BOTTOM (solid shape): outline of 90 points within 212.06,36.35 213.86,41
GND on BOTTOM (solid shape): outline of 118 points within 214.65,34.89 216.19,42.78
GND on BOTTOM (solid shape): outline of 96 points within 193.53,102.46 196.51,106.29
GND on BOTTOM (solid shape): outline of 173 points within 219.15,43.8 224.96,47.6
GND on BOTTOM (solid shape): outline of 203 points within 212.06,29.37 221.57,34.36
GND on BOTTOM (solid shape): outline of 183 points within 217.24,29.33 226.21,31.19
GND on BOTTOM (solid shape): outline of 139 points within 30.73,0.25 341.75,43.1
GND on BOTTOM (solid shape): outline of 176 points within 0.25,37.79 117.68,150.02
GND on BOTTOM (solid shape): outline of 161 points within 168.73,101.59 173.31,105.9
GND on BOTTOM (solid shape): outline of 151 points within 147.19,41.02 319.1,150.02
GND on BOTTOM (solid shape): outline of 1452 points within 212.02,33.77 226.82,47.86
GND on BOTTOM (solid shape): outline of 1739 points within 225.11,35.96 239.84,49.07
GND on BOTTOM (solid shape): outline of 6300 points within 170.45,97.28 193.67,106.29
GND on BOTTOM (solid shape): outline of 7924 points within 160.54,67.38 171.29,97.25
GND on BOTTOM (solid shape): outline of 12920 points within 176.65,67.37 200.22,99.44
GND on IN1 (solid shape): 63.76,28.67 63.76,21.62 62.73,20.59 59.08,20.59 58.49,21.19 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN1 (solid shape): 34.79,29.38 35.25,29.38 35.3,29.43 36.05,29.43 36.29,29.2 36.29,27.57 35.86,27.14 28.41,27.14 27.94,27.62 27.94,28.95 28.42,29.43 34.74,29.43
GND on IN1 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN1 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN1 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,143.55 138.62,142.71 138.62,139.28 137.54,138.2 136.02,138.2 134.75,139.47 133.42,139.47 133.1,139.16 133.1,138.14 132.59,137.63 130.88,137.63 130.11,138.39 130.11,140.98 130.2,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN1 (solid shape): outline of 316 points within 12.04,12.92 22.04,19.78
GND on IN1 (solid shape): outline of 450 points within 176.62,32.64 198.34,45.27
GND on IN1 (solid shape): outline of 168 points within 0.25,36.12 118.62,150.02
GND on IN1 (solid shape): outline of 135 points within 30.73,0.25 341.75,43.1
GND on IN1 (solid shape): outline of 154 points within 146.43,41.02 319.1,150.02
GND on IN2 (solid shape): 63.76,28.67 63.76,21.62 62.73,20.59 59.08,20.59 58.49,21.19 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN2 (solid shape): 34.77,29.37 35.43,29.37 35.53,29.48 35.91,29.48 36.24,29.15 36.24,27.02 35.54,26.33 28.27,26.33 27.9,26.7 27.9,28.92 28.45,29.48 34.66,29.48
GND on IN2 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN2 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN2 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,146.5 137.78,146.5 137.78,143.55 138.62,142.71 138.62,140.55 137.1,139.03 136.46,139.03 136.02,139.47 133.42,139.47 133.1,139.16 133.1,138.71 131.89,137.5 130.43,137.5 129.86,138.08 129.86,140.84 130.09,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN2 (solid shape): outline of 168 points within 0.25,36.08 118.62,150.02
GND on IN2 (solid shape): outline of 135 points within 30.73,0.25 341.75,43.1
GND on IN2 (solid shape): outline of 980 points within 146.43,38.52 319.1,150.02
GND on IN3 (solid shape): 63.76,28.67 63.76,21.62 62.71,20.58 59.12,20.58 58.49,21.21 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN3 (solid shape): 259.94,10.13 259.94,4.68 259.81,4.55 252.82,4.55 252.71,4.66 252.71,9.89 253.88,11.06 259.01,11.06
GND on IN3 (solid shape): 34.77,29.37 35.43,29.37 35.53,29.48 35.91,29.48 36.24,29.15 36.24,27.02 35.54,26.33 28.27,26.33 27.9,26.7 27.9,28.92 28.45,29.48 34.66,29.48
GND on IN3 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN3 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN3 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.68,147.63 137.77,147.51 137.77,143.56 138.62,142.71 138.62,140.74 137.35,139.47 133.1,139.47 131.64,138.01 130.81,138.01 130.43,138.39 130.43,140.89 130.61,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN3 (solid shape): outline of 164 points within 0.25,36.07 118.62,150.02
GND on IN3 (solid shape): outline of 140 points within 30.73,0.25 341.75,43.1
GND on IN3 (solid shape): outline of 984 points within 146.43,38.52 319.1,150.02
GND on IN4 (solid shape): 63.76,28.67 63.76,27.78 62.42,26.44 62.42,20.66 62.33,20.58 59.08,20.58 58.49,21.17 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN4 (solid shape): 34.77,29.37 35.43,29.37 35.53,29.48 35.91,29.48 36.24,29.15 36.24,27.02 35.54,26.33 28.27,26.33 27.9,26.7 27.9,28.92 28.45,29.48 34.66,29.48
GND on IN4 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN4 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN4 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.68,147.63 137.77,147.51 137.77,143.56 138.62,142.71 138.62,140.81 137.29,139.47 132.97,139.47 131.57,138.08 130.81,138.08 130.37,138.52 130.37,140.89 130.55,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN4 (solid shape): outline of 164 points within 0.25,36.09 118.62,150.02
GND on IN4 (solid shape): outline of 132 points within 30.73,0.25 341.75,43.1
GND on IN4 (solid shape): outline of 966 points within 147.19,38.52 319.1,150.02
GND on IN5 (solid shape): 63.76,28.67 63.76,21.62 62.73,20.59 59.1,20.59 58.49,21.2 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN5 (solid shape): 259.94,10.13 259.94,6.21 259.61,5.88 253.07,5.88 252.71,6.23 252.71,9.89 253.88,11.06 259.01,11.06
GND on IN5 (solid shape): 34.77,29.37 35.43,29.37 35.53,29.48 35.91,29.48 36.24,29.15 36.24,27.02 35.54,26.33 28.27,26.33 27.9,26.7 27.9,28.92 28.45,29.48 34.66,29.48
GND on IN5 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN5 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN5 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,145.23 137.86,144.95 138.06,144.75 138.06,143.27 138.62,142.71 138.62,140.81 137.29,139.47 132.97,139.47 131.57,138.08 130.81,138.08 130.37,138.52 130.37,140.88 130.56,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN5 (solid shape): outline of 167 points within 0.25,36.09 118.62,150.02
GND on IN5 (solid shape): outline of 136 points within 30.73,0.51 341.75,43.1
GND on IN5 (solid shape): outline of 971 points within 147.19,38.52 319.1,150.02
GND on IN6 (solid shape): 63.76,28.67 63.76,21.62 62.73,20.59 59.1,20.59 58.49,21.2 58.49,28.41 59.44,29.36 63.06,29.36
GND on IN6 (solid shape): 259.94,10.13 259.94,4.68 259.81,4.55 252.82,4.55 252.71,4.66 252.71,9.89 253.88,11.06 259.01,11.06
GND on IN6 (solid shape): 34.77,29.37 35.43,29.37 35.53,29.48 35.91,29.48 36.24,29.15 36.24,27.02 35.54,26.33 28.27,26.33 27.9,26.7 27.9,28.92 28.45,29.48 34.66,29.48
GND on IN6 (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on IN6 (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on IN6 (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.87,147.89 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,145.23 137.82,145.02 137.94,144.85 137.94,143.4 138.62,142.71 138.62,140.81 137.29,139.47 132.97,139.47 131.57,138.08 130.81,138.08 130.37,138.52 130.37,140.91 130.53,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on IN6 (solid shape): outline of 163 points within 0.25,36.1 118.62,150.02
GND on IN6 (solid shape): outline of 138 points within 30.73,0.25 341.75,43.1
GND on IN6 (solid shape): outline of 141 points within 147.19,41.02 319.1,150.02
GND on IN6 (solid shape): outline of 1061 points within 1.29,13.58 13.02,37.63
GND on GND1: outline of 277 points within 0.26,0.25 341.75,150.02 ; 1 cut-out
GND on IN1, IN3: 110.77,118.79 110.77,126.89 111.2,127.32 113.09,127.32 113.46,126.95 113.46,120.98 114.55,119.89 118.48,119.89 118.99,120.4 118.99,126.82 120,127.83 121.53,127.83 121.84,127.53 121.84,121.22 122.7,120.35 127.71,120.35 128.19,120.84 128.19,122.31 128.23,122.35 128.23,126.33 128.89,126.99 131.36,126.99 131.8,126.54 131.8,119.21 130.54,117.95 111.61,117.95
GND on VCC: outline of 176 points within 98.07,136.23 204.75,150.02
GND on VCC: outline of 240 points within 301.18,0.25 341.75,92.52
GND on VCC: 78.44,15.9 75.36,18.98 75.36,26.08 76.14,26.86 76.14,30.97 74.68,32.43 74.68,42.19 79.78,47.29 79.78,61.7 83.76,65.67 83.76,67.84 85.55,69.63 85.55,72.12 86.68,73.25 86.68,84.38 90.47,88.17 95.44,88.17 95.44,85.52 96.71,84.25 96.71,80.57 98,79.28 101.69,79.28 101.69,70.88 101.17,70.36 101.17,66.73 99.51,65.07 99.51,39.19 98.54,38.22 98.54,30.23 98.06,29.75 98.06,27.38 99.72,25.72 99.72,15.9
GND on VCC: 179.56,65.14 178.95,65.75 178.95,74.47 179.43,74.96 185.08,74.96 185.97,75.85 187.37,75.85 190.95,79.42 190.95,85.01 191.77,85.84 191.77,98.11 190.92,98.96 179.28,98.96 178.27,97.94 175.3,97.94 170.6,102.64 168.13,102.64 161.86,108.91 161.86,122.86 164.4,125.4 164.4,127.94 166.03,129.57 168.93,129.57 170.65,127.85 182.14,127.85 183.34,129.06 192.92,129.06 193.61,128.37 193.61,126.2 198.31,121.5 198.31,116.75 200.75,114.31 202.37,114.31 202.66,114.03 202.66,103.9 206.32,100.23 223.84,100.23 227.46,96.61 227.46,68.24 224.36,65.14
GND on VCC: 120.08,15.9 120.08,26.52 120.84,27.28 120.84,30.3 121.41,30.87 121.41,37.78 120.84,38.35 120.84,44.21 119.62,45.43 119.62,55.1 117.63,57.09 117.63,69.27 116.77,70.14 116.77,79.28 117.31,79.28 118.07,78.51 121.84,78.51 124.91,81.58 124.91,83.72 131.02,83.72 134.08,80.67 134.08,66.61 135.31,65.38 135.31,53.34 137.86,50.79 137.86,44.55 141.82,40.59 142.72,40.59 143.6,39.71 143.6,36.64 145,35.24 145,29.47 142.18,26.65 142.18,16.77 141.31,15.9
GND on IN3: 190.17,33 189.1,34.07 189.1,42.02 189.74,42.66 192.44,42.66 192.6,42.49 193.98,42.49 194.18,42.69 194.18,44.89 194.55,45.27 197.9,45.27 198.34,44.82 198.34,37.73 197.83,37.22 197.82,37.22 197.53,36.93 197.53,35.51 195.02,33
GND on IN3: 176.9,34.08 176.62,34.35 176.62,41.93 177.35,42.66 181.23,42.66 181.58,42.31 181.58,34.24 181.42,34.08
GND on IN4: 191.81,33.26 196.91,33.26 198.49,34.83 198.49,44.68 197.9,45.27 195.51,45.27 194.2,43.95 194.2,42.75 191.18,39.74 191.18,33.88
GND on IN4: 177.49,33.01 181.64,33.01 182,33.36 182,41.59 181.02,42.57 176.68,42.57 176.19,42.07 176.19,34.31
GND on IN4: 110.77,118.38 110.77,126.89 111.2,127.32 113.09,127.32 113.46,126.95 113.46,120.21 114.2,119.48 118.58,119.48 118.99,119.88 118.99,126.82 120,127.83 121.53,127.83 121.84,127.53 121.84,120.43 122.42,119.85 127.8,119.85 128.19,120.24 128.19,122.31 128.23,122.35 128.23,126.33 128.89,126.99 131.36,126.99 131.8,126.54 131.8,119.76 130.17,118.13 111.02,118.13
GND on GND2: outline of 282 points within 0.26,0.25 341.75,150.02 ; 1 cut-out
GND on IN5: 111.06,117.95 110.77,118.24 110.77,126.89 111.2,127.32 113.09,127.32 113.46,126.95 113.46,120.98 114.73,119.71 118.3,119.71 118.99,120.4 118.99,126.82 120,127.83 121.53,127.83 121.84,127.53 121.84,121.22 122.7,120.35 127.71,120.35 128.19,120.84 128.19,122.31 128.23,122.35 128.23,126.33 128.89,126.99 131.36,126.99 131.8,126.54 131.8,119.21 130.54,117.95
GND on IN5: 195.02,33 197.53,35.51 197.53,36.93 197.82,37.22 197.83,37.22 198.34,37.73 198.34,44.82 197.9,45.27 194.55,45.27 194.18,44.89 194.18,42.69 193.98,42.49 192.6,42.49 192.44,42.66 177.35,42.66 176.62,41.93 176.62,34.37 176.96,34.03 181.43,34.03 181.58,34.17 181.58,38.45 181.84,38.71 188.78,38.71 189.1,38.39 189.1,34.07 190.17,33
GND on IN6: 195.02,33 197.53,35.51 197.53,36.93 197.82,37.22 197.83,37.22 198.34,37.73 198.34,44.82 197.9,45.27 194.55,45.27 194.18,44.89 194.18,42.69 193.98,42.49 192.6,42.49 192.44,42.66 177.35,42.66 176.62,41.93 176.62,34.2 176.79,34.04 181.43,34.04 181.58,34.19 181.58,38.45 181.84,38.71 188.78,38.71 189.1,38.39 189.1,34.07 190.17,33
GND on IN6: 128.8,121.33 131.06,121.33 131.8,122.07 131.8,126.54 131.36,126.99 128.89,126.99 128.23,126.33 128.23,121.9
GND on IN6: 113.09,127.32 111.2,127.32 110.77,126.89 110.77,117.98 111.25,117.49 121.83,117.49 122.32,117.99 122.32,120.05 121.84,120.53 121.84,127.53 121.53,127.83 120,127.83 118.99,126.82 118.99,119.67 118.34,119.02 114.1,119.02 113.46,119.65 113.46,126.95
GND on GND3: outline of 282 points within 0.26,0.25 341.75,150.02
VDD_SW on TOP (solid shape): 19.62,22.33 19.62,21.78 19.62,20.6 18.85,19.83 18.85,19.79 18.85,19.78 18.82,19.65 18.85,19.52 18.85,19.51 18.85,19.43 18.7,19.28 18.7,19.26 18.64,19.2 18.64,18.22 18.58,18.16 18.08,18.16 18.02,18.22 18.02,19.36 18.44,19.78 18.44,20.24 18.44,20.24 18.44,21.36 18.35,21.44 17.91,21.44 17.51,21.85 17.51,22.22 17.79,22.5 19.45,22.5
VIN on BOTTOM (solid shape): 46.36,25.68 47.86,25.68 47.92,25.62 48.01,25.62 48.01,23.08 48.39,22.7 48.39,19.46 47.56,18.63 44.64,18.63 44.1,18.1 40.22,18.1 39.93,18.39 39.93,18.39 39.74,18.58 37.1,18.58 36.71,18.19 36.71,17.62 36.64,17.55 32.39,17.55 32.39,20.79 32.13,21.05 32.13,21.11 44.13,21.11 44.13,20.03 44.26,19.9 44.71,19.9 44.9,20.09 44.9,21.11 44.71,21.3 44.33,21.3 44.13,21.11 32.13,21.11 32.13,22 32.13,22.06 32.15,22.08 37.8,22.08 38.36,22.63 40.45,22.63 42.49,24.68 42.49,26.01 43.4,26.91 45.13,26.91
VIN on IN2 (solid shape): 45.71,27.41 45.71,25.77 46.32,25.16 47.58,25.16 48.01,24.73 48.01,19.52 47.16,18.67 45.42,18.67 45.02,19.06 45.02,21.11 44.76,21.38 44.26,21.38 44.07,21.19 44.07,20.72 42.38,19.03 37.25,19.03 36.82,19.46 36.82,21.1 42.31,26.58 42.31,27.5 42.56,27.75 45.37,27.75
+GVDD on BOTTOM (solid shape): 8.3,34.18 8.3,33.49 7.28,32.46 7.28,32.25 8.27,31.26 8.27,30.43 8.38,30.32 8.38,30.25 7.83,29.7 7.77,29.7 6.58,28.52 6.49,28.52 6.4,28.6 6.4,28.71 6.98,29.29 6.98,30.24 7.64,30.91 7.64,31.35 6.46,32.53 6.46,32.72 7.5,33.76 7.5,34.12 7.67,34.29 8.19,34.29
+HDMI_5V_OUT on BOTTOM (solid shape): 137.01,137.1 137.01,135.57 136.72,135.28 135,135.28 134.85,135.44 134.85,137.12 135.03,137.3 136.81,137.3
+HDMI_5V_OUT on IN6 (solid shape): outline of 198 points within 127,133.68 136.72,139.58
+INV_PWR_SRC on TOP (solid shape): 90.64,122.36 90.64,122.26 89.81,121.43 89.69,121.43 88.25,122.87 88.25,123.05 89.01,123.82 89.19,123.82
+INV_PWR_SRC on TOP (solid shape): 83.51,121.9 83.51,121.13 84.09,120.54 84.42,120.54 85.98,118.99 85.98,118.64 83.26,115.91 82.87,115.91 81.66,117.12 81.66,118.96 82.17,119.47 82.17,120.28 81.98,120.47 81.98,121.8 82.25,122.07 83.35,122.07
+LAN_IO on TOP (solid shape): 328.04,35.59 328.04,34.51 327.85,34.32 325.69,34.32 325.44,34.57 325.44,35.59 325.63,35.78 327.85,35.78
+LAN_IO on TOP (solid shape): 316.76,31.95 316.76,30.98 316.68,30.89 316.3,30.89 315.29,29.88 315.29,29.48 315.23,29.42 315.23,28.92 315.05,28.74 313.11,28.74 313.11,28.73 312.63,28.73 312.51,28.61 312.51,26.63 313.93,25.21 314.52,25.21 314.8,25.48 314.8,26.01 314.95,26.16 316.45,26.16 316.53,26.08 316.53,25.22 315.41,24.09 313.54,24.09 311.6,26.02 311.6,30.13 311.71,30.23 314.75,30.23 316.55,32.03 316.68,32.03
+LAN_IO on IN2 (solid shape): outline of 337 points within 313.54,28.45 326.8,35.57
+LAN_IO on IN4 (solid shape): 326.77,36.29 326.77,34.38 326.65,34.25 325.69,34.25 325.57,34.38 325.57,35.65 325.76,35.84 325.76,36.29 325.88,36.41 326.65,36.41
+LCDVDD on BOTTOM (solid shape): 85.84,123.24 85.84,122.84 84.68,121.69 84.16,121.69 83.71,121.23 83.49,121.23 82.9,121.82 82.9,122.04 84.68,123.82 85.26,123.82
+LCDVDD_CONN on TOP (solid shape): 94.68,127.52 94.69,127.52 95.2,127 96.02,126.19 96.1,126.19 96.33,125.96 96.33,125.44 97,124.77 97,124.3 96.61,123.9 96.43,123.9 95.2,125.14 95.2,125.85 93.98,127.07 93.98,127.21 94.43,127.66 94.54,127.66
+LCDVDD_CONN on BOTTOM (solid shape): 89.18,121.71 89.18,121.17 88.78,120.76 88.78,120.3 88.48,120 87.66,120 86.47,121.19 86.2,121.19 86.05,121.04 85.99,121.04 85.42,121.61 85.42,121.78 86.22,122.58 86.22,123.15 85.37,124 85.37,124.2 85.8,124.62 85.81,124.62 85.98,124.8 86.1,124.8
+LCDVDD_CONN on IN4 (solid shape): outline of 161 points within 87.38,120.05 97.03,127.29
+PAVDD on BOTTOM (solid shape): 8.22,24.35 8.49,24.35 8.86,23.99 8.86,22.64 9.11,22.39 10.52,22.39 10.65,22.26 10.65,20.58 10.51,20.44 9.51,20.44 9.42,20.54 9.42,21.04 9.25,21.2 8.27,21.2 8.07,21.4 8.07,24.13 7.47,24.73 7.47,24.84 7.55,24.92 7.66,24.92
+PCH_VCCCFUSE on TOP (solid shape): 237.2,37.3 237.2,36.6 237.62,36.18 237.62,34.91 238.25,34.28 238.25,33.57 237.99,33.3 236.91,33.3 236.48,33.73 236.48,34.1 236.31,34.28 235.78,34.28 235.69,34.37 235.69,37.3 235.75,37.37 237.13,37.37
+PCH_VCCCLK on TOP (solid shape): outline of 377 points within 217.7,41.24 222.13,49.82
+PCH_VCCCLK on BOTTOM (solid shape): 220.39,41.97 220.39,41.04 220.28,40.93 219.52,40.93 219.39,41.06 219.39,41.14 219.57,41.32 219.57,41.45 219.57,41.5 219.57,41.66 219.39,41.83 219.39,41.98 219.49,42.08 220.29,42.08
+PCH_VCCCLK on BOTTOM (solid shape): 221.86,42.65 221.98,42.65 222.08,42.55 222.08,42.5 222.36,42.23 222.36,41.85 222.13,41.62 222.13,41.42 221.65,40.94 221.62,40.91 221.48,40.91 221.38,41.01 221.38,41.18 221.45,41.25 221.48,41.29 221.55,41.5 221.48,41.71 221.46,41.73 221.37,41.82 221.37,41.95 221.57,42.14 221.57,42.52 221.7,42.65 221.79,42.65
+PCH_VCCCLK3_3 on TOP (solid shape): outline of 469 points within 223.61,38.76 233.56,42.76
+PCH_VCCCLK3_3 on BOTTOM (solid shape): 223.9,42.09 223.9,41.8 224.08,41.62 224.08,41.42 223.94,41.27 223.77,41.27 223.62,41.42 223.62,41.57 223.33,41.86 223.04,41.86 222.93,41.75 222.82,41.75 222.66,41.91 222.66,42.07 222.73,42.14 223.85,42.14
+PCH_VCCCLK3_3 on BOTTOM (solid shape): 225.97,41.39 226.06,41.37 226.14,41.39 226.54,41.39 226.64,41.29 226.64,41.02 226.23,40.61 226.23,39.61 226.14,39.51 225.41,39.51 225.41,39.52 225.38,39.52 225.3,39.6 225.3,41.01 225.66,41.37 225.68,41.39
+PCH_VPROC on BOTTOM (solid shape): 219.08,34.67 219.08,34.04 218.59,33.54 218.16,33.54 218.08,33.62 218.08,33.89 218.52,34.33 218.52,34.63 218.65,34.76 218.99,34.76
+RTC_CELL on IN1 (solid shape): 236.67,29.75 236.67,25.25 236.54,25.12 235.35,25.12 235.09,25.38 235.09,28.9 235.29,28.9 235.29,28.84 235.3,28.79 235.32,28.74 235.34,28.69 235.37,28.65 235.41,28.61 235.45,28.57 235.5,28.55 235.55,28.53 235.6,28.52 235.65,28.51 235.7,28.52 235.76,28.53 235.81,28.55 235.85,28.57 235.89,28.61 235.93,28.65 235.96,28.69 235.98,28.74 236,28.79 236.01,28.84 236.01,28.9 236,28.95 235.98,29 235.96,29.05 235.93,29.09 235.89,29.13 235.85,29.16 235.81,29.19 235.76,29.21 235.7,29.22 235.65,29.23 235.6,29.22 235.55,29.21 235.5,29.19 235.45,29.16 235.41,29.13 235.37,29.09 235.34,29.05 235.32,29 235.3,28.95 235.29,28.9 235.09,28.9 235.09,29.6 235.1,29.61 235.1,29.81 235.32,30.02 236.39,30.02
+SM_VREF on IN3 (solid shape): outline of 550 points within 124.84,78.53 129.57,81.31
+USB3_VCCA on BOTTOM (solid shape): 327.38,65.15 327.38,62.55 327.33,62.15 327.38,61.75 327.38,59.36 324.68,56.67 321.45,56.67 321.06,57.06 320.34,57.06 320.11,57.29 320.11,58.39 320.3,58.57 323.98,58.57 324.17,58.76 324.17,60.03 325.67,61.52 325.67,64.69 326.51,65.53 326.99,65.53
+USB3_VCCB on BOTTOM (solid shape): 327.37,46.9 327.37,46.24 326.89,45.76 326.89,44.79 324.87,42.76 320.87,42.76 320.44,43.19 320.44,43.73 320.19,43.99 319.45,43.99 319.34,44.1 319.34,44.61 319.5,44.76 322.17,44.76 322.71,44.22 323.28,44.22 323.41,44.35 323.41,45.05 323.66,45.31 324.04,45.31 326.04,47.3 326.97,47.3
+VCOMP_OUT on TOP (solid shape): outline of 311 points within 122.91,81.82 133.62,84.27
+VGA_CORE on TOP (solid shape): outline of 3993 points within 164.85,49.69 199.21,104.99
+VGA_CORE on BOTTOM (solid shape): outline of 9261 points within 160.59,50 197.29,106.17
+VGA_CORE on IN1 (solid shape): outline of 11194 points within 159.32,50.96 198.75,104.23
+VGA_CORE on IN2 (solid shape): outline of 6058 points within 160.81,78.05 188.73,106.2
+VGA_CORE on IN3 (solid shape): outline of 13926 points within 160.27,51.27 196.28,106.61
+VGA_CORE on IN4 (solid shape): outline of 12516 points within 160.49,51.33 196.28,106.61
+VGA_CORE on IN5 (solid shape): outline of 13419 points within 159.2,51.47 196.71,104.36
+VGA_CORE on IN6 (solid shape): outline of 4616 points within 160.72,77.66 188.73,104.29
+VGA_CORE on GND1: 162.21,50.21 159.05,53.37 157.39,53.37 156.02,54.74 156.02,64.65 153.1,67.57 153.1,77.52 153.71,78.13 156.88,78.13 160.47,81.73 169.17,81.73 170.4,82.95 170.4,94.06 167.14,97.32 162.53,97.32 160.75,99.1 160.75,103.54 161.52,104.32 163,104.32 165.05,102.28 173,102.28 173.46,101.81 173.46,96.44 174.26,95.65 188.54,95.65 188.9,95.29 188.9,78.19 188.36,77.65 178.7,77.65 175.22,74.17 175.22,69.23 177.23,67.22 177.23,65.84 179.26,63.8 179.26,62.53 182.48,59.31 194.94,59.31 197.91,56.35 197.91,51.77 196.34,50.21
+VGA_CORE on VCC: 193.08,51.72 192.26,52.54 163.18,52.54 158.05,57.66 158.05,91.24 162.35,95.53 188.68,95.53 188.79,95.43 188.79,78.92 189.25,78.45 187.16,76.35 185.76,76.35 184.87,75.47 179.22,75.47 178.44,74.68 178.44,65.54 179.35,64.63 196.73,64.63 196.73,52.43 196.01,51.72
+VGA_CORE on GND2: 168.52,51.48 164.77,55.23 164.77,95.84 160.87,99.74 160.87,104.72 162.22,106.07 164.3,106.07 164.53,105.84 164.53,103.44 166.7,101.27 169.82,101.27 173.03,98.07 173.03,96.99 174.19,95.82 187.5,95.82 188.79,94.54 188.79,93.27 188.95,93.1 188.95,79.16 187.67,77.88 186.02,77.88 185.89,77.75 183.98,77.75 182.54,76.31 182.54,64.53 189.76,57.3 195.26,57.3 196.19,56.37 196.19,51.97 195.69,51.48
ADPIN on BOTTOM (solid shape): 52.01,23.52 52.58,22.95 59.69,22.95 59.69,17.74 59.63,17.68 52.63,17.68 52.57,17.74 52.57,18.12 52.13,18.57 49.79,18.57 48.96,19.39 48.96,25.68 52.01,25.68
ADPIN on IN1 (solid shape): 53.15,22.19 53.15,20.16 52.64,19.65 48.96,19.65 48.77,19.84 48.77,22.25 49.15,22.63 52.71,22.63
ADPIN on IN2 (solid shape): 53.15,22.19 53.15,20.16 52.64,19.65 48.96,19.65 48.77,19.84 48.77,22.25 49.15,22.63 52.71,22.63
ADPIN on IN4 (solid shape): 53.15,22.19 53.15,20.16 52.64,19.65 48.96,19.65 48.77,19.84 48.77,22.25 49.15,22.63 52.71,22.63
AM2 on BOTTOM (solid shape): 9.46,26.81 9.47,26.81 9.7,26.58 9.7,26.25 9.55,26.1 8.9,26.1 8.53,26.47 8.53,26.59 9.06,27.12 9.15,27.12
AMGND on GND1, GND2, GND3: 3.09,15.65 0.26,18.49 0.26,34.44 8.72,34.44 10.35,32.82 10.35,19.31 9.46,18.42 9.46,17.02 8.09,15.65
AMGND on VCC: 3.09,15.65 1.27,17.47 1.27,34.44 8.72,34.44 10.35,32.82 10.35,19.31 9.46,18.42 9.46,17.02 8.09,15.65
B+ on TOP (solid shape): 74.04,61.37 74.04,60.8 75.76,59.08 75.76,56.16 75.38,55.78 71.88,55.78 70.55,57.11 70.55,61.5 71.31,62.26 73.15,62.26
B+ on TOP (solid shape): 198.4,46.79 198.4,46.51 197.51,45.62 196.53,45.62 196.41,45.75 196.41,46.38 196.6,46.57 196.94,46.57 197.64,47.27 197.92,47.27
B+ on TOP (solid shape): 246.53,36.61 246.53,36.07 246.88,35.71 247.27,35.71 247.46,35.52 247.46,35.14 247.08,34.76 246.51,34.76 246.51,34.76 246.2,34.76 245.46,35.5 245.46,36.67 245.54,36.75 246.39,36.75
B+ on TOP (solid shape): 65.51,19.99 65.51,17.76 65.51,17.76 65.51,16.62 65.53,16.59 65.53,16.47 65.34,16.28 63.63,16.28 63.25,16.66 63.25,18.25 62.49,19.01 62.49,20.22 62.55,20.28 65.22,20.28
B+ on TOP (solid shape): 53.66,28.98 53.66,22 52.71,21.05 48.58,21.05 48.01,21.62 48.01,22.51 49.6,22.51 49.79,22.7 49.79,23.2 49.6,23.4 48.01,23.4 48.01,26 47.66,26.35 47.66,26.86 46.99,27.52 46.99,30.19 47.56,30.76 51.88,30.76
B+ on TOP (solid shape): 149.02,51.31 154.36,51.31 156.44,49.23 156.44,46.92 156.34,46.81 155.05,46.81 153.82,45.57 153.82,44.76 153.47,44.41 150.09,44.41 149.37,43.69 149.09,43.69 149.09,44.24 148.6,44.24 148.6,43.69 147.32,43.69 147.23,43.78 147.23,44.93 147.1,45.06 146.72,45.44 144.58,45.44 144.07,45.94 144.07,49.57 143,50.64 143,53.06 143.42,53.48 146.84,53.48
B+ on TOP (solid shape): 87.9,117.02 87.9,112.64 81.66,106.4 81.66,105.31 80.77,104.42 80.08,104.42 77.28,101.63 75.57,101.63 74.23,102.96 74.23,103.98 75.32,105.07 75.34,105.07 78.31,106.45 80.05,109.22 80.06,109.23 80.64,109.82 81.41,109.82 84.66,113.07 84.66,113.43 86.17,114.94 86.17,115.76 85.81,116.12 85.81,116.47 85.22,117.06 85.22,117.16 86.33,118.26 86.66,118.26
B+ on BOTTOM (solid shape): 47.5,30.38 51.31,30.38 51.82,29.87 51.82,26.63 51.41,26.22 46.58,26.22 45.34,27.46 42.74,27.46 42.48,27.71 42.48,30.63 42.8,30.95 46.93,30.95
B+ on BOTTOM (solid shape): 247.48,35.52 247.48,31.94 247.89,31.52 248.29,31.52 248.41,31.4 248.41,30.22 248.22,30.03 246.92,30.03 246.83,30.13 246.83,30.93 246.17,31.58 246.17,35.48 246.37,35.68 247.32,35.68
B+ on BOTTOM (solid shape): 84.08,111.41 84.08,106.2 82.55,104.68 81.5,104.68 81.38,104.55 79.39,103.62 78.14,101.82 76.57,101.82 74.71,103.68 74.71,104.02 75.85,105.17 79.03,107.21 80.27,110.78 80.27,112.04 83.44,112.04
B+ on BOTTOM (solid shape): outline of 1555 points within 67.34,45.24 148.52,71.78
B+ on IN2 (solid shape): 197.55,46.76 197.55,45.75 197.36,45.56 196.66,45.56 196.41,45.81 196.41,46.95 196.47,47.02 197.3,47.02
B+ on IN2 (solid shape): 167.48,51.26 167.48,50.45 167.16,50.13 165.03,50.13 164.77,50.38 164.77,51.35 164.9,51.47 167.26,51.47
B+ on IN5 (solid shape): 149.07,49.15 149.07,48.45 148.81,48.19 147.04,48.19 146.81,48.41 146.81,49.02 146.9,49.11 147.81,49.11 148.18,49.48 148.74,49.48
B+ on IN5 (solid shape): 165.99,51.21 165.99,50.78 165.16,49.94 164.89,49.94 164.28,50.56 164.28,50.67 164.64,51.04 164.64,51.17 164.94,51.46 165.74,51.46
B+ on IN6 (solid shape): 83.89,109.56 83.89,106.58 79.98,102.67 79.92,102.62 79.84,102.53 78.49,101.18 76.39,101.18 75.5,102.07 75.5,104.36 76.52,105.37 79.05,107.23 80.23,110.14 83.31,110.14
B+ on IN6 (solid shape): outline of 1644 points within 46.93,26 75.88,65.88
B+_BIAS on TOP (solid shape): 68.26,15.71 68.26,13.81 67.95,13.49 64.91,13.49 64.9,13.5 64.1,13.5 63.96,13.63 63.96,14.43 63.82,14.57 63.82,14.59 63.79,14.59 63.63,14.76 63.12,14.76 62.93,14.95 62.93,15.52 63.18,15.77 63.19,15.78 65.55,15.78 65.64,15.86 68.11,15.86
B+_BIAS on BOTTOM (solid shape): 10.72,20.16 10.72,19.24 10.37,18.89 10.37,18.15 10.11,17.89 10.11,17.51 10.01,17.42 8.55,17.42 8.54,17.47 8.53,17.53 8.53,18.33 8.58,18.38 9.22,18.38 9.39,18.55 9.39,20.18 9.49,20.28 10.6,20.28
B+_BIAS on IN5 (solid shape): outline of 670 points within 51.9,8.55 67.76,14.52
B+_BIAS on IN5 (solid shape): outline of 1689 points within 8.6,9.32 34.13,20.29
BATDRV_CHG on TOP (solid shape): 46.8,37.43 46.8,37.24 46.67,37.11 45.85,37.11 45.66,37.3 44.52,37.3 44.45,37.37 44.45,37.49 44.52,37.56 46.67,37.56
BATDRV_CHG on BOTTOM (solid shape): 68.01,51.21 68.01,50.32 67.82,50.13 66.93,50.13 66.83,50.13 66.72,50.24 66.72,51.27 66.85,51.4 67.82,51.4
BATDRV_CHG on IN1 (solid shape): 67.25,51.14 67.25,50.32 67.12,50.19 65.34,50.19 65.09,50.45 65.09,51.14 65.28,51.34 67.06,51.34
BATDRV_CHG on IN1 (solid shape): 47.74,38.42 47.74,38.17 46.69,37.12 45.84,37.12 45.73,37.23 45.73,37.84 45.9,38 46.14,38 47.02,38.89 47.27,38.89
BATT+ on TOP (solid shape): 45.79,36.98 46.67,36.98 46.8,36.86 46.8,36.6 46.67,36.48 45.79,36.48 45.4,36.86 44.52,36.86 44.45,36.92 44.45,37.05 44.52,37.11 45.66,37.11
BATT+ on BOTTOM (solid shape): 71.82,51.28 71.82,50.32 71.06,49.56 71.06,44.49 71.39,44.17 72.48,44.17 72.8,43.84 72.8,38.01 72.58,37.8 68.9,37.8 68.59,38.1 68.59,43.44 68.18,43.86 65.92,43.86 65.72,44.05 65.72,45.58 67.1,45.58 67.45,45.94 67.1,46.29 65.72,46.29 65.72,47.27 66.36,47.91 68.39,47.91 68.65,48.16 68.65,51.25 68.85,51.46 71.64,51.46
BATT+ on IN1 (solid shape): 69.15,49.56 69.15,48.29 68.52,47.65 67.25,47.65 67.19,47.72 67.19,48.67 68.14,48.67 68.46,48.99 68.46,49.56 68.65,49.75 68.96,49.75
BATT+ on IN1 (solid shape): 48.83,37.84 48.83,37.6 48.1,36.88 47.9,36.88 47.19,36.17 45.83,36.17 45.75,36.26 45.75,36.82 45.91,36.98 46.78,36.98 48.12,38.33 48.34,38.33
BATT++ on TOP (solid shape): 70.42,40.27 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.68 64.26,37.81 65.66,37.81 65.79,37.94 65.79,40.25 66.05,40.52 70.17,40.52
BATT++ on BOTTOM (solid shape): 68.43,43.32 68.43,37.75 68.72,37.45 69.86,37.45 70.21,37.11 70.21,35.89 69.58,35.25 69.58,29.91 69.48,29.82 62.5,29.82 62.3,30.02 62.3,36.98 63.12,37.81 64.03,37.81 64.86,38.64 64.86,43.42 65.06,43.63 68.12,43.63
BATT++ on IN2 (solid shape): 70.42,40.29 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.68 64.26,37.81 65.22,37.81 65.72,38.32 65.72,40.6 65.98,40.86 69.85,40.86
BATT++ on IN3 (solid shape): 70.42,40.29 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.68 64.26,37.81 65.22,37.81 65.72,38.32 65.72,40.6 65.98,40.86 69.85,40.86
BATT++ on IN4 (solid shape): 70.42,40.41 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.68 64.26,37.81 65.47,37.81 65.72,38.06 65.72,40.6 66.04,40.92 69.92,40.92
BATT++ on IN5 (solid shape): 70.42,40.29 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.68 64.26,37.81 65.22,37.81 65.72,38.32 65.72,40.6 65.98,40.86 69.85,40.86
BATT++ on IN6 (solid shape): 70.42,40.16 70.42,35.65 69.47,34.7 64.71,34.7 64.14,35.27 64.14,37.37 64.58,37.81 65.47,37.81 65.79,38.13 65.79,40.6 66.04,40.86 69.73,40.86
BOOT1 on BOTTOM (solid shape): 137.07,124.56 137.07,124.48 136.48,123.88 136.48,122.73 136.33,122.58 135.31,121.57 135.2,121.57 134.52,122.25 134.52,122.32 134.95,122.76 135.24,122.76 136.18,123.7 136.18,123.88 136.93,124.63 137,124.63
BOOT2 on BOTTOM (solid shape): 134.07,128.66 134.54,128.66 135.95,127.24 135.95,127.15 135.87,127.06 135.78,127.06 134.7,128.14 133.55,128.14 133.46,128.05 133.05,128.05 132.54,128.56 132.54,128.62 133.18,129.26 133.47,129.26
BOOT3 on TOP (solid shape): 103.52,116.34 103.52,114.91 102.87,114.26 101.16,114.26 101.03,114.39 101.03,114.96 101.09,115.03 102.81,115.03 103.25,115.46 103.25,116.35 103.31,116.41 103.44,116.41
BSNL on BOTTOM (solid shape): 4.93,24.13 4.93,24.02 4.16,23.26 4.16,22.33 3.59,21.76 3.51,21.76 3.07,22.2 3.07,22.3 3.73,22.95 3.73,23.2 4.74,24.21 4.85,24.21
BSNR on BOTTOM (solid shape): 3.88,25.19 3.88,25.1 3.18,24.4 3.18,23.51 3.52,23.16 3.52,23.13 2.88,22.49 2.85,22.49 2.46,22.88 2.46,23.19 2.76,23.49 2.76,24.34 2.76,24.35 3.69,25.28 3.78,25.28
BSPL on BOTTOM (solid shape): 7.3,23.14 7.3,22.57 7.08,22.35 7.08,21.05 6.99,20.96 6.99,19.78 6.31,19.1 6.16,19.1 5.74,19.52 5.74,19.61 6.39,20.26 6.39,20.79 6.56,20.97 6.56,22.29 7.02,22.74 7.02,23.06 6.4,23.68 6.4,23.78 6.49,23.86 6.58,23.86
