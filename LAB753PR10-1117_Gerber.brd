# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS6: length 70.8
  IN1 w0.099: v3(124.82,76.72) 124.47,76.38 124.47,75.81 125.61,74.68 127.41,74.68 128.27,73.81 128.27,60.74 128.4,60.62 129.34,60.62 130.06,59.9 130.06,49.07 130.7,48.42 130.7,44.08 134.36,40.43 134.36,39.23 135.75,37.84 135.75,31.8 133.67,29.72 133.67,28.53 133.91,28.28 133.91,21.1 133.69,20.88 133.55,20.88 v3(133.29,20.62)
  BOTTOM w0.089: CPU1.AW6 124.48,76.38 v3(124.82,76.72)
  BOTTOM w0.127: JDIMM2.171 132.05,24.87 132.05,24.76 132.54,24.27 132.54,23.94 134,22.47 134,21.12 133.73,20.86 133.53,20.86 v3(133.29,20.62)
DDR_B_DQS7: length 76.8
  IN1 w0.089: 129.8,79.54 129.65,79.7 129.65,79.7 129.61,79.74 129.61,79.75 129.47,79.89 129.24,79.89 129.06,80.07 129.06,80.07 128.01,81.11 127.74,81.11 127.31,81.55 v3(127.17,81.55)
  IN1 w0.099: v3(139.02,20.62) 138.8,20.84 138.4,20.84 138.19,21.05 138.19,22.41 138.62,22.85 138.62,27.02 139.12,27.52 139.12,28.8 141.25,30.92 141.25,37.86 138.65,40.46 138.65,41.13 136.02,43.75 136.02,47.88 135.91,48 134.26,48 134.01,48.24 134.01,48.65 134.26,48.89 134.89,48.89 135.02,49.02 135.02,49.27 134.89,49.4 134.26,49.4 134.01,49.64 134.01,49.92 133.54,50.4 133.54,64.72 132.36,65.9 132.36,76.98 129.8,79.54
  BOTTOM w0.089: v3(127.17,81.55) 126.82,81.9 CPU1.AL3
  BOTTOM w0.127: JDIMM2.188 137.15,18.48 137.23,18.57 137.39,18.57 137.6,18.78 137.89,18.78 138.41,19.3 138.41,20.68 138.64,20.91 138.73,20.91 v3(139.02,20.62)
DDR_B_DQS#0: length 84.3
  IN1 w0.089: 90.97,85.84 90.98,85.85 90.98,85.86 91.52,86.4 93.03,86.4 v3(93.42,86.78)
  IN1 w0.099: 90.97,85.84 89.51,84.38 89.51,73.34 87.31,71.15 87.31,68.86 85.55,67.09 85.55,64.89 81.48,60.81 81.48,45.35 78.23,42.11 78.23,38.29 78.02,38.08 77.35,38.08 77.22,37.95 77.22,37.7 77.35,37.57 78.02,37.57 78.23,37.36 78.23,36.97 78.02,36.76 76.59,36.76 76.46,36.63 76.46,36.38 76.59,36.25 78.02,36.25 78.23,36.04 78.23,26.86 81.07,24.03 81.07,22.42 80.81,22.16 80.66,22.16 v3(80.45,21.96)
  BOTTOM w0.089: v3(93.42,86.78) 93.77,86.43 CPU1.AD52
  BOTTOM w0.127: v3(80.45,21.96) 80.65,22.15 81.08,22.15 81.23,22 81.23,18.9 81.47,18.66 81.47,18.57 81.35,18.45 JDIMM2.10
DDR_B_DQS#1: length 72.8
  IN1 w0.089: v3(97.57,77.56) 97.69,77.68 97.87,77.68 98.05,77.49 98.05,77.31 97.91,77.17 97.17,77.17 97.17,77.18 97.17,77.18 96.92,77.42 96.32,77.42 95.93,77.03 95.93,76.9 95.45,76.42 95.3,76.42 94.8,75.91 94.8,75.56 92.69,73.45 92.63,73.39 92.63,71.58 91.18,70.13 91.17,70.13 91.13,70.09 91.13,70.09 90.98,69.94
  IN1 w0.099: v3(86.17,22.72) 86.38,22.51 86.53,22.51 86.67,22.65 86.67,24.58 84.81,26.45 84.81,29.18 83.05,30.93 83.05,37.51 85.74,40.19 85.74,40.94 86.17,41.37 86.17,49.81 86.07,49.9 85.76,49.9 85.51,50.15 85.51,50.56 85.76,50.8 86.11,50.8 86.24,50.93 86.24,51.18 86.11,51.31 85.77,51.31 85.53,51.55 85.53,51.96 85.77,52.2 86.07,52.2 86.17,52.3 86.17,52.62 90.03,56.47 90.03,59.79 89.45,60.37 89.45,66.32 90.64,67.51 90.64,69.6 90.64,69.6 90.98,69.94
  BOTTOM w0.089: CPU1.AU46 98.24,77.63 98.24,77.5 98.12,77.38 97.75,77.38 v3(97.57,77.56)
  BOTTOM w0.127: JDIMM2.27 86.45,24.64 86.45,24.58 86.66,24.36 86.66,22.61 86.44,22.39 86.24,22.39 86.17,22.47 v3(86.17,22.72)
DDR_B_DQS#2: length 67.2
  IN1 w0.099: v3(97.13,72.6) 96.71,72.17 96.71,71.42 95.57,70.28 95.57,68.84 94.19,67.46 94.19,64.7 93.52,64.04 93.52,53.29 93.43,53.19 92.75,53.19 92.51,52.95 92.51,52.53 92.75,52.29 93.41,52.29 93.54,52.16 93.54,51.91 93.41,51.79 92.19,51.79 91.94,51.54 91.94,51.13 92.19,50.89 93.43,50.89 93.52,50.79 93.52,50.36 93.43,50.26 92.31,50.26 92.07,50.02 92.07,49.6 92.31,49.36 93.43,49.36 93.52,49.26 93.52,48.18 91.97,46.62 91.97,40.83 91.9,40.76 89.94,38.8 88.42,37.28 88.42,31.53 89.7,30.25 89.7,26.6 91.89,24.41 91.89,22.66 91.81,22.58 91.62,22.58 91.61,22.57 v3(91.47,22.72)
  BOTTOM w0.089: CPU1.BD48 96.84,72.88 v3(97.13,72.6)
  BOTTOM w0.127: JDIMM2.45 91.85,24.81 92.18,24.47 92.18,22.61 91.95,22.38 91.78,22.38 91.47,22.69 v3(91.47,22.72)
DDR_B_DQS#3: length 60.7
  IN1 w0.089: 99.28,69.94 99.28,69.95 99.28,69.96 99.28,70.26 99.96,70.93 99.96,72.82 v3(100.39,73.26)
  IN1 w0.099: v3(97.31,21.96) 97.08,22.18 96.95,22.18 96.71,22.42 96.71,25.16 95.18,26.69 95.18,30.54 94.53,31.19 94.53,36.86 97.17,39.5 97.17,59.52 97.68,60.03 97.68,65.86 99.28,67.45 99.28,69.94
  BOTTOM w0.089: CPU1.BD43 100.02,72.88 v3(100.39,73.26)
  BOTTOM w0.127: v3(97.31,21.96) 97.4,22.05 97.62,22.05 97.76,21.91 97.76,20.82 97.06,20.12 97.06,18.85 96.95,18.74 96.95,18.62 JDIMM2.62
DDR_B_DQS#4: length 65.2
  IN1 w0.089: v3(118.24,75.97) 118.24,76.16 118.37,76.29 118.54,76.29 118.67,76.16 118.67,75.78 118.56,75.67 118.56,70.76 118.89,70.42 118.89,70.42 119.04,70.27 119.28,70.03 119.28,70.03 119.37,69.94
  IN1 w0.099: v3(122.13,22.92) 122.13,22.7 122.31,22.53 122.41,22.53 122.54,22.65 122.54,25.64 122.82,25.92 122.82,26.06 122.54,26.34 122.54,26.64 122.87,26.97 123.17,26.97 123.45,26.69 123.59,26.69 124.46,27.56 124.46,27.76 123.78,28.44 123.78,31.31 124.34,31.86 124.34,38.08 122.42,39.99 122.42,44.96 121.31,46.07 121.31,55.72 119.44,57.59 119.44,69.65 119.44,69.87 119.41,69.9 119.41,69.9 119.37,69.94
  BOTTOM w0.089: v3(118.24,75.97) 118.24,76.16 118.1,76.31 118.09,76.31 118.01,76.38 CPU1.AW16
  BOTTOM w0.127: v3(122.13,22.92) 122.13,22.67 122.22,22.58 122.42,22.58 122.57,22.73 122.57,23.84 122.31,24.1 122.12,24.1 121.68,24.54 121.41,24.54 121.25,24.7 JDIMM2.135
DDR_B_DQS#5: length 69.6
  IN1 w0.089: 123.37,69.94 123.37,69.95 123.37,69.96 123.37,70.02 123.36,70.02 123.36,70.28 122.86,70.78 122.86,74.34 122.52,74.68 121.92,74.68 121.56,75.04 121.56,76.3 121.65,76.39 121.65,76.47 v3(121.96,76.78)
  IN1 w0.099: 123.37,69.94 123.37,58.92 125.8,56.49 125.8,55.61 125.94,55.47 126.19,55.47 126.44,55.23 126.44,54.65 126.22,54.44 125.9,54.44 125.78,54.31 125.78,54.06 125.9,53.94 126.22,53.94 126.44,53.72 126.44,53.25 126.22,53.04 125.9,53.04 125.78,52.91 125.78,52.66 125.9,52.53 126.22,52.53 126.44,52.32 126.44,46.22 127.1,45.56 127.1,40.58 129.97,37.71 129.97,31.34 129.37,30.74 129.02,30.74 128.47,30.19 128.47,20.73 128.06,20.33 127.45,20.33 v3(127.29,20.17)
  BOTTOM w0.089: CPU1.AW10 121.58,76.53 121.82,76.78 v3(121.96,76.78)
  BOTTOM w0.127: JDIMM2.152 126.35,18.55 126.49,18.7 126.71,18.7 127.01,19 127.26,19 127.3,19.04 127.53,19.04 127.86,19.38 127.86,20.38 127.7,20.54 127.58,20.54 127.29,20.26 v3(127.29,20.17)
DDR_B_DQS#6: length 70.7
  IN1 w0.099: v3(123.88,76.77) 124.15,76.77 124.28,76.64 124.28,75.73 125.53,74.48 127.33,74.48 128.08,73.73 128.08,60.66 128.32,60.42 129.26,60.42 129.86,59.82 129.86,48.99 130.51,48.34 130.51,44 134.16,40.35 134.16,39.15 135.55,37.76 135.55,31.88 133.47,29.8 133.47,28.45 133.72,28.2 133.72,21.18 133.61,21.07 133.45,21.07 133.29,21.24 v3(133.29,21.38)
  BOTTOM w0.089: v3(123.88,76.77) 123.5,76.38 CPU1.AW8
  BOTTOM w0.127: v3(133.29,21.38) 133.29,21.24 133.44,21.09 133.64,21.09 133.73,21.18 133.73,22.36 132.27,23.83 132.27,24.16 131.84,24.59 131.68,24.59 131.45,24.82 131.45,24.92 JDIMM2.169
DDR_B_DQS#7: length 76.8
  IN1 w0.089: 129.8,79.82 129.54,80.07 129.31,80.07 129.24,80.15 129.24,80.15 128.09,81.3 128.09,81.3 127.87,81.51 v3(127.87,81.55)
  IN1 w0.099: 129.8,79.82 132.55,77.06 132.55,65.98 133.74,64.8 133.74,50.48 134.21,50 134.21,49.72 134.34,49.59 134.97,49.59 135.21,49.35 135.21,48.94 134.97,48.7 134.34,48.7 134.21,48.57 134.21,48.32 134.34,48.19 135.99,48.19 136.22,47.96 136.22,43.83 138.84,41.21 138.84,40.54 141.44,37.94 141.44,30.84 139.32,28.72 139.32,27.44 138.82,26.94 138.82,22.77 138.38,22.33 138.38,21.13 138.48,21.04 138.68,21.04 v3(139.02,21.38)
  BOTTOM w0.089: CPU1.AL2 127.52,81.9 v3(127.87,81.55)
  BOTTOM w0.127: JDIMM2.186 136.55,18.59 136.73,18.77 137.06,18.77 137.12,18.84 137.28,18.84 137.49,19.05 137.78,19.05 138.14,19.41 138.14,20.79 138.53,21.17 138.82,21.17 v3(139.02,21.38)
DDR_B_MA0: length 62.3
  IN1 w0.089: 108.62,68.1 108.62,68.91 108.48,69.05 108.48,74.74 108.32,74.91 107.84,74.91 107.73,75.02 107.73,75.18 v3(107.9,75.35)
  IN1 w0.155: v3(109.88,22.76) 109.88,22.91 109.42,23.37 109.42,26.74 108.71,27.45 108.71,37.74 108.05,38.4 108.05,47.38 108.21,47.53 108.47,47.53 108.62,47.69 108.62,48 108.47,48.15 108.21,48.15 108.05,48.31 108.05,48.62 108.21,48.77 108.47,48.77 108.62,48.93 108.62,49.24 108.47,49.39 108.21,49.39 108.05,49.55 108.05,49.85 108.21,50.01 108.47,50.01 108.62,50.16 108.62,68.1
  BOTTOM w0.089: CPU1.BA30 108.05,75.35 v3(107.9,75.35)
  BOTTOM w0.206: JDIMM2.98 110.15,18.67 110.49,19.01 110.49,22.15 v3(109.88,22.76)
DDR_B_MA1: length 65.1
  IN1 w0.089: 109.09,68.1 109.09,69.03 108.7,69.42 108.7,74.84 108.27,75.28 108.27,76.61 108.14,76.73 v3(107.95,76.73)
  IN1 w0.155: v3(109.88,24.28) 110.17,24.28 110.3,24.41 110.3,24.96 110.17,25.09 110.01,25.09 109.88,25.22 109.88,25.58 110.01,25.71 110.17,25.71 110.3,25.84 110.3,26.2 110.17,26.33 110.01,26.33 109.88,26.46 109.88,26.82 110.01,26.95 110.15,26.95 110.3,27.11 110.3,27.4 110.05,27.65 109.35,27.65 109.17,27.83 109.17,37.86 109.3,37.99 109.82,37.99 109.95,38.12 109.95,38.57 109.82,38.7 108.64,38.7 108.52,38.83 108.52,39.19 108.64,39.32 109.42,39.32 109.55,39.45 109.55,39.81 109.42,39.94 108.64,39.94 108.52,40.07 108.52,40.53 108.67,40.68 108.78,40.68 108.93,40.84 108.93,41.15 108.78,41.3 108.67,41.3 108.52,41.46 108.52,41.77 108.67,41.92 108.8,41.92 108.93,42.05 108.93,42.41 108.8,42.54 108.64,42.54 108.52,42.67 108.52,43.03 108.64,43.16 108.78,43.16 108.9,43.29 108.9,43.65 108.78,43.78 108.64,43.78 108.52,43.91 108.52,44.27 108.64,44.4 108.96,44.4 109.09,44.53 109.09,44.9 108.93,45.05 108.64,45.05 108.52,45.18 108.52,45.54 108.64,45.67 108.93,45.67 109.09,45.83 109.09,46.14 108.93,46.29 108.64,46.29 108.52,46.42 108.52,46.78 108.64,46.91 108.96,46.91 109.09,47.04 109.09,68.1
  BOTTOM w0.089: v3(107.95,76.73) 107.95,76.55 108.11,76.38 CPU1.AW30
  BOTTOM w0.206: JDIMM2.97 109.85,24.85 109.6,24.6 109.6,24.38 109.7,24.28 v3(109.88,24.28)
DDR_B_MA2: length 66.2
  IN1 w0.089: 108.16,68.1 108.16,74.11 107.89,74.38 107.7,74.38 107.51,74.58 107.51,75.73 v3(107.85,76.07)
  IN1 w0.155: v3(109.88,19.71) 109.42,20.18 109.42,22.72 108.95,23.18 108.95,26.54 108.24,27.26 108.24,37.55 107.59,38.2 107.59,50.29 107.74,50.44 108.03,50.44 108.16,50.57 108.16,50.93 108.03,51.06 107.71,51.06 107.59,51.19 107.59,51.55 107.71,51.68 108.03,51.68 108.16,51.81 108.16,52.17 108.03,52.3 107.71,52.3 107.59,52.43 107.59,52.79 107.71,52.92 108.03,52.92 108.16,53.05 108.16,53.41 108.03,53.54 107.71,53.54 107.59,53.67 107.59,54.03 107.71,54.16 108.03,54.16 108.16,54.29 108.16,54.65 108.03,54.78 107.71,54.78 107.59,54.91 107.59,55.27 107.71,55.4 108.03,55.4 108.16,55.53 108.16,55.86 108,56.02 107.74,56.02 107.59,56.17 107.59,56.48 107.74,56.64 108,56.64 108.16,56.79 108.16,57.13 108.03,57.26 107.74,57.26 107.59,57.41 107.59,57.72 107.74,57.88 108.03,57.88 108.16,58.01 108.16,68.1
  BOTTOM w0.089: CPU1.AY30 108.3,75.68 107.91,76.07 v3(107.85,76.07)
  BOTTOM w0.206: v3(109.88,19.71) 109.55,19.38 JDIMM2.96
DDR_B_MA3: length 65.8
  IN1 w0.089: 109.55,68.1 109.55,68.97 108.92,69.6 108.92,74.91 108.46,75.37 108.46,76.92 v3(107.95,77.43)
  IN1 w0.155: v3(109.88,21.24) 110.4,21.75 110.4,22.92 110.77,23.29 110.77,27.59 110.4,27.95 110.4,28.86 110.27,28.99 109.79,28.99 109.63,29.14 109.63,29.45 109.79,29.61 109.96,29.61 110.12,29.76 110.12,30.19 109.96,30.34 109.79,30.34 109.63,30.5 109.63,30.81 109.79,30.96 109.96,30.96 110.12,31.12 110.12,31.43 109.96,31.58 109.79,31.58 109.63,31.74 109.63,32.05 109.79,32.2 109.96,32.2 110.12,32.36 110.12,37.63 110.42,37.93 110.42,38.77 110.02,39.18 110.02,40 109.4,40.62 109.4,43.06 109.55,43.22 109.55,68.1
  BOTTOM w0.089: v3(107.95,77.43) 108.3,77.08 CPU1.AV30
  BOTTOM w0.206: JDIMM2.95 109.25,24.99 109.25,24.82 108.92,24.49 108.92,22.2 v3(109.88,21.24)
DDR_B_MA4: length 65.2
  IN1 w0.089: 107.23,68.1 107.23,68.52 107.08,68.67 107.08,71.15 106.52,71.71 106.52,74.63 106.68,74.79 106.68,75.41 106.9,75.63 107.12,75.63 107.37,75.88 107.37,76.3 v3(107.06,76.62)
  IN1 w0.155: v3(107.83,23.88) 107.83,26.35 107.31,26.87 107.31,31 107.16,31.16 106.78,31.16 106.66,31.29 106.66,31.65 106.78,31.78 107.16,31.78 107.31,31.93 107.31,32.24 107.16,32.4 106.78,32.4 106.66,32.53 106.66,58.47 106.81,58.62 107.1,58.62 107.23,58.75 107.23,59.11 107.1,59.24 106.81,59.24 106.66,59.39 106.66,59.7 106.81,59.86 107.1,59.86 107.23,59.99 107.23,60.35 107.1,60.48 106.81,60.48 106.66,60.63 106.66,60.94 106.81,61.1 107.1,61.1 107.23,61.23 107.23,61.59 107.1,61.72 106.81,61.72 106.66,61.87 106.66,63.88 107.23,64.45 107.23,68.1
  BOTTOM w0.089: v3(107.06,76.62) 107.13,76.62 107.36,76.38 CPU1.AW32
  BOTTOM w0.206: v3(107.83,23.88) 108.47,23.23 108.47,18.89 108.35,18.77 JDIMM2.92
DDR_B_MA5: length 64.4
  IN1 w0.089: 106.61,68.1 106.61,71.34 106.3,71.66 106.3,74.68 106.43,74.81 106.43,75.44 107.01,76.01 v3(107.01,76.03)
  IN1 w0.155: v3(107.83,22.35) 107.36,22.82 107.36,26.16 106.19,27.33 106.19,28.05 106.32,28.18 106.72,28.18 106.85,28.3 106.85,28.67 106.72,28.8 106.32,28.8 106.19,28.92 106.19,29.96 106.32,30.08 106.69,30.08 106.85,30.24 106.85,30.55 106.69,30.7 106.32,30.7 106.19,30.83 106.19,40.11 106.06,40.24 105.66,40.24 105.53,40.36 105.53,40.73 105.66,40.86 106.06,40.86 106.19,40.98 106.19,41.35 106.06,41.47 105.66,41.47 105.53,41.6 105.53,43.4 105.66,43.53 106.06,43.53 106.19,43.65 106.19,44.02 106.06,44.15 105.66,44.15 105.53,44.27 105.53,45.81 106.19,46.47 106.19,64.07 106.61,64.49 106.61,68.1
  BOTTOM w0.089: v3(107.01,76.03) 107.36,75.68 CPU1.AY32
  BOTTOM w0.206: JDIMM2.91 108.05,24.82 107.2,23.97 107.2,22.98 v3(107.83,22.35)
DDR_B_MA6: length 66.7
  IN1 w0.089: v3(108.84,78.11) 108.54,77.81 107.76,77.81 107.59,77.64 107.59,77.36 107.23,77 106.92,77 106.65,76.72 106.65,75.92 106.24,75.52 106.24,74.89 106.11,74.76 106.11,71.58 106.15,71.54 106.15,69.94
  IN1 w0.155: v3(107.83,19.3) 106.9,20.23 106.9,25.97 105.73,27.14 105.73,37.05 105.6,37.17 105.2,37.17 105.07,37.3 105.07,37.79 105.2,37.92 105.57,37.92 105.73,38.08 105.73,38.39 105.57,38.54 105.2,38.54 105.07,38.67 105.07,39.03 105.2,39.16 105.57,39.16 105.73,39.31 105.73,39.62 105.57,39.78 105.2,39.78 105.07,39.91 105.07,46 105.73,46.66 105.73,64.26 106.15,64.69 106.15,69.94
  BOTTOM w0.089: v3(108.84,78.11) 108.47,78.48 CPU1.AT30
  BOTTOM w0.206: v3(107.83,19.3) 107.75,19.23 JDIMM2.90
DDR_B_MA7: length 65.1
  IN1 w0.089: v3(107,77.55) 106.74,77.81 105.9,77.81 105.73,77.64 105.73,76 105.86,75.87 105.86,75.05 105.37,74.56 105.2,74.56 104.81,74.16 104.81,71.77 105.22,71.36 105.22,69.94
  IN1 w0.155: 105.22,69.94 105.22,65.07 104.8,64.65 104.8,47.05 103.68,45.93 103.68,41.18 103.97,40.89 103.97,30.39 104.8,29.56 104.8,26.52 105.65,25.66 v3(105.65,23.56)
  BOTTOM w0.089: v3(107,77.55) 107.01,77.55 CPU1.AV32
  BOTTOM w0.206: v3(105.65,23.56) 106.18,23.03 106.18,21.3 106.94,20.55 106.94,18.89 106.55,18.5 JDIMM2.86
DDR_B_MA8: length 64.9
  IN1 w0.089: 107.69,68.1 107.69,68.4 107.32,68.78 107.32,75 v3(107.06,75.26)
  IN1 w0.155: v3(107.83,20.83) 107.99,20.66 108.83,20.66 108.95,20.79 108.95,21.28 108.83,21.41 108.39,21.41 108.26,21.54 108.26,21.9 108.39,22.03 108.83,22.03 108.95,22.16 108.95,22.52 108.83,22.65 108.55,22.65 108.42,22.78 108.42,26.42 107.78,27.06 107.78,37.35 107.12,38.01 107.12,57.92 107.69,58.49 107.69,61.84 107.12,62.41 107.12,63.68 107.69,64.26 107.69,68.1
  BOTTOM w0.089: CPU1.BA32 107.33,74.98 v3(107.06,75.26)
  BOTTOM w0.206: v3(107.83,20.83) 106.76,21.89 106.76,24.25 107.45,24.94 JDIMM2.89
DDR_B_MA9: length 66.1
  IN1 w0.089: v3(107.01,78.13) 107.11,78.13 107.38,77.87 107.38,77.42 107.15,77.19 106.72,77.19 106.46,76.92 106.46,76 106.05,75.59 106.05,74.97 105.69,74.61 105.69,69.94
  IN1 w0.155: v3(105.65,22.04) 106.43,22.82 106.43,25.54 105.26,26.71 105.26,30.32 105.13,30.45 104.56,30.45 104.43,30.58 104.43,30.94 104.56,31.07 105.11,31.07 105.26,31.23 105.26,31.54 105.11,31.69 104.73,31.69 104.61,31.82 104.61,42.86 104.45,43.01 104.27,43.01 104.14,43.14 104.14,43.51 104.27,43.63 104.45,43.63 104.61,43.79 104.61,46.2 105.26,46.85 105.26,64.46 105.69,64.88 105.69,69.94
  BOTTOM w0.089: CPU1.AU32 107.36,77.78 v3(107.01,78.13)
  BOTTOM w0.206: v3(105.65,22.04) 105.16,22.53 105.16,23.74 105.74,24.32 106,24.32 106.25,24.57 JDIMM2.85
DDR_B_MA10: length 68.6
  IN1 w0.089: 112.46,68.1 112.46,68.62 112.35,68.73 112.35,76.67 113.14,77.45 v3(113.59,77.45)
  IN1 w0.155: v3(113.73,22.76) 113.08,22.76 112.95,22.89 112.95,24.62 113.08,24.75 114.26,24.75 114.38,24.88 114.38,25.24 114.26,25.37 113.6,25.37 113.47,25.5 113.47,25.86 113.6,25.99 114.26,25.99 114.38,26.12 114.38,29.11 114.57,29.3 114.57,43.12 114.44,43.25 113.58,43.25 113.46,43.37 113.46,43.74 113.58,43.87 114.44,43.87 114.57,43.99 114.57,44.36 114.44,44.49 113.58,44.49 113.46,44.61 113.46,44.98 113.58,45.11 114.44,45.11 114.57,45.23 114.57,45.62 114.44,45.75 114.16,45.75 114.03,45.87 114.03,46.43 113.72,46.75 112.67,46.75 112.46,46.95 112.46,68.1
  BOTTOM w0.089: v3(113.59,77.45) 113.25,77.78 CPU1.AU23
  BOTTOM w0.206: JDIMM2.107 112.85,23.64 v3(113.73,22.76)
DDR_B_MA11: length 63.7
  IN1 w0.089: v3(105.14,76.16) 105.14,75.91 105.46,75.58 105.46,75.24 105.19,74.97 104.88,74.97 104.29,74.37 104.29,69.94
  IN1 w0.155: 104.29,69.94 104.29,65.46 103.87,65.03 103.87,47.43 102.75,46.31 102.75,37.56 102.61,37.43 102.61,29.93 102.74,29.8 103.24,29.8 103.37,29.67 103.37,29.31 103.24,29.18 102.74,29.18 102.61,29.05 102.61,28.69 102.74,28.56 103.32,28.56 103.45,28.43 103.45,26.55 104.72,25.28 104.72,19.92 v3(105.65,18.99)
  BOTTOM w0.089: v3(105.14,76.16) 105.6,75.7 CPU1.AY35
  BOTTOM w0.206: v3(105.65,18.99) 105.95,18.69 105.95,18.6 JDIMM2.84
DDR_B_MA12: length 65.7
  IN1 w0.089: 104.76,69.94 104.76,71.55 104.62,71.69 104.62,74.43 104.93,74.75 105.29,74.75 105.67,75.13 105.67,75.79 105.54,75.92 105.54,76.41 v3(105.1,76.85)
  IN1 w0.155: v3(105.65,20.51) 105.18,20.98 105.18,25.47 104.33,26.32 104.33,29.36 103.5,30.19 103.5,40.7 103.21,40.99 103.21,46.12 104.33,47.24 104.33,64.84 104.76,65.27 104.76,69.94
  BOTTOM w0.089: CPU1.AW35 105.57,76.38 v3(105.1,76.85)
  BOTTOM w0.206: v3(105.65,20.51) 104.79,21.37 104.79,24.09 105.35,24.65 105.52,24.65 105.65,24.78 JDIMM2.83
DDR_B_MA13: length 68.1
  IN1 w0.089: v3(114.54,78.12) 114.95,77.72 114.95,76.67 114.92,76.64 114.92,75.25 114.53,74.87 114.53,72.29 114.24,71.99 114.24,71.22 114.33,71.13 114.33,68.81 114.77,68.37 114.92,68.37 115.01,68.28 115.01,68.1
  IN1 w0.155: v3(115.78,20.07) 117.48,21.77 117.48,28.75 118.18,29.45 118.18,41.82 116.89,43.11 116.89,49.59 115.01,51.47 115.01,68.1
  BOTTOM w0.089: CPU1.AU20 114.66,78.12 v3(114.54,78.12)
  BOTTOM w0.206: v3(115.78,20.07) 116.33,20.62 116.33,21.58 116.81,22.05 116.81,24.32 116.45,24.68 JDIMM2.119
DDR_B_MA14: length 64.8
  IN1 w0.089: 103.36,69.94 103.36,73.98 104.59,75.21 104.59,76.2 104.22,76.56 v3(104.22,76.72)
  IN1 w0.155: 103.36,69.94 103.36,65.84 102.94,65.42 102.94,49.06 102.81,48.93 101.94,48.93 101.82,48.8 101.82,48.44 101.94,48.31 102.81,48.31 102.94,48.18 102.94,47.82 102.81,47.69 101.94,47.69 101.82,47.56 101.82,37.95 101.68,37.81 101.68,26.99 103.59,25.07 v3(103.59,22.74)
  BOTTOM w0.089: v3(104.22,76.72) 104.56,76.38 CPU1.AW36
  BOTTOM w0.206: JDIMM2.80 104.75,18.91 104.21,19.46 104.21,22.13 v3(103.59,22.74)
DDR_B_MA15: length 62.5
  IN1 w0.089: 103.83,69.94 103.83,74.18 105.05,75.4 v3(105.1,75.4)
  IN1 w0.155: 103.83,69.94 103.83,65.65 103.4,65.23 103.4,47.62 102.28,46.5 102.28,37.76 102.15,37.62 102.15,28.22 102.27,28.09 102.86,28.09 102.99,27.97 102.99,27.6 102.86,27.47 102.47,27.47 102.34,27.35 102.34,26.98 102.47,26.85 102.86,26.85 102.99,26.73 102.99,26.35 104.25,25.09 104.25,20.35 v3(103.59,19.69)
  BOTTOM w0.089: v3(105.1,75.4) 105.51,74.98 CPU1.BA35
  BOTTOM w0.206: JDIMM2.78 104.15,18.56 103.59,19.12 v3(103.59,19.69)
DDR_B_RAS#: length 68.8
  IN1 w0.089: v3(112.64,77.46) 112.64,77.46 112.13,76.96 112.13,70.69 112.03,70.59 112.03,68.49 112,68.46 112,68.1
  IN1 w0.155: v3(113.73,22) 112.61,22 112.49,22.13 112.49,25.58 113.67,26.77 113.67,29.09 114.1,29.52 114.1,39.75 113.35,40.5 113.35,41.81 113.21,41.95 112.64,41.95 112.51,42.08 112.51,42.45 112.64,42.57 112.98,42.57 113.11,42.7 113.11,43.07 112.98,43.19 112.12,43.19 112,43.32 112,43.69 112.12,43.81 112.84,43.81 113,43.97 113,44.28 112.84,44.43 112.12,44.43 112,44.56 112,44.93 112.12,45.05 112.84,45.05 113,45.21 113,46.15 112.87,46.28 112.12,46.28 112,46.41 112,68.1
  BOTTOM w0.089: v3(112.64,77.46) 113.01,77.08 CPU1.AV23
  BOTTOM w0.206: JDIMM2.110 113.75,18.59 114.24,19.08 114.24,21.49 v3(113.73,22)
DDR_B_WE#: length 67.2
  IN1 w0.089: 114.02,68.1 114.02,68.38 113.79,68.61 113.54,68.61 113.02,69.13 113.02,74.06 113.88,74.92 113.88,76.49 v3(113.55,76.82)
  IN1 w0.155: v3(115.78,23.11) 116.43,23.11 116.55,23.23 116.55,29.97 116.68,30.1 116.68,42 115.96,42.72 115.96,47.24 115.83,47.37 115.07,47.37 114.94,47.5 114.94,47.86 115.07,47.99 115.83,47.99 115.96,48.12 115.96,48.48 115.83,48.61 114.15,48.61 114.02,48.74 114.02,68.1
  BOTTOM w0.089: v3(113.55,76.82) 113.12,76.38 CPU1.AW23
  BOTTOM w0.206: JDIMM2.113 114.65,24.57 115.22,23.99 115.22,23.5 114.68,22.96 114.68,21.55 114.82,21.42 115.2,21.42 115.32,21.53 115.32,22.66 v3(115.78,23.11)
DDR_CKE0_DIMMA: length 46
  IN6 w0.089: v3(105.25,72.57) 105.62,72.21 105.62,71.68 105.34,71.41 104.97,71.41
  IN6 w0.155: 104.97,71.41 104.81,71.41 102.33,68.92 102.33,58.67 102.2,58.54 100.95,58.54 100.82,58.42 100.82,58.08 100.98,57.92 101.55,57.92 101.68,57.8 101.68,57.43 101.55,57.3 100.98,57.3 100.82,57.15 100.82,38.89 101.14,38.57 101.14,36.28 v3(100.69,35.83)
  BOTTOM w0.089: v3(105.25,72.57) 105.64,72.18 CPU1.BE34
  BOTTOM w0.206: JDIMM1.73 102.64,37.78 v3(100.69,35.83)
DDR_CKE1_DIMMA: length 46.2
  IN6 w0.089: 102.68,69.94 104.58,71.83 v3(105.26,71.83)
  IN6 w0.155: v3(100.69,32.78) 100.23,33.24 100.23,58.57 101.86,60.21 101.86,69.12 102.68,69.94
  BOTTOM w0.089: CPU1.BF34 105.61,71.48 v3(105.26,71.83)
  BOTTOM w0.206: JDIMM1.74 102.94,31.49 102.83,31.61 102.8,31.61 102.55,31.86 102.55,32.25 102.02,32.78 v3(100.69,32.78)
DDR_CKE2_DIMMB: length 61.3
  IN1 w0.089: v3(104.19,77.43) 103.84,77.09 103.84,75.47 102.74,74.37 102.74,70.66 102.34,70.25 102.34,69.94
  IN1 w0.155: v3(101.6,22.74) 102.03,23.18 102.03,25.16 100.26,26.94 100.26,38.31 100.76,38.81 100.76,50.75 101.91,51.91 101.91,65.85 102.34,66.27 102.34,69.94
  BOTTOM w0.089: v3(104.19,77.43) 104.54,77.78 CPU1.AU36
  BOTTOM w0.206: v3(101.6,22.74) 102.65,23.79 JDIMM2.73
DDR_CKE3_DIMMB: length 64.9
  IN1 w0.089: v3(105.14,78.05) 104.3,78.05 103.65,77.41 103.65,76.51 102.42,75.27 102.42,70.76 101.87,70.21 101.87,69.94
  IN1 w0.155: v3(101.6,21.22) 101.13,21.68 101.13,25.4 99.79,26.74 99.79,38.54 100.29,39.04 100.29,50.95 101.45,52.1 101.45,66.04 101.87,66.46 101.87,69.94
  BOTTOM w0.089: v3(105.14,78.05) 105.41,77.78 CPU1.AU35
  BOTTOM w0.206: JDIMM2.74 102.95,19.14 102.16,20.65 v3(101.6,21.22)
DDR_CS0_DIMMA#: length 48.5
  IN6 w0.089: 117.56,69.94 117.56,70.75 117.84,71.02 117.84,71.47 v3(117.47,71.83)
  IN6 w0.155: v3(117.75,34.36) 118.37,34.36 118.69,34.68 118.69,39.42 119.04,39.78 119.04,61.51 118.92,61.64 117.69,61.64 117.56,61.77 117.56,62.13 117.69,62.26 118.92,62.26 119.04,62.39 119.04,62.75 118.92,62.88 117.69,62.88 117.56,63.01 117.56,69.94
  BOTTOM w0.089: CPU1.BE16 117.82,72.18 v3(117.47,71.83)
  BOTTOM w0.206: JDIMM1.114 114.94,31.72 115.7,32.48 116.23,32.48 116.77,33.02 116.77,33.39 v3(117.75,34.36)
DDR_CS1_DIMMA#: length 48.2
  IN6 w0.089: v3(116.69,73.92) 116.33,73.92 116.14,73.73 116.14,70.25 116.45,69.94
  IN6 w0.155: v3(117.68,40.94) 117.77,40.86 117.99,40.86 118.11,40.98 118.11,54.34 117.99,54.47 117.23,54.47 117.11,54.6 117.11,54.96 117.23,55.09 117.99,55.09 118.11,55.22 118.11,55.63 117.99,55.75 116.76,55.75 116.63,55.88 116.63,56.24 116.76,56.37 117.99,56.37 118.11,56.5 118.11,56.86 117.99,56.99 116.76,56.99 116.63,57.12 116.63,57.48 116.76,57.61 117.99,57.61 118.11,57.74 118.11,58.1 117.99,58.23 116.76,58.23 116.63,58.36 116.63,58.72 116.76,58.85 117.99,58.85 118.11,58.98 118.11,59.34 117.99,59.47 116.76,59.47 116.63,59.6 116.63,69.76 116.45,69.94
  BOTTOM w0.089: CPU1.BC17 117.02,73.58 v3(116.69,73.92)
  BOTTOM w0.206: JDIMM1.121 117.04,40.48 117.51,40.94 v3(117.68,40.94)
DDR_CS2_DIMMB#: length 63.4
  IN1 w0.089: v3(115.49,74.77) 115.06,74.77 114.94,74.65 114.94,74.45 115.06,74.32 115.36,74.32 115.45,74.23 115.45,71.67 115.41,71.63 115.41,69.09 115.57,68.92
  IN1 w0.155: v3(118.08,22.38) 118.39,22.38 118.51,22.51 118.51,23.58 118.36,23.73 118.17,23.73 118.04,23.86 118.04,24.23 118.17,24.35 118.36,24.35 118.51,24.51 118.51,24.82 118.36,24.97 118.17,24.97 118.04,25.1 118.04,25.47 118.17,25.59 118.36,25.59 118.51,25.75 118.51,27.76 119.2,28.45 119.2,42.25 117.92,43.54 117.92,54.49 116.04,56.37 116.04,68.46 115.57,68.92
  BOTTOM w0.089: v3(115.49,74.77) 115.27,74.98 CPU1.BA20
  BOTTOM w0.206: JDIMM2.114 114.95,18.6 115.69,19.34 115.83,19.34 117.14,20.64 117.14,20.79 117.39,21.45 117.39,21.69 v3(118.08,22.38)
DDR_CS3_DIMMB#: length 66.1
  IN1 w0.089: 115.57,68.27 115.57,68.51 115.46,68.62 114.81,68.62 114.57,68.86 114.57,72.05 114.72,72.2 114.72,74.79 115.11,75.17 115.11,76.14 115.38,76.41 116.12,76.41 v3(116.4,76.13)
  IN1 w0.155: 115.57,68.27 115.57,68.26 115.57,55.73 115.7,55.6 116.15,55.6 116.27,55.48 116.27,55.11 116.15,54.98 115.7,54.98 115.57,54.86 115.57,54.49 115.7,54.36 117.32,54.36 117.45,54.24 117.45,53.87 117.32,53.75 115.7,53.75 115.57,53.62 115.57,53.25 115.7,53.13 117.32,53.13 117.45,53 117.45,52.63 117.32,52.51 115.7,52.51 115.57,52.38 115.57,52.02 115.7,51.89 117.3,51.89 117.45,51.74 117.45,51.43 117.3,51.27 116.62,51.27 116.5,51.14 116.5,50.78 116.62,50.65 117.3,50.65 117.45,50.5 117.45,43.34 118.74,42.05 118.74,28.64 v3(118.04,27.94)
  BOTTOM w0.089: CPU1.AY19 115.95,75.68 v3(116.4,76.13)
  BOTTOM w0.206: JDIMM2.121 117.05,26.95 v3(118.04,27.94)
DDR_HVREF_RST_PCH: length 9.8
  TOP w0.127: RH100.2 225.94,24.93 225.94,25.65 v3(226.28,25.99)
  IN1 w0.099: v3(225.82,31.92) 225.52,31.61 225.52,29.72 225.84,29.39 226.34,29.39 226.91,28.82 226.91,26.62 v3(226.28,25.99)
  BOTTOM w0.089: v3(225.82,31.92) 225.56,31.92 UH1.N8
DEMA0: length 8.3
  BOTTOM w0.127: UM8.49 162.33,132.87 162.45,132.98 164.51,132.98 164.95,132.54 165.91,132.54 RM83.2 RM88.2 RM68.2 168.04,134.56 v1(168.04,134.89)
DEMA1: length 8.7
  BOTTOM w0.127: RM67.2 v1(167.38,131.8) RM65.2 166.25,130.69 RM63.2 165.34,132.11 165.17,132.29 164.85,132.29 164.4,132.73 162.64,132.73 162.28,132.37 UM8.50
DEMB0: length 4.4
  TOP w0.127: v3(162.45,130.06) 162.93,130.55 RM75.2 RM79.2 162.5,131.6 v1(161.91,131.02)
  BOTTOM w0.127: UM8.53 162.18,130.87 162.45,130.6 v3(162.45,130.06)
DEMB1: length 4.2
  TOP w0.127: v1(160.02,130.46) 160.25,130.23 RM86.2 161.34,129.87 v3(161.65,129.87) 162,129.87 RM62.2
  BOTTOM w0.127: UM8.54 161.3,130.37 161.23,130.29 161.23,130.1 161.46,129.87 v3(161.65,129.87)
DEPOP#_EC: length 288.5
  TOP w0.127: JIO.20 12.04,23.53 v3(12.27,23.29) ; UE6.2 239.2,42.85 v1(239.71,42.34) 240.13,41.91 240.48,41.91 240.69,41.7 v3(240.69,41.47)
  IN5 w0.099: v3(12.27,23.29) 10.35,23.29 6.33,19.27 6.33,16.21 4.32,14.2 v3(4.08,14.2)
  IN6 w0.099: v3(12.27,23.29) 12.27,22.92 16.77,18.42 21.27,18.42 23.61,16.07 25.43,16.07 26.5,15.01 26.5,14.23 26.92,13.81 27.77,13.81 31.07,10.51 34.47,10.51 36.16,8.82 56.69,8.82 57.29,9.43 58.69,9.43 59.29,8.83 61.69,8.83 64.61,11.75 69.39,11.75 72.23,8.91 72.23,8.89 72.25,8.86 72.29,8.86 72.31,8.84 144.87,8.84 146.25,10.23 149.13,10.23 153.52,5.83 193.25,5.83 198.24,10.82 201.59,10.82 202.83,9.58 203.95,9.58 204.66,8.86 222.34,8.86 223.89,10.41 229.25,10.41 237.4,18.56 237.4,19.93 238.18,20.71 238.18,23.72 241.22,26.76 241.22,28.94 242.71,30.43 242.71,31.85 242.41,32.14 242.41,39.6 240.69,41.32 v3(240.69,41.47)
  BOTTOM w0.254: v3(4.08,14.2) 4.51,13.77 RA44.1
DEW1:
  vias: v1(158.28,13.62)
DEW2: length 4.6
  TOP w0.127: v1(165.69,20.96) 165.51,20.78 RN17.1 RN6.1 162.55,19.51 UN1.6
DGPU_HOLD_RST#: length 160.5
  TOP w0.102: v2(161.95,76.13) 162.12,75.96 v3(162.82,75.96)
  TOP w0.127: v3(231.43,53.91) 232,53.34 233.12,53.34 234.56,51.9 241.96,51.9 243.17,50.69 243.17,47.55 243.65,47.07 RE98.1
  IN3 w0.091: v3(204.5,53.89) 205.72,55.11 214.16,55.11 214.86,55.8 219.48,55.8 220.05,55.23 229.65,55.23 230.97,53.91 v3(231.43,53.91)
  IN4 w0.089: 209.04,37.36 213.14,37.36 213.98,38.2 217.27,38.2 218.09,37.39 224.68,37.39 225.16,36.91 225.16,36.58 225.53,36.21 227.94,36.21 228.14,36.41 228.14,36.9 228.41,37.16 229.34,37.16 229.81,36.68 229.81,34.58 230.81,33.58 v3(230.82,33.58)
  IN4 w0.091: v3(204.5,53.89) 204.5,49.22 202.15,46.87 202.15,38.16 203.38,36.93 208.36,36.93 208.78,37.36 209.04,37.36
  IN6 w0.089: v3(162.82,75.96) 163.79,74.98 163.79,73.66 166.24,71.22 169.08,71.22 172.38,67.92 176.12,67.92 177.69,66.34
  IN6 w0.099: v3(204.5,53.89) 204.06,53.45 202.57,53.45 199.37,56.64 198.34,56.64 195.59,59.39 188.71,59.39 186.38,61.72 183.37,61.72 180.93,64.16 180.24,64.16 179.63,64.77 179.63,65.33 179.28,65.68 178.35,65.68 177.69,66.34
  BOTTOM w0.089: UH1.C12 229.92,33.92 230.25,33.58 v3(230.82,33.58)
  BOTTOM w0.127: UV14.1 155.31,75.6 RV58.2 156.68,76.98 RV530.2 156.85,77.15 157.85,77.15 159.04,75.96 v3(162.82,75.96)
DGPU_PEX_RST#: length 18.3
  BOTTOM w0.127: RV59.1 154.92,69.1 153.82,69.1 153.48,68.76 RV39.2 153.57,67.07 RV40.1 155.2,66.54 154.94,66.28 154.94,64.05 154.19,63.3 v2(154.19,61.84) 154.19,60.17 DV8.1 152.73,57.89 152.97,57.65 154.98,57.65 RV208.2
DGPU_PEX_RST#_R: length 25.2
  TOP w0.127: v2(163.78,79.57) 164.12,79.91 v3(164.43,79.91)
  IN4 w0.122: v3(162.72,67.16) 163.22,67.67 163.22,69.42 163.22,74.45 164.02,75.25 164.02,79.5 v3(164.43,79.91)
  BOTTOM w0.1: UV1.BE20 164.43,82.35 v3(164.43,79.91)
  BOTTOM w0.127: v3(162.72,67.16) 158.19,67.16 158.07,67.29 155.89,67.29 RV40.2
DGPU_PRSNT#: length 9.8
  TOP w0.089: 212.74,31.82 213.28,31.82 213.37,31.9 215.29,31.9 v3(215.34,31.85)
  TOP w0.102: RH134.2 211.37,32.2 v1(212.36,32.2) 212.74,31.82
  TOP w0.127: RH134.2 210.03,33.53 209.27,33.53 209.22,33.58 208.82,33.58 208.36,34.04 208.36,34.57 RH135.2
  BOTTOM w0.089: UH1.AT7 215.59,31.61 v3(215.34,31.85)
DGPU_PWR_EN: length 125.3
  TOP w0.127: v3(175.01,28.79) 174.6,28.79 v2(174.3,29.1)
  TOP w0.203: RV538.2 152.93,56.54 UV11.3
  TOP w0.254: PR615.2 175.14,28.79 v3(175.01,28.79) ; RV538.2 RH44.2 153.33,55.39 154.08,55.39 v3(154.6,54.87)
  IN1 w0.254: v3(154.6,54.87) 154.6,54.07 155.28,53.38 156.39,53.38 160.97,48.81 165.23,48.81 167.49,46.55 167.49,35.65 168.38,34.76 169.33,34.76 171.01,33.08 172.33,33.08 174.5,30.91 174.5,29.3 v3(175.01,28.79) 175.53,28.79 177.18,30.44 185.37,30.44 v3(186.2,31.27)
  IN3 w0.254: v3(231.31,33.91) 231.59,33.63 231.59,25.49 229.36,23.27 228.32,23.27 227.45,24.14 216.33,24.14 214.33,26.15 208.31,26.15 v3(207.51,26.95)
  IN4 w0.254: v3(186.2,31.27) 186.48,30.99 186.48,28.56 185.59,27.68 185.59,25.12 185.84,24.87 188.02,24.87 188.31,24.59 188.76,24.59 189.97,25.8 192.55,25.8 196.94,30.19 201.61,30.19 204.85,26.95 v3(207.51,26.95)
  BOTTOM w0.127: UH1.A12 230.48,34.02 231.2,34.02 v3(231.31,33.91)
DGPU_PWROK: length 25.1
  TOP w0.127: UE6.19 236.66,46.77 236.11,47.32 v3(236.11,48.14)
  IN6 w0.099: v3(236.11,48.14) 235.32,47.35 235.32,44.2 235.75,43.77 235.75,41.16 235.36,40.77 235.36,38.06 234.47,37.17 v3(234.47,34.72)
  BOTTOM w0.089: 231.12,36.1 230.52,36.1 230.5,36.07 230.25,36.07 230.06,36.26 229.8,36.26 229.47,35.94 UH1.C16
  BOTTOM w0.102: 231.12,36.1 231.43,35.78 231.43,35.45 231.52,35.36 231.53,35.36 231.55,35.34 231.68,35.34 231.69,35.33 231.92,35.33 231.94,35.32 231.96,35.32 232.15,35.12
  BOTTOM w0.127: 232.15,35.12 232.56,34.71 v1(232.75,34.71) 233.28,34.71 234.15,33.83 RH151.2 234.56,34.63 v3(234.47,34.72)
DH_1.35V: length 8.9
  IN2 w1.016: 149.04,39.21 149.04,34.95 151.64,32.35
  BOTTOM w0.127: v1(152.54,32.3) 152.01,31.76 v3(152.01,31.52)
  vias: v3(148.66,40.29) v3(149.29,40.29) v3(151.39,31.52)
DH_CHG: length 15.3
  TOP w0.127: PQ704.4 57.98,40.25 v1(57.81,40.41)
  IN4 w1.016: 55.95,39.08 54.55,39.08 53.12,40.51 48.55,40.51 47.12,41.94 44.77,41.94 44.26,41.43 43.56,41.43
  vias: v3(42.48,40.96) v3(42.47,40.38) v3(57.28,39.27) v3(57.28,38.64)
DIR_SEL: length 4.4
  TOP w0.203: UA6.6 25.68,6.14 25.21,5.67 23.97,5.67 v1(23.86,5.77) 22.97,6.66 RA101.2
DISP_CEC: length 3.4
  BOTTOM w0.127: JDP1.6 141,138.93 140.82,138.75 v1(140.82,137.91) 140.82,137.15 RV18.2
DISP_CLK_AUXP_CONN: length 23.1
  IN6 w0.099: v3(152.52,142.17) 152.37,142.03 152.37,141.27 148.82,137.72 145.45,137.72 144.31,138.86 144.31,141.95 144.21,142.05 144,142.05 143.83,141.88 v3(143.83,141.85)
  BOTTOM w0.127: RV16.1 144.19,137.21 144.19,137.54 144.16,137.57 144.16,138.16 144.19,138.19 144.19,138.79 144,138.97 JDP1.16 144,141.02 144.25,141.26 144.25,141.96 144.18,142.03 143.98,142.03 143.83,141.88 v3(143.83,141.85) ; UV3.4 153.17,141.24 152.91,141.51 152.47,141.51 152.34,141.63 152.34,141.99 v3(152.52,142.17)
DISP_DAT_AUXN_CONN: length 23.2
  IN6 w0.099: v3(151.93,142.17) 152.15,141.95 152.15,141.37 148.73,137.95 145.55,137.95 144.54,138.96 144.54,142.04 144.3,142.28 144.01,142.28 v3(143.83,142.46)
  BOTTOM w0.127: v3(151.93,142.17) 152.08,142.02 152.08,141.57 151.98,141.46 151.47,141.46 151.22,141.21 UV3.7 ; RV15.1 144.41,137.28 144.41,137.89 v4(144.41,137.89) 144.41,138.82 144.6,139.01 JDP1.18 144.6,141.14 144.5,141.24 144.5,142.06 144.28,142.29 144.01,142.29 v3(143.83,142.46)
DISPOFF#: length 7.8
  TOP w0.127: JEDP1.37 91.06,122.43 91.06,120.82 90.21,119.97 RV1.1 90.21,118.97 DV1.1 88.88,117.63 v1(88.88,116.27)
DL_1.35V: length 17.2
  IN2 w1.016: 150.05,41.3 147.77,41.3 147,40.54 147,33.11 150.05,30.06 151.45,30.06
  BOTTOM w0.127: v3(153.1,30.25) v1(153.61,30.76)
  vias: v3(150.37,40.6) v3(150.37,39.97) v3(152.47,30.25)
DL_CHG: length 12.8
  IN4 w1.016: 45.47,40.1 46.1,40.1 47.37,38.83 52.39,38.83 55.06,36.16 55.88,36.16
  BOTTOM w0.127: v3(44.52,40.35) 44.52,40.4 v1(44.02,40.9)
  vias: v3(43.88,40.35) v3(56.71,36.48) v3(56.71,35.84)
DMI_CRX_PTX_N0: length 114.3
  IN6 w0.089: v3(129.27,88.81) 129.33,88.81 129.51,88.62 129.51,88.4 129.8,88.12
  IN6 w0.099: 129.8,88.12 129.8,88.11 131.5,88.11 146.51,73.11 146.51,71.17 150.3,67.38 152.55,67.38 153.75,66.18 158.2,66.18 160.68,63.7 164.68,63.7 166.24,65.26 175.94,65.26 180.22,60.99 181.2,60.99 182.45,59.73 185.44,59.73 187.76,57.41 194.53,57.41 201.26,50.68 201.26,49.83 204.98,46.1 204.98,42.67 207.66,39.99 207.66,38.93 v3(207.3,38.57)
  BOTTOM w0.089: 209.15,37.8 209.16,37.8 209.28,37.68 210.98,37.68 211.18,37.48 211.86,37.48 212.08,37.26 212.33,37.26 212.43,37.35 212.43,37.47 212.34,37.55 UH1.BD21
  BOTTOM w0.127: 209.15,37.8 207.98,37.8 207.49,38.28 207.49,38.38 v3(207.3,38.57) ; v3(129.27,88.81) 129.45,88.63 129.45,88.22 129.15,87.91 128.42,87.91 128.29,88.04 127.92,88.04 CPU1.AB2
DMI_CRX_PTX_N1: length 130.4
  IN6 w0.099: v3(205.93,38.57) 205.81,38.44 205.81,38.25 205.97,38.09 206.16,38.09 206.57,38.5 206.68,38.61 206.68,39.41 204.39,41.7 204.39,45.83 200.65,49.57 200.65,50.46 194.41,56.7 187.64,56.7 185.19,59.15 182.21,59.15 180.95,60.4 179.98,60.4 176.29,64.09 172.73,64.09 172.22,64.6 166.41,64.6 165.72,63.91 165.72,62.75 165.23,62.26 165.23,58.3 163.35,56.43 162.67,56.43 162.57,56.33 160.41,56.33 159.52,57.23 156.12,57.23 155.58,57.77 153.09,57.77 151.69,59.17 150.99,59.17 149.89,60.27 148.58,60.27 144.53,64.33 144.53,66.58 145.76,67.81 145.76,73.03 131.33,87.46 129.1,87.46 127.95,88.61 127.07,88.61 126.89,88.43 126.89,88.1 126.99,88 v3(127.19,88)
  BOTTOM w0.089: v3(127.19,88) 126.84,87.64 CPU1.AB3 ; UH1.BE20 211.63,37.29 211.41,37.29 211.35,37.24 211.35,37.07 211.31,37.03 211.06,37.03 210.99,37.09 210.99,37.28 210.89,37.39 210.71,37.39 210.7,37.4 209.8,37.4 209.7,37.3 209.7,37.31 209.71,37.32 209.69,37.32
  BOTTOM w0.127: 209.69,37.32 207.81,37.32 206.83,38.31 206.47,38.31 206.43,38.27 206.23,38.27 v3(205.93,38.57)
DMI_CRX_PTX_N2: length 124
  IN6 w0.099: v3(204.76,37.8) 205.1,38.14 205.1,38.36 203.68,39.77 203.68,45.49 200.02,49.16 200.02,50.27 194.17,56.11 187.4,56.11 184.95,58.56 181.97,58.56 180.71,59.82 167.6,59.82 163.6,55.82 162.88,55.82 162.81,55.75 160.15,55.75 159.28,56.62 155.88,56.62 155.33,57.17 152.14,57.17 149.62,59.69 148.25,59.69 143.7,64.24 143.7,66.89 145.16,68.35 145.16,72.8 131.11,86.86 127.96,86.86 127.8,87.02 127,87.02 126.81,86.83 126.81,86.64 126.96,86.49 v3(127.18,86.49)
  BOTTOM w0.089: UH1.BD17 212.41,35.93 212.47,35.87 212.47,35.75 212.35,35.64 212.09,35.64 211.9,35.83 210,35.83 209.47,36.36 209.04,36.36 ; CPU1.AC3 126.84,86.83 127.18,86.49 v3(127.18,86.49)
  BOTTOM w0.127: v3(204.76,37.8) 204.76,37.77 204.99,37.55 204.99,37.26 205.58,36.68 207.04,36.68 207.36,36.36 209.04,36.36
DMI_CRX_PTX_N3: length 122.5
  IN6 w0.099: v3(209.93,36.71) 209.99,36.71 210.3,37.02 210.3,37.09 210.23,37.16 204.52,37.16 203.08,38.6 203.08,45.17 199.38,48.87 199.38,50.08 193.93,55.53 187.16,55.53 184.71,57.98 181.72,57.98 180.49,59.21 167.85,59.21 163.85,55.21 163.08,55.21 163.03,55.16 159.91,55.16 159.04,56.03 155.63,56.03 155.08,56.58 151.84,56.58 149.32,59.11 147.92,59.11 142.94,64.09 142.94,67.18 144.56,68.8 144.56,72.58 131.06,86.08 130.78,86.08 130.58,85.88 130.58,85.54 130.67,85.45 130.86,85.45 v3(130.99,85.58)
  BOTTOM w0.089: CPU1.AC1 128.35,86.7 128.36,86.7 128.51,86.55 129.71,86.55 129.71,86.55 129.77,86.55 129.78,86.56 129.8,86.56 ; UH1.BE18 211.67,36.44 211.03,36.44 210.98,36.4 210.98,36.28 210.94,36.24 210.4,36.24 v3(209.93,36.71)
  BOTTOM w0.127: 129.8,86.56 130.26,86.56 130.58,86.24 130.58,85.73 130.73,85.58 v3(130.99,85.58)
DMI_CRX_PTX_P0: length 114.2
  IN6 w0.089: 129.8,88.72 129.69,88.62 129.69,88.47 129.8,88.37
  IN6 w0.099: v3(130.02,88.81) 129.88,88.81 129.8,88.72 ; v3(207.89,38.57) 207.84,38.62 207.84,40.06 205.16,42.74 205.16,46.18 201.44,49.9 201.44,50.76 194.61,57.59 187.84,57.59 185.51,59.91 182.53,59.91 181.27,61.17 180.29,61.17 176.02,65.44 166.16,65.44 164.6,63.88 160.76,63.88 158.28,66.36 153.82,66.36 152.63,67.56 150.37,67.56 146.69,71.24 146.69,73.19 131.58,88.29 129.88,88.29 129.8,88.37
  BOTTOM w0.089: UH1.BB21 212.63,37.57 212.34,37.86 212.08,37.86 211.9,37.69 211.27,37.69 211.07,37.88 209.38,37.88 209.24,38.02 209.18,38.02 209.16,38.04 209.15,38.04
  BOTTOM w0.127: v3(130.02,88.81) 129.69,88.49 129.69,88.11 129.25,87.67 128.73,87.67 128.65,87.59 128.65,87.47 128.53,87.34 128.35,87.34 128.22,87.47 CPU1.AB1 ; v3(207.89,38.57) 207.73,38.42 207.73,38.39 208.08,38.04 209.15,38.04
DMI_CRX_PTX_P1: length 130.5
  IN6 w0.089: 129.8,87.64 129.19,87.64 128.04,88.79 126.99,88.79 126.7,88.5 126.7,88.21 v3(126.49,88)
  IN6 w0.099: 129.8,87.64 131.4,87.64 145.94,73.1 145.94,67.74 144.71,66.5 144.71,64.4 148.66,60.45 149.96,60.45 151.07,59.35 151.77,59.35 153.17,57.95 155.65,57.95 156.2,57.41 159.59,57.41 160.49,56.51 162.5,56.51 162.59,56.61 163.28,56.61 165.05,58.38 165.05,62.33 165.54,62.83 165.54,63.98 166.34,64.78 172.29,64.78 172.8,64.27 176.36,64.27 180.05,60.58 181.03,60.58 182.28,59.33 185.27,59.33 187.72,56.88 194.49,56.88 200.83,50.54 200.83,49.64 204.57,45.9 204.57,41.77 206.86,39.48 206.86,38.54 206.7,38.37 206.44,38.11 v3(206.44,37.79)
  BOTTOM w0.089: v3(126.49,88) 126.14,87.64 CPU1.AB4 ; UH1.BC20 212.54,37.05 212.08,37.05 211.86,36.83 210.97,36.83 210.93,36.88 210.86,36.95 210.86,36.95 210.61,37.2 209.88,37.2 209.78,37.09 209.71,37.09 209.71,37.08 209.69,37.08
  BOTTOM w0.127: 209.69,37.08 207.71,37.08 206.73,38.06 206.57,38.06 206.44,37.94 v3(206.44,37.79)
DMI_CRX_PTX_P2: length 124.1
  IN6 w0.099: v3(126.47,86.5) 126.63,86.65 126.63,86.91 126.93,87.2 127.87,87.2 128.04,87.04 131.18,87.04 145.34,72.88 145.34,68.28 143.88,66.82 143.88,64.31 148.33,59.87 149.7,59.87 152.21,57.36 155.4,57.36 155.96,56.8 159.35,56.8 160.22,55.93 162.73,55.93 162.8,56 163.52,56 167.53,60 180.79,60 182.04,58.74 185.03,58.74 187.48,56.3 194.25,56.3 200.2,50.34 200.2,49.23 203.86,45.56 203.86,39.85 205.28,38.44 205.28,37.87 v3(205.35,37.8)
  BOTTOM w0.089: CPU1.AC4 126.14,86.83 v3(126.47,86.5) ; 209.04,36.6 209.12,36.6 209.16,36.57 209.55,36.57 210.08,36.04 211.91,36.04 212.12,36.25 212.36,36.25 212.37,36.24 212.66,35.95 UH1.BB17
  BOTTOM w0.127: v3(205.35,37.8) 205.23,37.69 205.23,37.37 205.68,36.92 207.14,36.92 207.46,36.6 209.04,36.6
DMI_CRX_PTX_P3: length 122.7
  IN6 w0.099: v3(210.52,36.7) 210.5,36.72 210.5,37.15 210.31,37.35 204.59,37.35 203.26,38.68 203.26,45.25 199.56,48.94 199.56,50.15 194,55.71 187.23,55.71 184.78,58.16 181.8,58.16 180.57,59.39 167.78,59.39 163.77,55.39 163.01,55.39 162.95,55.34 159.99,55.34 159.11,56.21 155.7,56.21 155.16,56.76 151.92,56.76 149.39,59.29 148,59.29 143.12,64.16 143.12,67.11 144.74,68.72 144.74,72.66 131.13,86.26 130.71,86.26 130.4,85.96 130.4,85.8 v3(130.17,85.58)
  BOTTOM w0.089: CPU1.AC2 127.85,86.5 128.28,86.5 128.44,86.34 129.7,86.34 129.7,86.34 129.77,86.34 129.78,86.32 129.8,86.32 ; UH1.BC18 212.56,36.45 212.09,36.45 211.9,36.64 210.58,36.64 v3(210.52,36.7)
  BOTTOM w0.127: v3(130.17,85.58) 130.34,85.74 130.34,86.14 130.16,86.32 129.8,86.32
DMI_CTX_PRX_N0: length 125.6
  IN6 w0.099: v3(127.89,85.57) 127.98,85.48 128.58,85.48 129.55,84.5 131.98,84.5 144.06,72.42 144.06,68.98 142.36,67.27 142.36,64.06 147.73,58.69 149.15,58.69 151.67,56.17 154.88,56.17 155.42,55.63 157.66,55.63 158.9,54.38 163.62,54.38 168.03,58.79 180.34,58.79 181.56,57.58 184.54,57.58 187.01,55.11 193.78,55.11 198.86,50.03 198.86,48.75 202.66,44.96 202.66,38.33 204.27,36.71 207.45,36.71 208.17,35.98 210.47,35.98 212.6,38.12 213.41,38.12 213.73,38.44 214.16,38.44 214.36,38.25 214.36,37.76 v3(214.56,37.56)
  BOTTOM w0.089: v3(214.56,37.56) 214.28,37.84 UH1.AW22 ; CPU1.AF2 v3(127.89,85.57)
DMI_CTX_PRX_N1: length 136.3
  IN6 w0.099: v3(215.83,36.62) 216,36.44 216,36.34 215.86,36.2 213.08,36.2 212.41,35.53 212.41,34.95 211.24,33.78 207.97,33.78 207.72,33.53 204.79,33.53 203.42,32.16 197.16,32.16 188.6,23.59 173.57,23.59 171.98,25.18 170.42,25.18 169.75,25.85 169.75,28.02 166.92,30.85 166.92,33.58 165.31,35.19 164.81,35.19 162.24,37.77 162.24,41.29 161.93,41.59 161.93,44.46 157.35,49.04 155.69,49.04 152.78,51.95 149.98,51.95 136.74,65.18 136.74,76.92 130.9,82.76 129.97,82.76 129.66,83.07 129.66,83.47 128.78,84.35 127.78,84.35 126.94,85.18 126.49,85.18 126.37,85.31 126.37,85.43 v3(126.49,85.56)
  BOTTOM w0.089: v3(126.49,85.56) 126.14,85.21 CPU1.AF4
  BOTTOM w0.102: UH1.AR20 216.08,36.87 v3(215.83,36.62)
DMI_CTX_PRX_N2: length 136.3
  IN6 w0.089: v3(126.4,83.99) 126.57,83.82
  IN6 w0.099: v3(217.13,35.65) 216.84,35.37 216.84,35.23 216.67,35.06 213.79,35.06 211.22,32.49 205.26,32.49 204.12,31.35 197.43,31.35 188.91,22.83 180.18,22.83 179.76,22.41 177.12,22.41 176.7,22.83 173.11,22.83 171.61,24.33 170.17,24.33 168.93,25.57 168.93,27.63 166.12,30.44 166.12,32.37 161.47,37.02 161.47,40.87 161.04,41.3 161.04,43.2 156.29,47.94 155.48,47.94 152.26,51.16 149.63,51.16 135.98,64.81 135.98,76.6 130.67,81.91 129.7,81.91 128.98,82.63 128.98,83.29 128.67,83.6 127.77,83.6 127.53,83.35 126.86,83.35 126.59,83.63 126.59,83.8 126.57,83.82
  BOTTOM w0.089: v3(126.4,83.99) 126.4,84.2 126.21,84.39 CPU1.AG4 ; v3(217.13,35.65) 216.67,36.11 UH1.AP17
DMI_CTX_PRX_N3: length 131.6
  IN6 w0.099: v3(214.52,36.62) 214.37,36.77 214.37,36.96 214.15,37.17 212.59,37.17 210.79,35.38 208.05,35.38 207.36,34.69 205.12,34.69 203.45,33.01 197.19,33.01 188.5,24.33 174.52,24.33 167.5,31.34 167.5,34.23 163.05,38.68 163.05,44.19 157.39,49.85 155.77,49.85 153.05,52.57 150.23,52.57 137.33,65.47 137.33,77.18 131.78,82.73 131.78,83.49 131.37,83.9 130.55,83.9 130.28,83.62 130.28,83.5 130.09,83.31 v3(130.05,83.31)
  BOTTOM w0.089: UH1.AV20 214.52,36.75 v3(214.52,36.62)
  BOTTOM w0.127: v3(130.05,83.31) 130.25,83.51 130.25,83.8 130.03,84.02 129.06,84.02 128.97,83.93 128.34,83.93 128.23,84.04 128.02,84.04 127.67,84.39 CPU1.AG2
DMI_CTX_PRX_P0: length 125.6
  IN6 w0.099: v3(213.91,37.56) 214.18,37.82 214.18,38.17 214.08,38.26 213.81,38.26 213.48,37.94 212.68,37.94 210.54,35.8 208.1,35.8 207.37,36.53 204.2,36.53 202.48,38.25 202.48,44.89 198.68,48.68 198.68,49.95 193.71,54.93 186.94,54.93 184.47,57.4 181.48,57.4 180.27,58.61 168.1,58.61 163.7,54.2 158.83,54.2 157.58,55.45 155.35,55.45 154.8,55.99 151.59,55.99 149.08,58.51 147.65,58.51 142.18,63.98 142.18,67.35 143.88,69.05 143.88,72.35 131.91,84.32 129.48,84.32 128.5,85.3 128.13,85.3 127.88,85.04 v3(127.88,84.85)
  BOTTOM w0.089: UH1.AY22 213.91,37.86 v3(213.91,37.56) ; CPU1.AF1 128.22,85.19 v3(127.88,84.85)
DMI_CTX_PRX_P1: length 136.3
  IN6 w0.099: v3(216.48,36.62) 216.36,36.62 216.18,36.44 216.18,36.26 215.94,36.02 213.15,36.02 212.59,35.45 212.59,34.88 211.31,33.6 208.05,33.6 207.79,33.35 204.87,33.35 203.49,31.98 197.23,31.98 188.67,23.41 173.49,23.41 171.91,25 170.35,25 169.57,25.77 169.57,27.94 166.74,30.77 166.74,33.5 165.23,35.01 164.74,35.01 162.06,37.69 162.06,41.21 161.75,41.52 161.75,44.39 157.28,48.86 155.62,48.86 152.71,51.76 149.91,51.76 136.56,65.11 136.56,76.84 130.82,82.58 129.9,82.58 129.48,83 129.48,83.4 128.71,84.16 127.7,84.16 126.86,85 126.69,85 v3(126.49,84.8)
  BOTTOM w0.089: v3(126.49,84.8) 126.49,84.88 CPU1.AF3
  BOTTOM w0.102: UH1.AP20 216.67,36.81 v3(216.48,36.62)
DMI_CTX_PRX_P2: length 136.4
  IN6 w0.099: v3(127.21,83.99) 126.92,84.27 126.83,84.27 126.77,84.22 126.77,83.7 126.94,83.53 127.45,83.53 127.69,83.78 128.74,83.78 129.16,83.36 129.16,82.71 129.78,82.09 130.74,82.09 136.16,76.67 136.16,64.88 149.71,51.34 152.34,51.34 155.55,48.12 156.36,48.12 161.22,43.27 161.22,41.38 161.65,40.94 161.65,37.1 166.3,32.45 166.3,30.52 169.12,27.7 169.12,25.64 170.25,24.51 171.68,24.51 173.19,23.01 176.77,23.01 177.19,22.59 179.69,22.59 180.11,23.01 188.84,23.01 197.36,31.53 204.05,31.53 205.19,32.67 211.14,32.67 213.71,35.24 216.59,35.24 216.66,35.31 216.66,35.45 v3(216.48,35.64)
  BOTTOM w0.089: CPU1.AG3 126.82,84.37 v3(127.21,83.99) ; UH1.AR17 216.48,35.73 v3(216.48,35.64)
DMI_CTX_PRX_P3: length 131.4
  IN6 w0.099: v3(130.89,83.31) 130.74,83.17 130.55,83.17 130.46,83.26 130.46,83.55 130.63,83.72 131.29,83.72 131.6,83.41 131.6,82.66 137.15,77.11 137.15,65.4 150.15,52.39 152.97,52.39 155.69,49.67 157.32,49.67 162.87,44.11 162.87,38.6 167.32,34.15 167.32,31.27 174.45,24.15 188.58,24.15 197.27,32.83 203.52,32.83 205.2,34.51 207.44,34.51 208.13,35.2 210.87,35.2 212.66,36.99 214.07,36.99 214.19,36.88 214.19,36.8 214,36.62 v3(213.87,36.62)
  BOTTOM w0.089: v3(213.87,36.62) 213.87,36.69 UH1.AW20
  BOTTOM w0.127: v3(130.89,83.31) 130.71,83.31 130.49,83.54 130.49,83.9 130.13,84.27 128.96,84.27 128.87,84.18 128.44,84.18 CPU1.AG1
DMI_IREF: length 4
  BOTTOM w0.254: RH144.2 208.24,35.54 208.35,35.65 v1(209.08,35.65) 209.38,35.65 209.48,35.55 211.74,35.55 UH1.BE16
DMI_RCOMP: length 5.5
  TOP w0.089: v1(210.14,38.06) 210.14,37.66 210.9,36.9 211.93,36.9 RH42.2
  TOP w0.254: RH42.2 212.8,36.02 213.48,36.02 v3(213.86,35.64)
  BOTTOM w0.254: v3(213.86,35.64) 213.69,35.81 UH1.AY17
DP_CBL_DET: length 198.6
  IN4 w0.089: 160.32,101.84 160.32,99.2 161.58,97.93 161.58,97.37 161.83,97.13 162.47,97.13 163.24,96.37 163.24,94.9 164.04,94.1 164.04,83.25 164.19,83.1 164.19,81.04 163.67,80.52 163.67,75.5 162.79,74.63 162.79,71.43 161.91,70.55 161.91,66.7
  IN4 w0.091: v3(139.46,137.1) 139.82,136.74 151.61,136.74 153.92,139.06 v3(154.78,139.06) ; v3(160.59,122.2) 160.03,121.63 160.03,113.14 160.32,112.84 160.32,101.84 ; v3(228.63,36.62) 228.02,36.01 225.2,36.01 224.92,36.3 224.92,36.81 224.67,37.06 222.37,37.06 221.41,36.11 208.78,36.11 208.39,36.5 203.2,36.5 201.72,37.98 201.72,48.54 199.41,50.85 167.22,50.85 166.08,51.99 166.08,53.1 165.57,53.61 165.19,53.61 163.58,55.22 161.72,55.22 158.59,58.36 158.59,61.06 161.91,64.39 161.91,66.7
  IN5 w0.099: v3(160.59,122.2) 159.63,123.17 159.63,125.44 156.86,128.21 156.86,128.72 155.64,129.94 155.64,135.16 155.87,135.38 155.87,137.96 v3(154.78,139.06)
  BOTTOM w0.089: v3(228.63,36.62) 228.45,36.44 UH1.F17
  BOTTOM w0.127: v1(138.93,137.7) 138.93,137.63 v3(139.46,137.1) 139.6,136.96 RV17.1 140.4,137.24 JDP1.4 ; v3(154.78,139.06) 155.12,139.4 UV3.1
DSWODVREN: length 10.7
  BOTTOM w0.089: 230.86,31.92 230.27,31.92 230.06,32.12 229.64,32.12 UH1.C8
  BOTTOM w0.102: 230.86,31.92 231.28,31.49 231.28,30
  BOTTOM w0.127: RH70.2 RH65.1 233.68,25.8 v1(233.05,25.8) 232.09,26.76 232.09,28.91 231.28,29.73 231.28,30
EAPD#: length 321.9
  TOP w0.127: v1(16.94,32.79) 16.19,33.54 v3(15.09,33.54)
  TOP w0.157: v3(244.24,41.95) 242.61,41.95 241.63,42.93 241.34,42.93 241.2,43.07 UE6.6 ; v3(27.01,18.24) 26.43,18.24 24.4,16.2 UA1.52
  IN1 w0.119: v3(2.54,14.21) 2.54,15.04 1.61,15.97 1.61,18.87 2.38,19.64 2.38,24.92 2.87,25.41 2.87,26.27 2.58,26.56 2.58,29.26 4.13,30.81 7,30.81 9.41,33.23 10.3,33.23 11.8,34.72 13.91,34.72 v3(15.09,33.54)
  IN2 w0.119: v3(15.09,33.54) 15.09,25.62 16.52,24.18 17.72,24.18 19.69,22.21 21.35,22.21 22.57,21 24.98,21 26.47,19.51 26.47,18.79 v3(27.01,18.24)
  IN3 w0.112: v3(27.01,18.24) 26.48,17.71 26.48,14.28 28.69,12.07 46.7,12.07 49.42,9.35 54.65,9.35 58.14,12.84 60.8,12.84 61.19,12.45 64.4,12.45 64.71,12.75 67.83,12.75 69.42,14.34 118.01,14.34 118.75,15.08 140.97,15.08 141.09,15.19 148.47,15.19 150.66,12.99 161.01,12.99 162.23,11.77 173.78,11.77 175.48,13.48 192.56,13.48 193.84,14.76 207.81,14.76 209.12,13.45 215.74,13.45 216.84,14.56 220.18,14.56 220.96,13.78 225.38,13.78 226.16,14.57 229.53,14.57 230.94,15.98 233.1,15.98 234.65,17.53 235.56,17.53 238.29,20.26 238.29,22.74 239.33,23.78 239.33,24.28 239.65,24.6 240.43,24.6 240.77,24.26 v3(240.77,23.75)
  IN6 w0.119: v3(244.24,41.95) 243.11,40.82 243.11,36.57 244.55,35.12 244.55,30.42 242.53,28.4 242.53,25.51 v3(240.77,23.75)
  BOTTOM w0.157: v3(2.54,14.21) 3.06,14.21 3.29,13.98 DA15.2
EC_AC_BAT#: length 145.5
  TOP w0.102: v2(168.73,67.58) 168.81,67.58 v3(169.19,67.96)
  TOP w0.127: v3(231.1,54.4) 232.67,54.4 233.18,53.89 234.74,52.33 242.14,52.33 243.6,50.87 243.6,47.74 244.54,46.8 244.54,45.91 243.9,45.27 UE6.9
  IN3 w0.091: v3(231.1,54.4) 229.83,55.67 220.23,55.67 219.66,56.24 214.63,56.24 213.94,55.54 205.54,55.54 v3(203.89,53.89)
  IN5 w0.099: v3(203.89,53.89) 203.05,53.05 202.45,53.05 200.26,50.86 167.84,50.86 167.54,51.16 167.54,53.13 166.93,53.74 166.93,56.44 166.47,56.9 166.47,64.27 168.82,66.62 168.82,67.59 v3(169.19,67.96)
  IN6 w0.089: v3(169.19,67.96) 168.79,68.37 160.28,68.37 160.16,68.25 159.33,68.25
  IN6 w0.099: v3(142.45,80.53) 142.45,79.9 148.22,74.13 148.22,72.06 151.28,69 153.37,69 154.12,68.25 159.33,68.25
  BOTTOM w0.127: v3(142.45,80.53) 141.93,80.01 RV93.2 140.41,80.58 140.41,81.46 140.63,81.68 UV19.2
