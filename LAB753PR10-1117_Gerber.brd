# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Nets (continued)
N30074465: RV185.1 UV15.J10
N30074953: QV25.1 RV205.1 RV206.1
N30306722: CM99.1 RM28.1 RM29.1
N30306724: CM98.1 RM27.1 RM38.1
N30306755: CM16.1 CM17.1 RM18.2 UM4.20
N30306794: RM25.2 UM4.18
N30306802: RM19.2 RM21.2 UM4.1
N30306843: RM28.2 UM4.13
N30306845: RM27.2 UM4.14
N30449531: PH500.1 PR525.1 PR528.1
N30468201: PQ701.4 PR725.1
N30503669: PQ707.4 PR726.1
N30670626: PR641.1 PU601.1
N30712936: PR727.2 PU700.15
N30751575: PQ710.3 PR732.2
N30751577: PQ710.5 PQ710.6 PR729.1 PR730.2
N30751626: PC724.1 PQ710.2 PR731.2
N30812755: PC660.1 PU602.7
N30972760: CT8.1 RT16.1
N31013912: PH501.2 PR551.1
N31910445: JSSD3.30 RN33.1 RN35.2
N31911348: JSSD2.30 RN29.1 RN30.2
N31911952: JSSD1.30 RN28.1 RN31.2
N32451492: JSSD4.30 RN32.1 RN34.2
N33138349: RV241.2 UV20.5
N33139824: RV242.2 RV554.1 UV20.8
N33139840: RV243.2 RV553.1 UV20.9
N33792732: RL5.1 UL2.3
N33792861: RE20.1 UE9.3
N34043429: RM72.2 UM8.27
N34067329: Q2411.5 R148.2
N34067344: Q2412.5 R152.2
N34067359: Q2413.5 R172.2
N34596334: CT2.1 UT1.2
N35007428: RM20.2 UM4.4
N35128238: RV293.2 UV4.18
N35755395: RH1.2 RH2.2 UH1.A14
N35913798: RC24.2 RC57.2 UC1.1
N35913809: CC31.1 RC56.2 UC1.2
N36090962: RV512.1 UV1.BB5
N36090964: RV513.1 UV1.BB4
N36090966: RV511.1 UV1.BD3
N36090968: RV510.1 UV1.BD4
N36096883: RV68.2 UV1.AW9
N36100380: RV67.1 UV1.BA23
N36106148: RV77.2 UV1.P40
N36106150: RV79.2 UV1.R47
N36106154: RV78.2 UV1.R48
N36126643: RV153.1 UV1.BB48
N36139218: RE98.2 UE6.10
N36226998: CR9.1 RR9.1
N36227015: CR14.1 RR10.1
N36403695: QM2.3 QM3.2 RM94.2
N36665397: CV374.1 RV13.2
N36871069: CE52.1 RE85.1 UE7.2
N37505012: CA17.1 CA18.2 UA1.40
N37505062: RA42.2 UA1.36
N37505130: RA64.2 UA1.37
N37505138: CA67.2 RA81.1
N37505139: CA68.2 RA84.1
N37505216: CA30.1 RA96.2
N37505235: CA19.2 UA6.13
N37505311: RA91.2 RA111.2 UA4.3
N37505354: CA101.2 UA4.5
N37505355: CA102.2 UA4.32
N37505357: CA101.1 RA117.2
N37505359: CA102.1 RA116.1
N37505361: CA103.1 RA118.2 RA120.2
N37505362: CA104.1 RA119.2 RA122.2
N37505403: QA7.5 QA7.6 RA123.2
N37505479: CA83.2 RA130.2
N37505480: CA84.2 RA131.2
N37505481: CA85.2 RA132.2
N37505482: CA86.2 RA133.2
N37505517: CA75.1 QA11.1 RA102.1
N37505593: CA73.1 QA13.1 RA100.1
N37505594: CA74.1 QA12.1 RA126.1
N37551658: RM61.2 UM8.52
N37905289: QA7.2 RA93.2 RA94.2
N38491094: QA14.5 QA14.6 RA114.2
N61580896: Q41.1 R177.2
N72585933: PC211.1 PR202.2
N198445017: T66.1(TP-1) UH1.C26
N198445717: T64.1(TP-1) UH1.BA2
N198445911: T65.1(TP-1) UH1.BB2
N198468312: T69.1(TP-1) UH1.AU42
N198468386: T71.1(TP-1) UH1.AU44
N198469522: T70.1(TP-1) UH1.AW17
N198469532: T72.1(TP-1) UH1.AV17
N198469635: T79.1(TP-1) UH1.AB10
N198547586: T68.1(TP-1) UH1.AD10
N198588020: RH83.1 UH1.Y3
N198588843: T82.1(TP-1) UH1.AD39
N198588869: T84.1(TP-1) UH1.AD38
N198608694: T85.1(TP-1) UH1.BA45
N198608700: T86.1(TP-1) UH1.BC45
N198608716: T87.1(TP-1) UH1.BE43
N198608718: T88.1(TP-1) UH1.BE44
N198628812: T91.1(TP-1) UH1.BC30
N198628814: T92.1(TP-1) UH1.BB29
N198628819: T89.1(TP-1) UH1.M33
N198628821: T90.1(TP-1) UH1.L33
N201379861: RH39.2 UH1.U40
N201503343: T80.1(TP-1) UH1.C40
N201737633: PC522.1 PR534.1
N201737689: PC542.1 PR550.1
N201737828: PC511.1 PR526.1 PU500.17
N201737837: PR507.2 PU500.28
N201737838: PR512.2 PU500.30
N201737840: PR509.2 PU500.29
N201737896: PC520.2 PR533.1
N201737910: PC527.2 PR543.1
N201737914: PC526.2 PR539.1
N201737923: PR529.2 PU500.9
N201737985: PC521.1 PR535.1 PU500.14
N201737986: PC521.2 PR545.2
N201738002: PC529.1 PC538.1 PR548.2
N201738025: PC518.1 PR530.1 PU500.16
N201738085: PC501.1 PR502.1
N205002433: CH11.1 RH108.1
N206179634: PC629.1 PR643.2 PU601.8
N206180145: PC626.1 PQ610.2 PR620.2 PR631.1
N206181687: PQ610.1 PR623.2
N212152397: JRTC1.1 PR2.2
N213961754: PC14.2 PQ8.2 PR28.2
N215666090: RH81.2 UH1.AA2
N215666239: RH82.2 UH1.AE4
N219840090: T67.1(TP-1) UH1.AB6
N303520630: C2506.1 U17.12
N303520770: C2507.1 U17.10
N359184751: RV2.1 UV2.3
N359204640: RT11.1 UT1.3
N384977821: PC628.1 PR640.2
N384979741: PC615.1 PR608.2
N384981221: PC621.1 PR626.2

Pads without a net: CPU1 A16 A17 AD45 AE9 AF9 AG45 AN35 AN37 AU19 AU39 AU40 AV19 AV35 AV36 AV39 AV40 AW19 AW20 AW39 AW40 AY26 AY27 AY36 AY39 AY40 B16 B17 BA26 BA27 BA39 BA40 BC23 BC34 BC37 BC39 BC53 BD16 BD17 BD23 BD31 BD34 BD37 BD38 BD39 BE17 BE23 BE37 BE38 BE39 BF17 BF23 BF37 BF39 C16 C17 C51 D16 D17 G14 G17 G53 J12 N51 R1 R2 R3 R4 T1 T2 T3 T4 V1 V2 V3 V4 Y1 Y2 Y3 Y4; DE2 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125; JDIMM2 77 122 125; JHDMI1 14; JKB1 2 3; JKBBL1 17 18 19 20; JPWR1 7 26; JSSD1 1 6 7 8 9 10 12 14 15 16 17 18 20 21 22 23 24 26 27 28 29 32 34 36 38 40 42 44 45 46 47 48 50 51 52 53 54 55 56 57 58 59 60 61; JSSD2 1 6 7 8 9 10 12 14 15 16 17 18 20 21 22 23 24 26 27 28 29 32 34 36 38 40 42 44 45 46 47 48 50 51 52 53 54 55 56 57 58 59 60; JSSD3 1 6 7 8 9 10 12 14 15 16 17 18 20 21 22 23 24 26 27 28 29 32 34 36 38 40 42 44 45 46 47 48 50 51 52 53 54 55 56 57 58 59 60; JSSD4 1 6 7 8 9 10 12 14 15 16 17 18 20 21 22 23 24 26 27 28 29 32 34 36 38 40 42 44 45 46 47 48 50 51 52 53 54 55 56 57 58 59 60 61; JWLAN1 8 9 10 11 12 13 14 15 17 19 20 21 22 23 24 26 28 34 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; PD1 3; PJPDC1 1 11; PU401 3 7; PU600 12; PU602 4; PU700 9 13 14; Q2411 6; Q2412 6; Q2413 6; RP2 1 8; RPH2 1 2 7 8; RPH3 1 4 5 8; RR4 3 4 5 6; U18 5 6 7 8 9 10 12; U2407 8; U2410 4 6; UA1 12 24 27 32 35; UA3 1 2; UA4 11; UA5 3 7; UA6 15; UE3 12 13 22 28 29; UE4 12 13 19 20 21 22 28 29; UE6 13 20; UE7 1; UE8 12 13 19 20 21 22 28 29; UH1 A28 A30 AA42 AA44 AB39 AB40 AE42 AE44 AF7 AF10 AF11 AH43 AH45 AJ10 AJ26 AJ28 AJ35 AJ36 AJ42 AJ44 AL35 AL36 AN4 AN38 AN39 AR31 AT31 AT39 AT40 AV43 AV45 AW13 AW38 AW44 AY13 AY38 AY45 B29 BB9 BB33 BC38 BC40 BD9 BD33 BD41 BD42 BE38 BE40 C28 C30 D2 D21 D29 F3 F22 F24 F26 F39 G5 G20 G22 G24 G26 H39 H43 H45 J42 J44 K13 K22 L15 M43 M45 N38 N40 N42 N44 T45 U44 V45 Y10 Y12 Y43 Y45; UL1 24 25 26 28 40; UM4 7 8; UM8 10 11 12 13 15 16 17 18 28 29 30 31 32 33 34 35; UN2 2 3; UR1 13 22 23 24 25 26; UT2 1 2 5 6 7 9 12 13 14 15 17 27 28; UU5 1; UV1 A18 A38 AA6 AA9 AA10 AC40 AC41 AC43 AD3 AD6 AD8 AD9 AF10 AF43 AF46 AF49 AG4 AG11 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ7 AJ8 AJ9 AJ41 AK1 AK2 AK3 AK4 AK5 AK6 AK7 AK8 AK9 AK10 AK46 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM10 AN1 AN2 AN3 AN4 AN5 AN6 AN7 AN8 AN9 AN10 AN44 AN46 AN47 AR1 AR2 AR3 AR4 AR5 AR6 AR7 AR8 AR9 AR10 AR42 AR43 AR47 AT2 AT3 AT4 AT5 AT8 AT10 AV2 AV5 AV6 AV8 AV9 AV46 AW3 AW5 AW6 AW14 AW20 AW21 AY14 AY18 AY20 AY21 BA11 BA12 BA14 BA15 BA17 BA18 BA20 BA21 BB9 BB11 BB12 BB14 BB15 BB17 BB18 BC8 BC9 BC11 BC12 BC14 BC15 BC17 BC18 BC29 BC30 BC32 BC33 BC35 BC36 BD5 BD6 BD8 BD9 BD11 BD12 BD14 BD15 BD17 BD18 BD29 BD30 BD32 BD33 BD35 BD36 BE1 BE5 BE6 BE8 BE9 BE11 BE12 BE14 BE15 BE17 BE18 BE31 BE32 BE34 BE35 BF1 BF2 BF4 BF6 BF8 BF9 BF11 BF12 BF14 BF15 BF17 BF18 BG2 BG3 BG4 BG5 BG6 BG8 BG9 BG11 BG12 BG14 BG15 BG17 BG18 BG30 BG32 BG33 BG35 BG36 BH3 BH4 BH6 BH8 BH9 BH11 BH12 BH14 BH15 BH17 BH18 BH30 BH32 BH33 BH35 BH36 BJ4 BJ5 BJ6 BJ8 BJ9 BJ11 BJ12 BJ14 BJ15 BJ17 BJ18 BJ21 BJ29 BJ30 BJ32 BJ33 BJ35 BJ36 C6 C9 C11 C24 C38 C41 D11 D14 D18 D27 D29 E39 E49 F3 F21 G9 G11 G18 G24 H9 H24 H30 H32 H35 J3 J7 J8 J15 J21 J24 J32 J33 J36 J44 J45 J48 K21 K36 L3 L4 L6 L42 L43 M49 P4 R9 R39 R41 U46 V1 V4 V7 Y41 Y42 Y44 Y47; UV3 9 10 11 12 13 14; UV6 A5 U5; UV7 A5 U5; UV8 A5 U5; UV9 A5 U5; UV12 A5 U5; UV13 A5 U5; UV15 A5 U5; UV16 A5 U5; UV20 1 2 10 13 16 17

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 811 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 322 vias
v3: diameter 0.457, hole 0.203, TOP to BOTTOM, 8529 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 84 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.35V_B+: length 19.8
  TOP w0.254: v3(151.32,24.33) 151.56,24.33 151.81,24.58 PR206.1
  IN2 w0.254: v3(145.35,38.38) 145.35,26.35 146.08,25.63 150.02,25.63 v3(151.32,24.33)
  vias: v1(147.45,41.4)
2.5VOUT: length 34.9
  IN3 w0.508: v3(159.69,137.85) 159.69,138.15 159.37,138.47 157.41,138.47 156.01,137.08 v3(155.09,137.08)
  IN5 w0.508: v3(155.09,137.08) 155.09,135.3 154.21,134.41 154.21,128.75 v3(154.87,128.09) ; v3(162.9,132.29) 161.61,133.58 161.61,134.2 160.71,135.1 160.71,135.99 161,136.29 161,137.44 160.59,137.85 v3(159.69,137.85)
  BOTTOM w0.127: v3(155.09,137.08) 155.09,137.57 v1(154.94,137.72)
  BOTTOM w0.254: 154.35,128.75 154.35,128.76 UM8.14 ; CM32.1 162.66,131.56 162.36,131.87 UM8.51 ; UM8.36 156.35,136.39 CM35.1 ; UM8.41 158.85,136.34 159.15,136.64 159.68,136.64 159.96,136.92 CM34.1 ; UM8.9 156.85,129.11 156.61,128.87 155.83,128.87 155.7,128.74
  BOTTOM w0.508: v3(155.09,137.08) 155.39,136.78 CM35.1 ; CM32.1 162.9,131.76 v3(162.9,132.29) ; v3(159.69,137.85) 159.69,137.44 CM34.1
3/5V_B+: length 14.7
  TOP w0.203: v3(25.91,28.54) 25.81,28.63 PU100.12
  IN1 w0.508: v3(25.91,28.54) 28.3,26.14 37.04,26.14 v3(38.1,27.21)
  vias: v2(39.77,28.6) v3(38.1,30.38) v3(38.1,29.75) v3(38.1,29.11) v3(38.1,28.48) v3(38.1,27.84) v3(38.74,27.21) v3(39.12,31.4) v3(39.12,30.76) v3(39.37,27.21) v3(39.5,31.97) v3(39.75,31.4) v3(39.75,30.76) v3(40.01,27.21)
3V3_MAIN_EN: length 113.2
  TOP w0.203: RV541.2 154.54,56.26 153.73,57.07 UV11.5
  TOP w0.254: v3(174.98,30.52) 175.29,30.52 PR621.2 ; PR620.1 182.95,19.42 190.77,19.42 192.38,21.03 192.38,24.25 193.8,25.67 193.8,29.31 194.99,30.5 v1(194.99,31.51) 194.99,32.31 v3(194.87,32.42) ; v3(156.2,60.38) 157.15,59.43 157.15,57.14 156.28,56.26 RV541.2
  IN1 w0.254: v3(168.05,44.03) 167.87,43.86 167.87,35.81 168.54,35.14 169.49,35.14 171.17,33.46 172.49,33.46 174.89,31.05 174.89,30.61 v3(174.98,30.52) 176.62,32.16 177.43,32.16 178.07,31.52 184.95,31.52 185.65,32.22 190.12,32.22 190.5,32.6 194.69,32.6 v3(194.87,32.43)
  IN5 w0.254: v3(168.15,67.74) 167.82,67.41 167.82,66.63 165.94,64.74 165.94,56.65 166.4,56.18 166.4,53.52 167.01,52.91 167.01,45.07 v3(168.05,44.03)
  IN6 w0.254: v3(161.28,65.55) 162.31,66.58 164.99,66.58 165.89,67.48 167.88,67.48 v3(168.15,67.74)
  BOTTOM w0.254: v3(161.28,65.55) 160.69,65.55 157.9,62.75 157.43,62.75 157.2,62.52 RV55.1 156.75,61.66 156.75,60.89 156.24,60.38 v3(156.2,60.38) ; UV1.AW1 168.32,67.58 v3(168.15,67.74)
3V_EN: length 12.3
  TOP w0.203: PU100.6 22.64,27.13 22.49,26.99 22.27,26.99 22.1,27.15 v3(22.1,27.78)
  TOP w0.254: v3(23.37,34.57) 23.42,34.62 v1(24.17,34.62) 24.68,34.62 24.99,34.93 PR100.1
  IN1 w0.254: v3(23.37,34.57) 22.48,34.57 21.72,33.81 21.72,28.16 v3(22.1,27.78)
3V_F347_ON: length 55
  TOP w0.127: v3(289.37,31.52) 289.02,31.17 289.02,30.34 RE83.1 290.06,29.3 290.06,28.25 288.99,27.18 288.99,26 289.14,25.85 UE5.128 ; UE9.4 249.4,44.47 251.08,46.15 252.16,46.15 253.01,45.3 253.76,45.3 256.3,42.76 v1(257,42.76) 258.28,42.76 259.68,41.37 261.23,41.37 262.49,40.11 264.62,40.11 265.09,39.64 266.12,39.64 266.87,38.89 v3(267.4,38.89)
  IN1 w0.099: v3(267.4,38.89) 267.86,38.43 268.4,38.43 268.48,38.51 271.03,38.51 271.68,37.87 283.03,37.87 v3(289.37,31.52)
3VALW_PCH:
  vias: v2(220.82,13.59)
3VS:
  vias: v1(56.71,12.85)
3VS_GATE: length 7.1
  TOP w0.127: v3(52.85,13.14) 52.93,13.22 U17.5
  BOTTOM w0.127: v3(52.85,13.14) 52.85,14.56 C258.1 52.11,14.31 50.59,14.31 R174.2 49.34,14.82 v1(48.73,15.43)
5V_EN: length 7.7
  TOP w0.203: PU100.20 22.64,30.86 22.16,31.33
  TOP w0.254: 22.16,31.33 21.49,32.01 21.49,34.83 21.99,35.32 v1(22.87,35.32) 23.13,35.57 PR112.1
5VS: length 1.5
  TOP w0.127: v2(55.2,18.66) 56.29,17.57
5VS_GATE: length 3
  TOP w0.127: U17.3 53.28,14.02 53.17,14.12 52.52,14.12 v1(52.25,14.39) 51.81,14.84 v3(51.65,14.84)
  BOTTOM w0.127: R182.2 51.64,14.82 v3(51.65,14.84)
+0.675VS:
  vias: v2(141.57,17.54) v3(141.86,20.47) v3(142.37,39.14) v3(142.37,38.51) v3(142.37,23.97) v3(142.37,20.79) v3(142.37,20.18) v3(143,23.97) v3(143,20.79) v3(143,20.18) v3(143.36,33.06) v3(143.37,32.48) v3(143.31,31.76) v3(143.34,29.36)
+0.675VSP:
  vias: v2(147.54,30.08)
+1.2VS: length 4
  TOP w0.203: UA1.48 23.64,14.6 23.76,14.73 v3(24.42,14.73) ; UA1.9 18.93,19.18 19.18,19.43 v3(19.18,19.65)
  TOP w0.254: 14.73,17.46 14.61,17.59 14.61,18.6 v3(14.78,18.77)
  vias: v1(14.61,16.7) v3(15.36,18.77)
+1.05V_+1.5V_RUN: length 31.2
  TOP w0.356: CH31.1 214.31,34.18 216.07,34.18 216.28,33.96 v3(216.28,33.66)
  TOP w0.508: v3(210.92,38.48) 211.38,38.02 CH30.1 ; v3(208.79,48.67) 210.25,47.21 212.26,47.21 CH23.1
  IN1 w0.508: v3(217.9,39.89) 217.9,37.61 218.28,37.23 218.91,37.23 219.2,36.93 219.2,35.33 218.29,34.42 217.04,34.42 v3(216.28,33.66)
  BOTTOM w0.254: v3(213.68,47.13) 213.22,47.13 UH1.BB44 ; v3(210.92,38.48) 211.42,37.98 UH1.BE22 ; v3(216.28,33.66) 216.58,33.66 UH1.AN11 ; v3(220.28,42.99) 220.07,42.78 UH1.AF34
  BOTTOM w0.508: RH92.2 213.44,53.02 212.89,53.57 209.25,53.57 208.19,52.52 208.19,49.27 v3(208.79,48.67)
  vias: v2(213.9,45.7) v3(214.61,45.15)
+1.05V_GPUP_B+: length 1
  BOTTOM w0.127: 134.96,90.88 v1(134,90.88)
+1.05V_PGOOD: length 70.2
  TOP w0.127: v1(241.48,24.13) v3(242.1,24.13)
  TOP w0.203: v3(288.69,23.24) 288.89,23.45 UE5.122
  IN2 w0.508: v3(288.69,23.24) 288.03,23.9 285.65,23.9 282.22,27.33 278.77,27.33 277.5,28.6 277.5,31.76 276.34,32.92 276.34,35.65 276,35.99 269.23,35.99 268.49,36.73 266.14,36.73 262.14,32.73 257.7,32.73 256.82,33.61 246.98,33.61 240.9,27.53 240.9,25.28 242.05,24.13 v3(242.1,24.13)
  BOTTOM w0.279: PR301.2 242.1,25.88 241.99,26 241.99,26.3 242.19,26.51 PU300.1
  BOTTOM w0.508: v3(242.1,24.13) PR301.2
+1.5VS: length 245.5
  TOP w0.203: v3(106.56,140.93) 106.79,140.7 UV4.12 ; UV4.40 113.33,141.1 v3(113.58,141.34) ; v3(113.51,137.14) 113.48,137.14 113.12,137.5 UV4.31
  TOP w0.508: RH110.2 RH111.1 210.72,43.47 v3(210.17,44.01) ; RH153.1 215.55,48.77 v3(215.65,48.86) ; v3(206.25,35.68) 206.25,36.54 206.76,37.05 v2(208.03,37.05) 208.71,37.05 209.65,36.11 211.44,36.11 RH42.1 ; RH22.1 RH28.2 209.51,29.24 v3(206.63,29.24)
  IN3 w0.508: v3(115.2,135.57) 115.33,135.7 129.85,135.7 129.99,135.84 132.51,135.84 133.21,135.14 140.26,135.14 141.61,133.8 141.61,132.49 147.91,126.19 147.91,119.88 152.41,115.37 152.41,104.66 145.26,97.51 145.26,70.03 138.37,63.13 v3(138.37,56.25) ; v3(156.1,22.66) 156.63,22.66 159.08,20.21 160.71,20.21 162.73,18.19 165.36,18.19 165.84,18.67 179.53,18.67 181.49,16.72 191.25,16.72 193.2,18.67 198.22,18.67 205.03,25.48 v3(207.51,25.48)
  IN5 w0.508: v3(156.1,22.66) 157.23,23.8 157.23,27.45 159.31,29.53 159.31,40.26 157.98,41.59 157.98,44.85 155.55,47.27 143.61,47.27 138.37,52.52 v3(138.37,56.25)
  BOTTOM w0.254: v3(213.15,45.57) 213.77,46.2 UH1.AW40
  BOTTOM w0.508: RH40.2 RH41.1 v3(212.47,52.85) ; RH91.1 v3(214.31,52.86) ; CV422.1 113.37,141.9 113.58,141.7 v3(113.58,141.34) ; v3(206.25,35.68) 206.8,35.68 RH144.1
  vias: v3(105.96,140.6) v3(106.68,137.86) v3(106.68,137.23) v3(207.51,26.1)
+1.05VS: length 253.4
  TOP w0.254: CH40.1 223.89,48.35 223.26,47.72 223.26,46.05 223.01,45.81 223.01,45.47 223.32,45.16 223.32,43.34 223.68,42.98 v3(223.82,42.98)
  TOP w0.508: v3(216.36,44.41) 216.75,44.8 CH22.1 ; RH142.1 223.78,50.24 223.09,50.93 ; 223.09,50.93 222.86,51.16 222.86,56.53 222.02,57.37 218.95,57.37 ; 223.09,50.93 v3(223.09,50.92) ; CH19.1 220.56,37.2 v3(220.56,36.62) ; CH32.1 220.49,38.99 v3(220.56,39.06) ; RC54.2 123.89,111.28 123.26,111.91 v3(121.92,111.91) 118.33,111.91 v3(117.41,111) 116.56,111 116.03,110.47 116.03,109.43 RC50.2 ; CH21.1 219.81,36.53 v3(219.9,36.62) ; v3(222.54,36.62) 222.54,36.03 CH27.1 ; CH45.1 223.16,41.99 v3(223.16,41.5) ; CH20.1 220.64,38.16 v3(220.56,38.25) ; CH40.1 223.47,48.86 v3(223.2,48.59) ; CH28.1 223.2,36.11 v3(223.2,36.62)
  TOP w1.524: 214.48,58.98 212.8,58.98 208.45,54.62 208.45,51.33 203.56,46.44 v2(203.56,44.35) 203.56,37.4
  IN1 w0.508: v3(147.69,95.8) 144.73,98.76 138.85,98.76 130.46,107.15 130.46,113.2 130.79,113.53 v3(131.07,113.53)
  IN2 w0.508: 226.07,38.23 228.13,38.23 229.87,39.97 229.87,44.82 230.39,45.34 230.39,46.67 229.68,47.39 224.41,47.39 v3(223.2,48.59) ; v3(117.41,111) 117.41,109.93 116.97,109.49 116.61,109.49 115.28,108.17 113.19,108.17 109.72,104.7 88.47,104.7 v3(87.16,106.01) ; v3(140.46,131.98) 142.42,131.98 145.93,128.48 145.93,122.01 142.43,118.51 136.26,118.51 135.95,118.2 133.91,118.2 131.07,115.35 v3(131.07,113.53) 130.38,113.53 129.58,112.73 129.58,110.69 128.44,109.55 125.43,109.55 123.07,111.91 v3(121.92,111.91)
  IN5 w1.524: 196.03,21.47 198.54,21.47 200.88,19.13 204.18,19.13 206.76,16.55 214.91,16.55 216.89,14.57 219.69,14.57 221.17,16.05 224.56,16.05 227.84,12.78 239.43,12.78 240.78,14.13 240.78,19.18
  BOTTOM w0.254: v3(225.81,36.65) 225.81,36.46 226.06,36.21 UH1.L17 ; UH1.AN34 216.85,42.75 216.83,42.77 216.83,43.19 216.85,43.21 UH1.AN35 216.76,43.38 216.33,43.81 216.33,44.38 v3(216.36,44.41) ; UH1.AK22 218.25,37.92 v3(218.58,38.25)
  BOTTOM w0.508: PR527.1 140.97,131.98 v3(140.46,131.98) ; 87.57,105.19 87.57,105.6 v3(87.16,106.01) ; CH26.1 223.19,50.83 223.09,50.93 v3(223.09,50.92)
  vias: v3(147.69,95.19) v3(148.33,95.8) v3(148.33,95.19) v3(148.96,95.8) v3(148.96,95.19) v3(149.6,95.8) v3(149.6,95.19) v3(194.01,23.12) v3(194.32,22.61) v3(194.64,23.12) v3(194.96,22.61) v3(195.28,23.12) v3(195.59,22.61) v3(195.91,23.12) v3(196.22,22.61) v3(203.9,36.1) v3(204.22,35.52) v3(204.48,36.1) v3(215.83,37.6) v3(216.48,37.61) v3(217.12,37.38) v3(217.13,36.58) v3(217.92,36.62) v3(219.9,39.84) v3(219.9,38.25) v3(220.6,39.84) v3(221.87,39.84) v3(222.57,41.49) v3(222.57,38.25) v3(223.2,38.25) v3(223.82,43.63) v3(223.83,36.62) v3(240.45,22.34) v3(240.41,21.74) v3(240.41,21.11) v3(240.98,20.6) v3(241.01,22.57) v3(241.01,21.93) v3(241.01,21.3) v3(241.3,23.08) v3(241.6,22.41) v3(241.62,21.81) v3(241.62,21.17) v3(241.62,20.54) v3(241.94,22.89) v3(242.38,22.44) v3(243.78,35.16) v3(243.78,34.57)
+1.05VS_VCC: length 1
  TOP w0.508: RH150.1 215.04,57.75 LH1.2
+1.05VS_VGA: length 14.4
  BOTTOM w0.305: UV1.AY35 v3(167.6,94.38) UV1.BA35 ; UV1.BB33 166.8,92.78 v3(166.81,92.78) ; UV1.BA27 167.2,88.35 v3(166.81,87.96) ; UV1.AY30 v3(168.4,91.18) ; UV1.AY26 v3(167.6,87.18) UV1.BA26 167.19,87.58 v3(166.81,87.96) ; v3(166.81,87.96) 166.4,88.37 UV1.BB27 ; UV1.BA33 167.2,93.17 v3(166.81,92.78) ; UV1.BB30 166.81,90.37 ; 166.81,90.37 v3(166.81,90.36) 167.19,89.98 UV1.BA29 v3(167.6,89.58) UV1.AY29 ; 166.81,90.37 167.2,90.76 UV1.BA30 ; UV1.AW33 168.8,93.18 v3(168.4,93.58) UV1.AY33 ; v3(166.81,92.78) 167.2,92.39 UV1.BA32 v3(167.6,91.98) UV1.AY32 ; UV1.AY24 v3(168.4,86.38) ; UV1.BA24 v3(166.8,86.38) UV1.BB24 ; UV1.AY27 v3(168.4,88.78) ; UV1.AW26 v3(169.4,87.18)
  vias: v2(158.99,97.44) v3(156.66,97.75) v3(156.59,96.12) v3(156.9,95.61) v3(157.23,97.32) v3(157.23,96.72) v3(157.22,96.12) v3(157.54,95.61) v3(157.67,97.77) v3(157.86,96.12) v3(158.17,95.61) v3(160.14,92.28) v3(165.21,97.59)
+1.05VS_VGAP: length 13.1
  TOP w0.127: v2(140.36,84.32) v3(140.36,83.33)
  IN5 w0.508: v3(141.96,93.02) 141.96,91.66 140.36,90.06 v3(140.36,83.33)
  BOTTOM w0.508: PR681.1 PC661.1 v3(140.36,83.33)
+1.5VSP: length 1.7
  TOP w0.127: v2(207.51,20.83) 206.82,20.83 206.3,21.35 PU401.1
+1.05VSP: length 11.7
  TOP w0.127: v2(245.35,23.4) 245.35,22.87 v3(245.11,22.63)
  IN2 w0.254: v3(239.14,28.73) 239.97,27.9 239.97,25.34 241.68,23.62 244.12,23.62 v3(245.11,22.63)
  BOTTOM w0.254: v3(239.14,28.73) 239.56,28.73 PR307.2
+1.05VSP_B+: length 1.1
  TOP w0.127: v2(249.49,29.21) 248.99,29.72 v3(248.6,29.72)
+1.35V: length 139.8
  TOP w0.508: RC12.2 92.65,55.31 v3(91.91,54.57) ; RD11.2 77.85,24.41 79.57,26.13 79.57,30.13 81.16,31.71 81.16,38.38 85.63,42.85 v3(85.63,44.6)
  IN3 w0.508: v3(91.91,54.57) 91.91,54.57 91.91,48.06 88.46,44.6 v3(85.63,44.6)
  BOTTOM w0.206: v3(111.97,27.17) 112.25,26.88 JDIMM2.105 ; JDIMM2.111 114.05,26.85 113.73,27.17 v3(113.16,27.17) ; v3(117.75,37.41) 117.64,37.51 JDIMM1.123 ; JDIMM1.99 110.44,37.36 v3(109.69,36.6) ; JDIMM2.99 110.45,24.09 v3(109.88,23.52)
  BOTTOM w0.356: JDIMM1.88 107.15,29.57 v3(106.81,29.24) ; v3(106.86,16.12) 107.15,16.41 JDIMM2.88 ; JDIMM2.117 115.85,26.85 115.85,27.04 v3(115.76,27.14) 116.15,27.52 JDIMM1.118 ; 114.11,16.03 114.35,16.27 JDIMM2.112 ; JDIMM2.93 108.65,27.08 108.02,27.71 v3(106.83,27.71) 106.83,27.15 106.85,27.13 JDIMM2.87 ; JDIMM1.106 112.54,29.66 v3(113.16,29.05) 113.92,29.05 114.34,29.47 JDIMM1.112 ; JDIMM1.105 112.24,37.4 v3(111.83,36.98) ; v3(108.79,16.24) 108.95,16.4 JDIMM2.94 ; JDIMM2.82 105.35,16.22 105.16,16.03 ; v3(117.74,16.24) 117.95,16.45 JDIMM2.124 ; JDIMM1.117 115.84,40.1 115.39,40.56 v3(113.9,40.56) 114.04,40.42 JDIMM1.111 ; JDIMM2.76 103.55,16.34 v3(103.39,16.18) ; JDIMM1.87 106.84,41.45 ; JDIMM2.81 105.05,27.19 104.46,27.78 v3(103.9,27.78) 103.25,27.13 JDIMM2.75 ; v3(118.04,27.18) 117.65,26.79 JDIMM2.123 ; JDIMM1.82 105.34,29.3 104.99,28.95 v3(103.86,28.95) 103.54,29.26 JDIMM1.76 ; v3(118.04,28.7) 117.94,28.8 JDIMM1.124 ; JDIMM2.106 112.55,15.8 112.46,15.71 ; JDIMM1.100 110.74,29.49 110.74,29.18 v3(110.81,29.11) 109.29,29.11 108.94,29.45 JDIMM1.94 ; JDIMM2.100 110.75,16.36 v3(110.57,16.18) ; JDIMM1.81 105.04,40.43 v3(104.14,41.33) 103.24,40.43 JDIMM1.75 ; 116.15,16.29 JDIMM2.118 ; JDIMM1.93 108.64,40.28
  BOTTOM w0.508: RD5.2 84.79,44.6 v3(85.63,44.6) 86.96,43.27 CD9.1
  vias: v2(135.12,26.43) v3(100.69,36.59) v3(100.69,35.06) v3(100.69,33.54) v3(100.69,32.02) v3(101.6,23.5) v3(101.6,21.98) v3(101.6,20.46) v3(103.04,36.59) v3(103.04,35.06) v3(103.04,33.54) v3(103.04,32.02) v3(103.59,21.98) v3(103.59,20.46) v3(104.14,42.6) v3(104.14,41.96) v3(105.04,35.93) v3(105.04,34.41) v3(105.04,32.89) v3(105.65,22.8) v3(105.65,21.28) v3(105.65,19.75) v3(106.05,43.09) v3(106.05,42.51) v3(106.02,41.92) v3(107.11,36.64) v3(107.11,35.12) v3(107.11,33.59) v3(107.83,23.11) v3(107.83,21.59) v3(107.83,20.07) v3(109.69,35.08) v3(109.69,33.55) v3(109.83,42.76) v3(109.83,42.12) v3(109.83,41.45) v3(109.83,40.85) v3(109.88,22) v3(109.88,20.47) v3(110.75,35.84) v3(110.84,28.18) v3(111.78,22.38) v3(111.78,20.09) v3(111.83,34.69) v3(111.97,29.2) v3(112.08,42.51) v3(112.08,40.22) v3(112.56,41.37) v3(112.79,21.24) v3(113.67,36.6) v3(113.67,35.08) v3(113.67,33.55) v3(113.73,23.52) v3(113.73,21.24) v3(113.73,19.71) v3(113.89,42.38) v3(113.89,41.77) v3(113.89,41.18) v3(115.78,36.86) v3(115.78,35.34) v3(115.78,33.81) v3(115.75,23.88) v3(115.78,22.35) v3(115.78,20.83) v3(117.68,41.71) v3(117.68,40.18) v3(117.75,35.12) v3(117.75,33.6) v3(118.08,23.15) v3(118.08,21.62) v3(118.08,20.1) v3(145.33,44.69) v3(145.33,42.03) v3(145.39,43.99) v3(145.39,43.36) v3(145.39,42.66) v3(145.9,44.38) v3(145.9,43.68) v3(145.9,43.04) v3(145.9,42.34) v3(145.9,41.71) v3(146.41,44.69) v3(146.41,44.06) v3(146.41,43.36) v3(146.47,42.66) v3(146.47,41.96)
+1.35V_CPU_VDDQ: length 52.5
  TOP w0.508: RC26.1 89.85,61.37 90.87,60.35 90.87,53.05 93.09,50.83 106.36,50.83
  BOTTOM w0.203: CPU1.AY18 116.52,75.68 116.32,75.48 116.32,74.82 116.13,74.63 116,74.63 115.81,74.44 115.81,72.63 CPU1.BE18
  BOTTOM w0.254: CPU1.AY18 116.88,75.69 v3(117.35,76.16) ; CPU1.BE30 108.85,72.28 108.85,72.79 CPU1.BD30 108.9,72.88 108.52,73.26 108.52,74.25 108.56,74.28 ; CPU1.BB34 105.61,74.28 v3(105.26,73.93) 104.91,74.28 CPU1.BB36 ; v3(111.76,71.86) 111.43,72.18 CPU1.BE26 111.31,72.25 111.31,72.82 CPU1.BD26 ; v3(108.84,76.73) 108.96,76.73 109.31,76.38 CPU1.AW29 ; v3(111.76,75.97) 112.18,76.38 CPU1.AW25 ; CPU1.BB31 108.56,74.28 ; 108.56,74.28 CPU1.BB30 ; CPU1.AT23 112.95,78.48 v3(112.69,78.74) ; CPU1.AT36 104.66,78.65 v3(104.94,78.93) ; CPU1.AR29 109.82,79.02 v3(110.29,79.02) 110.3,79 CPU1.AT27 ; CPU1.BB30 108.94,75.42 v3(108.89,75.47) ; CPU1.BB30 109.21,74.55 109.47,74.55 109.55,74.64 109.57,74.64 109.66,74.73 109.87,74.73 110.06,74.54 110.3,74.54 110.56,74.28 CPU1.BB27 CPU1.BB26 ; v3(120.17,78.12) 119.8,78.48 CPU1.AT13 ; CPU1.BD22 113.76,72.88 v3(113.38,72.5) 113.7,72.18 CPU1.BE22 ; v3(106.1,76.73) 106.23,76.73 106.54,76.42 CPU1.AW33 ; CPU1.BB22 113.82,74.28 v3(114.17,73.93) 114.28,73.93 CPU1.BB21 ; v3(114.52,76.16) 114.29,76.38 CPU1.AW22 ; v3(115.89,79.02) 115.94,78.97 CPU1.AT19 ; CPU1.BE33 106.5,72.18 v3(106.88,72.56) 106.55,72.88 CPU1.BD33 ; CPU1.AV37 103.6,77.08 103.29,76.77 v3(103.24,76.77) ; v3(108.9,78.91) 108.53,78.91 CPU1.AR31
  BOTTOM w0.305: CPU1.AR33 107.07,79.02 v3(107.49,79.02) 107.48,79.01 CPU1.AT32
  vias: v2(117.32,61.42)
+1.35V_PWRGD: length 119.4
  TOP w0.203: PR210.2 152.71,26.13 151.69,27.14 PU200.10
  TOP w0.508: v3(77.92,25.47) v2(77.92,28.37) 77.92,30.34 79.76,32.18 79.76,61.99 RC56.1 ; v3(153.35,25.43) 152.89,25.9 PR210.2
  IN3 w0.508: v3(153.35,25.43) 151.32,23.4 145.86,23.4 145.29,22.82 142.37,22.82 141.61,23.59 141.61,24.05 141,24.66 130.56,24.66 129.74,25.47 v3(77.92,25.47)
+1.35VP: length 43.9
  TOP w0.127: v3(150.37,31.97) v2(149.7,31.97)
  IN1 w0.254: v3(154.31,45.43) 149.1,45.43 147.02,43.35 147.02,38.94 148.53,37.43 148.53,33.49 147.77,32.73 147.77,28.73 v3(148.4,28.09)
  IN1 w1.016: 149.42,31.59 149.42,37.94 147.78,39.58 147.78,42.39 149.86,44.48 154.05,44.48
  vias: v3(150.37,31.33) v3(154.82,45.05)
+1.35VS_VGA: length 168.9
  TOP w0.203: UV15.L13 221.54,79.16 221.54,79.89 UV15.L14 ; UV15.G1 218.26,69.57 218.26,70.28 UV15.G2
  TOP w0.254: v3(214.19,80.69) 214.19,80.04 UV15.B14 ; UV6.M12 167.81,123.08 v3(167.81,123.03) ; UV6.C5 v3(172.61,115.88) ; UV6.G4 v3(173.41,119.88) ; v3(222.31,80.42) 222.31,79.93 UV15.M14 ; UV6.P12 v3(167.81,125.48) UV6.P11 ; v3(194.76,119.09) 194.37,119.48 UV8.L14 UV8.L13 UV8.M12 ; UV12.D12 v3(215.51,95.96) UV12.D11 ; v3(217.11,91.16) UV12.E5 ; UV6.T12 v3(167.81,127.08) ; UV6.M3 v3(175.01,123.08) ; UV12.M3 v3(221.91,89.56) UV12.L4 ; UV12.G2 v3(218.71,88.76) UV12.H3 ; UV12.B1 v3(213.91,87.16) ; UV6.H12 v3(167.81,119.88) UV6.G11 ; UV12.M14 222.31,97.96 v3(222.31,98.46) ; UV12.G1 218.31,87.18 v3(218.45,87.04) ; UV15.G1 218.45,69.38 v3(218.45,69.01) ; UV15.K3 v3(221.11,70.72) UV15.L2 ; v3(217.11,76.32) UV15.E10 ; UV6.K3 v3(175.01,122.28) UV6.L2 ; UV12.D1 215.91,86.95 v3(215.9,86.95) ; v3(217.11,77.92) UV15.F12 ; UV15.G2 v3(218.71,70.72) UV15.H3 ; v3(224.31,71.52) UV15.P3 ; UV15.P11 v3(224.31,77.92) UV15.P12 ; UV8.F12 v3(193.05,123.08) UV8.G13 ; UV6.P1 v3(176.61,125.48) ; UV6.L4 v3(174.21,122.28) ; UV6.C10 v3(169.41,116.68) ; v3(224.23,80.44) 223.91,80.12 UV15.P14 ; UV12.G14 v3(218.71,97.56) UV12.G13 ; v3(215.51,94.36) UV12.C10 ; UV6.B12 v3(167.01,115.08) ; UV12.L2 v3(221.11,88.76) UV12.K3 ; UV6.D3 v3(174.21,116.68) ; UV12.F1 v3(217.51,87.07) ; UV15.D3 v3(215.51,71.52) ; v3(224.31,89.56) UV12.P3 ; UV12.C5 v3(214.71,91.16) ; UV15.L4 v3(221.91,71.52) UV15.M3 ; v3(217.11,94.36) UV12.E10 ; UV8.F14 v3(194.65,123.08) UV8.G14 ; v3(217.11,73.12) UV15.E5 ; UV6.M1 v3(176.61,123.08) UV6.L1 ; UV12.F3 v3(217.91,89.56) UV12.G4 ; UV15.D12 v3(215.51,77.92) UV15.D11 UV15.C10 v3(215.51,76.32) ; v3(194.73,116.82) 194.51,116.82 UV8.P14 ; UV15.K12 v3(221.11,78.72) UV15.L13 UV15.M12 v3(221.91,77.92) UV15.L11 ; v3(218.71,96.76) UV12.H12 UV12.G11 ; UV15.B3 v3(213.91,71.52) ; v3(225.91,71.52) UV15.T3 ; v3(217.75,80.44) 217.51,80.2 UV15.F14 ; UV15.G14 v3(218.71,79.52) UV15.G13 ; UV6.F12 v3(167.81,118.28) ; UV12.B12 v3(213.91,96.76) ; UV15.L2 v3(221.11,69.92) UV15.L1 221.51,69.49 v3(221.98,69.01) 222.18,69.21 222.18,69.39 UV15.M1 UV15.L2 ; UV15.N10 v3(223.51,76.32) ; UV15.H12 v3(218.71,77.92) UV15.G11 ; UV15.C5 v3(214.71,73.12) ; UV15.B12 v3(213.91,78.72) ; v3(176.61,117.48) UV6.D1 ; UV6.K12 v3(167.81,122.28) UV6.L11 ; v3(217.65,98.51) 217.51,98.36 UV12.F14 ; UV12.D3 v3(215.51,89.56) ; UV12.L11 221.51,95.56 v3(221.91,95.96) UV12.M12 ; UV6.E5 v3(172.61,117.48) ; UV15.F3 v3(217.91,71.52) UV15.G4 ; v3(217.11,96.76) UV12.F12 ; v3(225.91,89.56) UV12.T3 ; v3(221.11,98.36) UV12.L14 ; UV6.T3 v3(175.01,127.08) ; UV15.F1 v3(217.51,69.03) ; UV12.K12 v3(221.11,96.76) UV12.L13 ; v3(225.11,76.32) UV15.R10 ; UV15.D14 v3(215.91,80.64) ; UV12.B3 v3(213.91,89.56) ; UV12.T12 v3(225.91,96.76) ; UV15.L14 v3(221.11,80.32) ; v3(225.91,78.72) UV15.T12 ; UV6.P3 v3(174.21,125.48)
  TOP w0.381: v3(211.71,83.59) 211.33,83.98 RV148.1 ; v3(209.34,69.59) 209.74,69.18 RV152.1
  TOP w0.508: CV288.1 215.7,65.8 CV180.1 216.18,65.79 v3(216.61,66.21) 216.95,65.87 CV291.1 ; RV189.1 CV154.1 163.14,132.91 163.54,132.52 v3(163.54,132.29) ; RV150.1 211.06,64.94 v3(210.57,65.43) ; CV290.1 v3(215.89,84.12)
  IN4 w0.4: v3(184.4,98.18) 184.1,98.18 183.3,97.38 v3(182.8,97.38)
  IN6 w0.381: v3(193.05,115.88) v3(192.25,116.68)
  BOTTOM w0.254: UV15.G4 v3(217.91,71.52) UV15.F3 ; UV6.F1 176.26,118.72 176.26,119.43 UV6.G1 v3(176.61,119.88) ; v3(165.3,117.08) UV7.D1 ; v3(217.11,91.16) UV12.E5 ; UV12.E10 v3(217.11,94.36) ; UV6.T3 v3(175.01,127.08) ; v3(169.41,126.28) UV6.R10 ; UV15.F12 v3(217.11,77.92) ; v3(169.41,123.88) UV6.N10 ; UV8.H12 v3(192.25,122.28) ; UV8.N5 v3(187.45,118.28) ; UV6.H3 v3(175.01,119.88) UV6.G2 ; UV8.K12 UV8.L11 v3(191.45,119.08) ; UV8.R5 187.25,116.07 v3(187.66,116.07) ; v3(215.91,69.01) UV15.D1 ; UV8.B12 v3(193.05,127.08) ; v3(217.11,73.12) UV15.E5 ; v3(218.45,87.04) 218.45,87.42 UV12.G1 ; UV15.G11 v3(218.71,77.92) UV15.H12 ; UV8.N10 v3(190.65,117.48) ; UV12.M3 v3(221.91,89.56) UV12.L4 ; UV15.C5 v3(214.71,73.12) ; UV6.E5 v3(172.61,117.48) ; UV15.E10 v3(217.11,76.32) ; UV6.C10 v3(169.41,116.68) ; UV12.C10 v3(215.51,94.36) ; UV6.F3 v3(175.01,119.08) ; v3(213.91,87.16) UV12.B1 ; UV6.L4 v3(174.21,122.28) ; UV8.T3 v3(185.05,115.88) ; UV15.L2 v3(221.11,70.72) UV15.K3 ; UV12.D12 v3(215.51,95.96) UV12.D11 ; UV8.H3 v3(185.05,122.28) ; v3(213.91,96.76) UV12.B12 ; UV15.L4 v3(221.91,71.52) UV15.M3 ; UV6.C5 v3(172.61,115.88) ; UV6.D3 v3(174.21,116.68) UV7.D11 ; UV8.G11 v3(191.45,123.08) ; UV8.M12 UV8.L13 UV8.L14 194.37,119.48 v3(194.76,119.09) 194.35,118.68 UV8.M14 ; v3(221.11,69.92) UV15.L1 ; UV8.B3 v3(185.05,126.28) ; UV15.B12 v3(213.91,78.72) ; UV12.G4 v3(217.91,89.56) UV12.F3 ; v3(167.81,118.28) UV6.F12 ; v3(215.9,86.95) 215.91,86.95 UV12.D1 ; v3(222.23,87.04) 222.23,87.48 UV12.M1 ; UV8.F1 183.42,123.48 v3(183.35,123.41) ; v3(213.91,89.56) UV12.B3 ; UV8.T12 v3(193.05,115.88) ; UV15.G1 218.45,69.38 v3(218.45,69.01) ; UV15.G13 v3(218.71,79.52) UV15.G14 UV15.F14 217.51,80.2 v3(217.75,80.44) ; v3(167.81,125.48) UV6.P12 ; UV8.G1 183.93,122.68 v3(184.24,122.37) 184.56,122.68 UV8.G2 ; v3(165.3,115.48) UV7.B1 ; UV15.G2 v3(218.71,70.72) UV15.H3 ; v3(169.41,118.28) UV6.E10 ; UV12.G2 v3(218.71,88.76) UV12.H3 ; UV12.K3 v3(221.11,88.76) ; v3(217.51,87.07) UV12.F1 ; UV8.G4 v3(185.85,123.08) UV8.F3 ; UV6.P3 v3(174.21,125.48) UV7.P11 ; 222.31,80.42 v3(222.31,80.42) ; UV8.M3 v3(185.85,119.08) UV8.L4 ; UV6.B3 v3(175.01,115.08) ; UV15.B3 v3(213.91,71.52) ; v3(215.51,89.56) UV12.D3 ; v3(172.43,126.01) 172.88,126.01 UV6.R5 ; UV6.N5 v3(172.46,124.28) ; v3(214.19,80.69) 214.19,80.04 UV15.B14 ; UV8.P3 v3(185.85,116.68) ; v3(167.81,116.68) UV6.D12 ; UV6.G4 v3(173.41,119.88) ; v3(217.51,69.03) UV15.F1 ; UV6.B1 v3(176.61,115.88) ; UV8.D3 v3(185.85,125.48) ; UV8.D1 v3(183.33,125.08) ; v3(167.81,127.08) UV6.T12 ; v3(214.71,91.16) UV12.C5 ; UV6.D1 v3(176.61,117.48) ; v3(167.01,115.08) UV6.B12 ; UV15.D3 v3(215.51,71.52)
  BOTTOM w0.381: RV113.1 193.82,108.78 v3(193.6,108.56)
  BOTTOM w0.508: CV274.1 CV272.1 214.12,82.96 v3(213.78,82.63) ; RV109.1 166.04,109.55 v3(165.28,109.55) ; CV156.1 CV201.1 v3(178.95,126.65) ; v3(187.01,110.9) 186.77,110.66 RV110.1 ; CV290.1 v3(215.89,84.12) ; v3(209.34,69.59) 209.34,68.26 211.34,66.26 216.56,66.26 216.6,66.21 ; RV203.1 216.6,66.21 ; 216.6,66.21 v3(216.61,66.21) ; v3(178.63,117.52) 178.87,117.28 CV227.1 CV247.1 ; CV246.1 CV228.1 v3(178.62,115.5) ; v3(181.23,118.84) 180.47,119.59 RV131.2 ; v3(171.41,129.87) 171.62,130.08 CV221.1 ; RV147.1 v3(211.71,83.59)
  vias: v2(221.95,106.29) v3(157.68,110.35) v3(157.68,109.71) v3(157.68,109.08) v3(157.68,108.44) v3(157.68,107.81) v3(157.68,107.17) v3(157.68,106.54) v3(157.68,105.9) v3(157.68,105.27) v3(157.67,104.68) v3(157.67,104.04) v3(157.67,103.41) v3(158.25,110.6) v3(158.25,109.97) v3(158.25,109.33) v3(158.25,108.7) v3(158.25,108.06) v3(158.25,107.43) v3(158.25,106.79) v3(158.25,106.16) v3(158.25,105.52) v3(158.25,104.89) v3(158.24,104.29) v3(158.24,103.66) v3(158.24,103.02) v3(158.8,109.63) v3(158.82,108.99) v3(158.82,108.36) v3(158.82,107.72) v3(158.82,107.09) v3(158.82,106.45) v3(158.82,105.82) v3(158.82,105.18) v3(158.82,104.55) v3(158.82,103.91) v3(158.82,103.28) v3(158.82,102.64) v3(163.32,126.16) v3(163.39,118.86) v3(163.39,117.9) v3(163.39,116.95) v3(163.39,116) v3(163.39,115.05) v3(163.39,114.09) v3(164.29,127.89) v3(165.3,125.08) v3(165.3,118.68) v3(165.41,127.08) v3(166.21,123.03) v3(166.21,119.88) v3(166.91,130.65) v3(174,98.18) v3(174.8,98.18) v3(174.8,97.04) v3(175.15,130.67) v3(175.58,97.06) v3(176.61,127.08) v3(178.4,97.1) v3(178.63,129.25) v3(178.63,128.67) v3(178.95,124.81) v3(178.95,96.86) v3(179.35,128.98) v3(179.6,97.38) v3(179.6,96.78) v3(179.6,76.18) v3(179.86,123.6) v3(179.99,128.98) v3(180.4,97.38) v3(180.4,96.78) v3(180.4,75.38) v3(180.56,123.6) v3(180.62,128.98) v3(181.26,128.98) v3(181.2,98.18) v3(181.2,97.38) v3(181.97,76.39) v3(183.26,119.4) v3(183.33,117.08) v3(183.33,115.48) v3(183.45,127.08) v3(184.4,76.78) v3(184.4,76.18) v3(185.05,119.88) v3(185.2,98.18) v3(185.2,97.38) v3(185.2,76.78) v3(185.2,76.18) v3(186,98.18) v3(186,97.38) v3(186,96.78) v3(186.8,97.38) v3(186.8,76.78) v3(186.8,76.18) v3(187.45,126.28) v3(187.6,97.37) v3(187.6,76.78) v3(187.6,76.18) v3(188.19,124.59) v3(189.2,97.44) v3(189.2,76.18) v3(189.9,77.08) v3(190,94.38) v3(190,93.58) v3(190,91.98) v3(190,91.18) v3(189.99,89.56) v3(189.99,88.8) v3(190,82.38) v3(190,81.58) v3(190,79.98) v3(190,79.18) v3(190.49,124.38) v3(190.4,77.58) v3(190.51,126.22) v3(190.6,94.38) v3(190.6,93.58) v3(190.6,91.98) v3(190.6,91.18) v3(190.6,89.58) v3(190.6,88.78) v3(190.6,86.38) v3(190.59,85.56) v3(190.6,84.78) v3(190.6,82.38) v3(190.6,81.58) v3(190.6,79.98) v3(190.6,79.18) v3(191.45,116.68) v3(191.4,91.98) v3(191.4,91.18) v3(191.4,89.58) v3(191.4,87.18) v3(191.56,99.09) v3(192.25,125.48) v3(192.4,99.98) v3(192.4,99.18) v3(192.4,98.38) v3(192.4,96.78) v3(193.2,100.69) v3(193.2,99.18) v3(194,100.78) v3(194.65,127.08) v3(194.76,125.4) v3(194.73,115.6) v3(194.8,100.78) v3(195.6,102.38) v3(195.6,101.58) v3(195.6,100.78) v3(196.4,103.18) v3(196.4,102.38) v3(197.2,103.98) v3(197.2,103.18) v3(197.2,102.38) v3(198,103.98) v3(198,103.18) v3(209.35,60.76) v3(209.8,61.21) v3(209.8,60.31) v3(210.25,61.66) v3(210.25,60.76) v3(210.57,107.53) v3(210.7,62.11) v3(210.7,61.21) v3(210.82,106.96) v3(211.08,100.96) v3(211.15,62.55) v3(211.15,61.66) v3(211.2,107.53) v3(211.46,106.96) v3(211.6,62.11) v3(211.84,107.53) v3(212.09,106.96) v3(212.35,103.15) v3(212.47,107.53) v3(212.73,106.96) v3(213.11,107.53) v3(213.39,60.97) v3(213.39,60.34) v3(213.89,100.97) v3(214.02,60.97) v3(214.02,60.34) v3(214.32,69.03) v3(214.51,98.45) v3(214.66,60.34) v3(215.78,98.47) v3(221.38,87.08) v3(222.71,91.16) v3(222.71,73.12) v3(223.46,84.86) v3(223.51,94.36) v3(223.91,87.04) v3(223.91,69.01) v3(223.9,65.1) v3(223.9,64.47) v3(223.9,63.83) v3(224.23,98.41) v3(224.31,95.96) v3(224.54,65.1) v3(224.54,64.47) v3(224.54,63.83) v3(224.98,84.86) v3(225.11,94.36) v3(225.11,91.16) v3(225.11,73.12) v3(225.17,65.1) v3(225.17,64.47) v3(225.17,63.83) v3(225.38,98.54) v3(225.38,80.5) v3(225.51,87.04) v3(225.51,69.01) v3(225.81,65.1) v3(225.81,64.47) v3(225.81,63.83) v3(226.44,65.1) v3(226.44,64.47) v3(226.82,84.82) v3(227.52,84.87) v3(227.87,63.82) v3(227.87,63.18) v3(228.3,82.29) v3(228.3,81.27) v3(228.3,80.25) v3(228.51,89.56) v3(228.51,88.54) v3(228.51,87.52) v3(228.51,86.51) v3(228.5,64.45) v3(228.5,63.82) v3(228.5,63.18) v3(228.68,74.65) v3(228.67,73.22) v3(228.67,72.38) v3(228.67,71.74) v3(228.67,71.11) v3(228.67,70.47) v3(228.67,69.84) v3(228.67,69.2) v3(228.68,68.2) v3(228.68,67.58) v3(228.69,76.71) v3(230.7,101.06) v3(231.15,100.62) v3(231.59,100.17)
+1.35VS_VGA_PGOOD: length 39.4
  TOP w0.127: v3(132.37,107.67) v1(130.74,109.3)
  IN2 w0.119: v3(144.19,79.11) 141.19,79.11 135.64,84.66 135.64,89.78 134.85,90.57 134.85,94.2 136.15,95.49 136.15,99.67 134.77,101.04 134.77,103.86 132.37,106.26 v3(132.37,107.67)
  BOTTOM w0.157: RV56.2 v3(144.19,79.11)
+1.35VS_VGAP: length 41
  TOP w0.127: v3(131.07,112.91) 131.61,112.91 v2(131.85,112.66)
  IN1 w0.254: v3(155.26,117.31) 152.28,114.33 152.28,107.19 150.78,105.69 142.24,105.69 141.87,106.06 139.21,106.06 138.86,105.71 133.32,105.71 131.57,107.46 131.57,112.4 v3(131.07,112.91)
  BOTTOM w0.254: v3(131.07,112.91) 130.94,112.78 PR319.1
+1.35VS_VGAP_B+:
  vias: v2(151.18,106.47) v3(148.62,107.02) v3(150.18,107.02)
+1.35VS_VGAP_B++: length 18.7
  TOP w2.286: 141.84,61.05 149.72,53.16 157.24,53.16 157.25,53.15
  vias: v2(147.03,102.19)
+3.3V_ALW_PCH_JTAG: length 5
  BOTTOM w0.127: v1(222.9,18.35) 223.29,18.75 RH17.2
  BOTTOM w0.508: RH21.1 RH19.1 RH23.1 222.63,20.21 RH17.2
+3.3V_AVDD: length 10
  TOP w0.203: 20.46,10.34 20.46,11.1 20.53,11.17 UA1.38
  TOP w0.254: 20.46,10.34 20.32,10.2
  TOP w0.508: 20.32,10.2 20.28,10.16 CA7.2 19.69,9.65 v3(19.59,9.55)
  BOTTOM w0.254: UA3.16 4.44,11.31 4.65,11.52 5.2,11.52 5.42,11.29 v3(5.42,10.97) ; v3(2.4,11.13) 2.4,11.25 2.58,11.43 2.83,11.43 2.93,11.33 UA3.13
  BOTTOM w0.508: RA41.2 RA44.2 4.97,14.44 v3(5.39,14.44) ; RA114.1 8.66,12.7 v3(9.08,13.12) ; v3(9.29,14.58) 9.01,14.86 RA115.1 ; v3(15.12,11.77) 14.62,12.27 RA43.2
  vias: v1(15.71,10.53) v3(18.71,10.34)
+3.3V_DVDD: length 49.1
  TOP w0.127: v3(19.89,23.27) 20.53,23.91 v1(20.53,24.28)
  TOP w0.203: v3(26.05,10.21) 26.08,10.18 UA6.14 ; v3(23.88,17.02) 23.86,17 UA1.54
  TOP w0.508: LA9.1 19.61,22.99 v3(19.89,23.27)
  IN2 w0.508: v3(23.88,17.02) 22.4,17.02 21.41,18.01 17.13,18.01 14.62,20.52 14.62,21.18 v3(14.01,21.79)
  IN3 w0.508: v3(19.89,23.27) 18,23.27 17.45,23.81 16.04,23.81 v3(14.01,21.79) 14.01,19.79 13.13,18.91 13.13,18.54 12.26,17.67 12.26,16.45 12.61,16.09 13.99,16.09 v3(14.26,15.82)
  IN4 w0.508: v3(14.26,15.82) 14.61,15.82 15.79,14.65 15.79,13.11 16.59,12.31 19.42,12.31 20.33,11.39 21.73,11.39 22.07,11.05 24.26,11.05 25.1,10.21 v3(26.05,10.21)
  BOTTOM w0.254: v3(14.26,15.82) 14.75,15.33 15.76,15.33 LA10.1
  BOTTOM w0.508: v3(23.88,17.02) 23.77,17.13 CA1.2
+3.3V_F347: length 272.5
  TOP w0.254: 222.23,115.27 222.2,115.27 221.22,116.24 UE3.27
  TOP w0.508: RE40.1 RE43.1 v3(223.84,117.96) ; 222.23,115.27 CE24.1 222.3,114.9 222.68,114.52 224.98,114.52 v3(225.41,114.09) ; RE25.1 v3(219.89,110.5)
  IN2 w0.508: v3(223.84,117.96) 224.18,117.96 225.41,116.73 v3(225.41,114.09) 225.47,114.03 225.47,106.98 229.6,102.84 234.42,102.84 235.46,101.81 235.46,71.29 234.96,70.79 234.96,66.91 234.49,66.45 234.49,64.91 233.9,64.31 233.9,61.14 234.91,60.12 234.91,57.93 237.31,55.53 241.56,55.53 251.49,45.6 251.49,42.53 251.42,42.47 ; 181.41,14.37 191.21,14.37 192.32,15.47 201.14,15.47 201.54,15.86 201.54,16.03 201.25,16.32 191.65,16.32 191.61,16.28 183.17,16.28 182.22,15.33 181.71,15.33
  IN2 w1.016: 258.87,20.53 256.1,17.76 249.76,17.76 248.63,16.63 242.97,16.63 241.1,18.49 237.01,18.49 236.54,18.96 233.68,18.96 228.13,13.41 220.46,13.41 219.65,14.23 215.28,14.23 213.95,15.56 203.08,15.56 202.77,15.86 201.54,15.86 ; 263.06,21.25 266.69,21.25 268.3,22.86 268.3,28.42 269.05,29.17 269.05,30.93 269.86,31.74 269.86,33.77
  IN3 w0.508: v3(219.89,110.5) 221.91,110.5 222.57,111.17 224.33,111.17 225.41,112.24 v3(225.41,114.09)
  IN6 w0.508: v3(269.76,34.95) 265.74,34.95 v3(260.77,39.92)
  BOTTOM w0.508: v3(269.76,34.95) 269.46,34.95 RE7.1 ; RE16.1 272.46,20.69 RE8.1 RE17.1 272.49,18.57 272.49,18.31 RE21.1 272.64,18.17 273.81,18.17 274.64,17.34 274.64,16.47 272.8,14.63 268.78,14.63 RE23.1 265.73,17.68 263.85,17.68 RE15.1 261.72,19.81 v3(261.72,21.47) ; JELC1.1 179.55,18.04 180.01,17.58 180.01,15.71 v3(180.34,15.38)
  vias: v2(255.06,39.94) v3(250.83,42) v3(252.9,39.97) v3(258.94,22.1) v3(258.94,21.47) v3(259.72,40.55) v3(260.15,40.11)
+3.3V_F347_1: length 308.6
  TOP w0.254: UE4.27 153.57,17.76 CE25.1
  TOP w0.356: QE16.5 221.96,112.22 221.48,111.74 v3(221.48,111.37)
  TOP w0.381: RE46.1 224.92,112.22 QE16.2
  TOP w0.508: v3(153.33,22.74) 153.93,22.14 RE26.1 ; RE6.2 256.5,36.65 v3(256.62,36.65) v2(260.07,36.65) 261.22,36.65 RE18.1 ; v3(221.48,111.37) 221.12,111.01 RE47.1 ; CE25.1 153.85,18.19 v3(153.39,18.65) ; v3(152.81,15.23) 152.67,15.09 RE32.1 ; v3(224.77,113.15) 225.06,112.85 RE46.1
  IN2 w0.508: v3(213.11,121.82) 212.65,121.37 212.65,113.91 213.79,112.77 215.89,112.77 217.64,111.01 219.09,111.01 219.45,111.37 v3(221.48,111.37) 221.63,111.22 221.63,107.09 224.91,103.81 224.91,102.92 233.72,94.11 233.72,72.09 233.28,71.64 233.28,67.58 233,67.3 233,66.18 231.68,64.86 231.68,59.95 236.96,54.67 240.96,54.67 247.8,47.82 247.8,39.76 249.06,38.51 251.46,38.51 252.64,37.33 255.95,37.33 v3(256.62,36.65)
  IN3 w0.508: v3(256.62,36.65) 256.62,34.44 255.74,33.57 245.48,33.57 239.96,28.05 239.96,26.62 238.27,24.93 238.27,24.3 237.21,23.24 237.21,20.72 235.61,19.13 233.43,19.13 232.07,17.77 228.31,17.77 228.04,18.04 226.9,18.04 226.58,17.72 226.58,16.49 226.2,16.11 225.24,16.11 224.61,16.73 217.82,16.73 217.31,17.24 206.36,17.24 205.12,18.48 200.87,18.48 200.13,17.74 193.17,17.74 191.51,16.08 180.11,16.08 179.05,15.01 175.05,15.01 173.47,13.44 170.58,13.44 169.28,14.73 167.96,14.73 167.62,15.08 159.91,15.08 158.99,15.99 157.47,15.99 157.04,16.42 155.62,16.42 v3(153.39,18.65) ; v3(224.77,113.15) 223.66,112.04 222.15,112.04 v3(221.48,111.37)
  IN5 w0.508: v3(153.39,18.65) 153.39,15.81 v3(152.81,15.23) ; v3(183.14,133.61) 183.14,133.61 182.89,133.86 v3(182.89,136.92)
  IN6 w0.508: v3(182.89,136.92) 183.73,136.08 186.16,136.08 187.25,134.99 189.4,134.99 190.57,133.82 194.02,133.82 194.22,134.03 196.18,134.03 200.9,129.31 203.52,129.31 209.58,123.26 211.67,123.26 v3(213.11,121.82)
  BOTTOM w0.254: UE8.27 183.49,138 CE53.1
  BOTTOM w0.508: RE45.1 183.68,138.46 183.5,138.28 CE53.1 183.5,137.3 183.12,136.92 v3(182.89,136.92) ; v3(183.14,133.61) 183.14,133.6 RE35.1 ; v3(153.33,22.74) 153.33,18.71 v3(153.39,18.65)
+3.3V_GFX_AON: length 69.8
  TOP w0.508: v3(170,91.18) 170,90.39 CV123.1 ; RV191.2 166.79,52.2 v3(166.52,52.47) ; CV122.1 170.75,91.75 170.22,91.75 v3(170,91.98) ; RV192.2 163.59,54.27 163.11,53.79 v3(163.03,53.79)
  IN2 w0.508: v3(161.63,53.06) 162.36,53.79 v3(163.03,53.79) 163.2,53.79 164.75,52.24 166.3,52.24 v3(166.52,52.47)
  IN5 w0.508: v3(157.1,78.95) 158.73,80.57 167.26,80.57 167.58,80.26 v3(167.58,79.95) 168.58,79.95 v3(168.58,79.96) ; v3(156.19,58.4) 156.67,57.91 156.67,56.8 155.82,55.95 155.82,53.71 157.44,52.08 160.66,52.08 v3(161.63,53.06) ; v3(144.15,77.61) 145.91,79.38 151.84,79.38
  IN6 w0.508: v3(167.58,79.95) 167.58,79.96 v3(168.58,79.96) 168.58,80.67 170.13,82.22 170.13,87.75 169.38,88.5 169.38,89.93 170,90.55 v3(170,91.18) v3(170,91.98)
  BOTTOM w0.254: UV1.AW17 v3(168.58,79.96)
  BOTTOM w0.305: UV1.AW32 169.4,91.98 v3(170,91.98) ; v3(170,91.18) 169.4,91.18 UV1.AW30 ; UV1.AY17 v3(167.58,79.95)
  BOTTOM w0.508: RV530.1 v3(155.77,77.62) ; v3(152.73,66.5) 152.57,66.66 RV39.1 ; RV548.1 161.97,52.73 v3(161.63,53.06) ; RV55.2 156.19,62.02 v3(156.19,61.08) ; v3(151.74,71.66) 151.93,71.85 RV219.2 ; v3(156.19,58.4) 156.19,58.13 158.69,55.63 RV547.1 ; v3(144.15,77.61) 144.86,76.9 RV62.2
  vias: v2(151.32,76.9) v3(151.93,78.26) v3(151.93,77.62) v3(151.89,61.57) v3(151.89,60.96) v3(152.5,61.57) v3(152.49,60.96) v3(155.59,59.15) v3(155.59,58.54) v3(156.19,59.01) v3(156.48,78.95)
+3V_PCH: length 87.3
  TOP w0.089: v3(223.19,39.08) v2(222.58,39.08)
  TOP w0.254: RPH7.6 220.54,23.55 220.19,23.2 220.19,22.9 220.03,22.74 v3(219.71,22.74) 219.71,23.33 220.04,23.66 RPH7.5 ; RPH7.7 221.04,23.49 220.72,23.17 v3(220.72,22.75) 220.84,22.75 221.54,23.45 RPH7.8 ; RPH4.5 226.52,23.1 226.79,22.84 v3(226.9,22.84) 226.99,22.93 226.99,23.56 RPH4.6 ; v3(220.27,33.6) 220.48,33.6 221.15,32.93 221.15,31.4 220.18,30.43 CH54.1 ; RPH4.8 228.02,23.23 v3(227.71,22.93) 227.52,23.12 RPH4.7
  TOP w0.381: CH41.1 223.19,37.49 223.86,38.17 v3(223.86,38.25)
  TOP w0.457: CH25.1 219.67,40.54 219.24,40.97 v3(219.24,41.5) ; v3(235.24,34.83) 235.24,35.27 RH145.1
  TOP w0.508: v3(228.49,15.98) 228.46,16 RH99.1 ; RH30.1 218.44,20.26 v3(218.44,21.58) 218.51,21.64 RH123.2 ; v3(214.61,22.84) 214.77,23 RH74.2 ; v3(223.86,39.87) 223.61,39.87 223.25,40.23 CH39.1 ; RH97.1 224.3,21.95 v3(223.52,22.74) 223.51,22.74 223.59,22.81 RH37.1 RH76.2 ; v3(230.88,39.69) 230.88,39.63 CH46.1 ; CH48.1 227.34,33.15 v3(226.79,32.59) ; RH100.1 225.43,22.91 v3(225.49,22.85) ; v3(237.66,40.25) 236.1,40.25 235.69,39.84 RH6.1
  IN4 w0.254: v3(220.27,33.6) 220.27,33.91 220.66,34.3 224.03,34.3 224.28,34.04 224.28,32.92 224.61,32.59 v3(226.79,32.59)
  IN4 w0.508: v3(230.88,39.69) 231.43,40.25 v3(237.66,40.25)
  IN6 w0.508: v3(228.49,15.98) 228.49,17.12 226.39,19.22 v3(225.36,19.22)
  BOTTOM w0.254: UH1.K8 226.4,32.2 v3(226.79,32.59) ; UH1.AD12 220.67,33.99 v3(220.27,33.6) ; RPH4.7 227.52,23.12 v3(227.71,22.93) 228.02,23.23 RPH4.8 ; RPH4.6 227.02,22.96 v3(226.9,22.84) 226.79,22.84 226.52,23.1 RPH4.5 ; v3(230.88,39.69) 230.57,39.69 230.49,39.61 UH1.A26
  BOTTOM w0.381: v3(214.61,22.84) 214.61,22.09 214.43,21.91 214.43,20.6 RH106.1
  BOTTOM w0.508: v3(223.53,20.4) 223.59,20.46 RH73.1 RH81.1 RH80.1 ; RH60.1 235.16,37.12 v3(235.16,36.73) ; RH75.1 219.76,22.68 v3(219.71,22.74) 219.71,23.43 RH77.1 ; RH83.2 225.44,22.9 v3(225.49,22.85) ; v3(208.36,21.43) 208.46,21.53 208.46,21.97 RH107.2 ; v3(220.72,22.75) RH82.1 ; RH17.1 225.02,19.22 v3(225.36,19.22) ; v3(221.87,17.54) 221.87,16.55 220.76,15.45 RH105.1 220.6,14.82 219.95,14.18 217.74,14.18 CH10.1 216.42,14.25 214.37,14.25 213.86,14.76 213.02,14.76 212.47,15.31 212.47,15.58 212.16,15.9 UH4.8 ; RH126.2 211.54,23.22 v3(211.54,22.89) ; RH31.1 RH101.1 228.16,17.38 228.49,17.05 v3(228.49,15.98)
  vias: v3(219.13,18.11) v3(219.72,18.11) v3(220.31,18.1)
+3VALW: length 541.9
  TOP w0.203: CE29.1 288.36,10.63 288.4,10.67 UE5.96 ; CE31.2 286.12,29.41 286.12,29.3 285.2,28.38 UE5.9 ; CE32.2 279.4,28.91 280,28.32 UE5.22 ; UE5.33 272.32,25.85 RE68.2 ; CE30.1 291.54,25.71 291.54,25.17 291.02,24.65 UE5.125
  TOP w0.254: UE6.24 237.56,44.27 237.45,44.16 236.54,44.16 CE56.1
  TOP w0.356: CC30.1 88.52,64.69 UC1.5
  TOP w0.457: CM28.2 v3(155.7,20.28)
  TOP w0.508: RE64.2 273.5,7.72 274.13,7.09 v3(275.66,7.09) 275.78,7.21 LE1.1 ; v3(298.61,26.48) 298.61,25.27 299.56,24.32 PR24.2 ; v3(240.67,39.07) 240.67,39.79 RE91.1 ; PR210.1 152.71,24.56 v3(153.3,23.97) ; v3(240.65,33.57) 240.15,33.57 239.63,33.05 239.63,32.56 239.21,32.15 237.25,32.15 236.23,33.16 235.64,33.16 235.02,33.79 RH141.1 ; RE102.2 235.54,45.37 v3(236.01,44.9) 236.45,44.45 CE56.1 ; PR709.2 48.04,39.09 PR710.1 48.41,39.1 48.74,39.44 48.74,40.52 49.18,40.95 49.18,41.59 48.3,42.47 v3(47.82,42.47) ; v3(272.16,26.46) 271.71,26 RE68.2 ; CC30.1 88.64,65.51 87.94,66.21 v3(81.76,66.21) ; v3(81.76,64.26) 82.21,64.26 82.67,64.72 RC24.1 ; CE32.2 279.06,29.48 278.74,29.8 278.74,31.5 v3(278.77,31.52) ; v3(286.7,29.11) 286.7,29.73 CE31.2 ; v3(280.91,31.55) 280.91,30.66 RE94.1 RE93.1 ; v3(291.53,26.38) CE30.1 ; v3(289.31,8.04) 292.36,8.04 v2(292.78,8.47) 293.19,8.88 RE79.1 ; v3(71.79,26.88) 71.79,26.88 PR16.2 ; v3(289.24,10.38) RE70.1 CE29.1 ; v3(288.48,34.95) 288.1,34.57 PR3.2 ; PR718.2 v3(47.98,35.7)
  TOP w1.524: 201.03,19.85 199.69,18.51 199.69,14.39 203.57,10.52 207.77,10.52 211.79,6.5 218.89,6.5 221.15,8.77 221.71,8.77 223.32,10.38 231.42,10.38 232.93,8.87 232.93,7.8 234.02,6.71 241.23,6.71 244.35,9.83 244.35,21.3 243.97,21.68 243.97,24.03 242.78,25.22 242.78,28.78 243.91,29.91 243.91,30.92 245.97,32.98 247.46,32.98 249.24,34.76
  IN1 w0.508: v3(275.66,7.09) 275.87,7.3 v3(280.02,7.3) ; v3(278.77,31.52) 278.77,31.84 279.14,32.21 280.57,32.21 280.91,31.87 v3(280.91,31.55) 280.91,30.33 281.37,29.87 285.94,29.87 v3(286.7,29.11) ; v3(289.24,10.38) 288.63,9.77 283.36,9.77 281.59,7.99 v3(280.02,7.99)
  IN1 w1.524: 269.34,30.28 268.8,30.82 264.92,30.82 261.04,34.71 256.87,34.71 255.48,36.11 255.48,36.13
  IN2 w0.508: v3(47.98,35.7) 46.87,35.7 46.06,34.9 45.38,34.9 44.68,35.6 44.68,38.86 46.09,40.27 46.09,41.54 46.74,42.19 47.54,42.19 v3(47.82,42.47) 48.03,42.47 48.36,42.8 48.36,43.04 48.36,43.04 48.36,43.46 48.36,43.87 50.12,45.62 50.55,45.62 51.56,46.64 52.86,46.64 54.23,48.01 62.51,48.01 63.43,47.09 68.55,47.09 72.65,43 72.65,36.67 70.75,34.77 70.75,31.03 71.79,29.99 v3(71.79,26.88)
  IN2 w1.016: 197.66,136.03 195.02,138.67 193.84,138.67 ; 161.33,139.85 162.02,139.17 166.89,139.17 170.82,143.09 170.82,144.14 171.98,145.3 174.82,145.3 ; 137.24,88.34 137.24,89.26 138.84,90.86 138.84,97.3 139.56,98.02 146.57,98.02 153,104.45 153,114.42 147.51,119.9 147.51,130.55 144.95,133.11 144.95,134.06 145.47,134.58 145.47,136.08 146,136.62 149.46,136.62 151.25,138.41 151.25,139.74 152.34,140.83 156.43,140.83
  IN3 w0.508: v3(236.01,44.9) 236.01,44.86 240.67,40.2 v3(240.67,39.07)
  IN3 w1.016: 176,145.28 176,144.07 177,143.07 190.1,143.07 192.8,140.36 192.8,139.31
  IN4 w0.508: v3(81.76,66.21) v3(81.76,64.26) 78.87,61.37 78.87,45.89 76.27,43.28 76.27,35.94 74.26,33.94 74.26,26.61
  IN4 w1.016: 135.75,86.9 133.07,84.22 133.07,80.34 133.58,79.83 133.58,45.9 140.9,38.57 140.9,31.9 141.76,31.04 141.76,27.41 141.45,27.1
  IN4 w3.048: 61.22,15.08 62.79,15.08 67.57,19.85 67.57,23.37 69.17,24.97
  IN6 w1.016: 153.41,73.47 151.27,73.47 149.65,75.1 148.86,75.1 145.28,78.68 145.28,80.1 139.23,86.15 138.81,86.15 138.57,86.39
  BOTTOM w0.381: UT2.19 241.57,34.85 240.92,34.2 CZ6.1 ; CT6.1 249.58,34.83 249.56,34.85 UT2.10 ; UT2.24 241.52,38.1 240.88,37.47 RE99.2 ; UM7.5 157.06,140.44 CM70.1 ; CT5.1 250.05,39.4 UT2.3
  BOTTOM w0.457: RM41.1 161.3,140.35 v3(160.78,140.87)
  BOTTOM w0.508: CZ6.1 240.68,33.59 v3(240.65,33.57) ; CM70.1 156.96,140.72 v3(157.42,141.18) ; RE99.2 CT7.1 240.68,39.08 v3(240.67,39.07) ; v3(250.05,36.22) CT6.1 ; v3(250.05,40.1) CT5.1
  vias: v2(204.97,14.77) v2(330.16,37.73) v3(29.66,19.22) v3(29.93,18.7) v3(30.28,18.17) v3(30.29,19.22) v3(30.58,18.7) v3(30.88,19.2) v3(30.91,18.17) v3(31.18,18.7) v3(31.5,19.22) v3(31.5,18.19) v3(31.82,18.7) v3(50.54,12.61) v3(50.55,11.97) v3(51.03,10.65) v3(51.13,12.61) v3(51.13,11.97) v3(51.61,10.65) v3(51.71,12.61) v3(51.72,11.97) v3(52.25,10.65) v3(52.29,12.61) v3(52.3,11.97) v3(52.83,10.65) v3(137.06,87.1) v3(137.66,87.11) v3(154.38,73.81) v3(154.38,73.22) v3(156.96,18.79) v3(157.55,18.79) v3(158.17,18.77) v3(175.52,146.23) v3(176.1,146.22) v3(192.47,138.43) v3(193.11,138.43) v3(198.35,134.83) v3(198.96,134.83) v3(202.05,20.54) v3(202.48,20.94) v3(251.13,37.9) v3(251.56,37.48) v3(252.01,37.1) v3(287.66,28.73) v3(287.97,29.24) v3(288.29,28.73) v3(331.09,36.86) v3(331.09,36.16) v3(331.66,36.48)
