# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_HDMI_N2: length 88.6
  TOP w0.127: CV38.2 113.35,144.81 113.46,144.92 113.46,145.44 113.18,145.73 v3(113.18,145.76)
  IN1 w0.099: v3(113.18,145.76) 113.58,146.16 113.58,146.34 112.43,147.49 106.9,147.49 105.73,146.32 105.73,145.47 101.31,141.05 100.92,141.05 88.6,128.73 88.6,104.92 91.63,101.88 91.63,100.68 93.23,99.09 94.43,99.09 94.81,99.47 95.46,99.47 95.78,99.15 110.14,99.15 110.66,99.66 111.75,99.66 112.1,100.02 112.1,100.43 112.03,100.51 111.92,100.51 v3(111.72,100.32)
  BOTTOM w0.089: CPU1.C25 112.1,100.39 112.03,100.32 v3(111.72,100.32)
CPU_HDMI_N3: length 76.7
  TOP w0.127: v3(107.68,145.69) 107.68,145.64 107.99,145.33 107.99,144.99 107.75,144.74 CV45.2
  IN1 w0.099: v3(107.68,145.69) 107.92,145.94 107.92,146.04 107.85,146.11 107.46,146.11 107.09,145.75 107.09,144.92 105.24,143.07 105.24,141.42 103.48,139.66 101.63,139.66 90.76,128.8 90.76,117.29 90.97,117.08 90.97,104.65 93.55,102.07 111.15,102.07 111.42,102.34 112.67,102.34 112.96,102.06 113.18,102.06 113.29,102.16 v3(113.29,102.52)
  BOTTOM w0.089: CPU1.A24 113.21,102.07 113.29,102.15 v3(113.29,102.52)
CPU_HDMI_P0: length 77.7
  TOP w0.127: v3(110.1,145.66) 110.04,145.6 110.04,144.94 CV42.2
  IN1 w0.099: v3(113.31,99.63) 113.77,100.09 113.77,100.57 114.03,100.83 114.03,102.74 113.55,103.21 94.05,103.21 92.05,105.21 92.05,129.15 100.71,137.81 101.46,137.81 102.12,138.47 103.23,138.47 105.99,141.23 105.99,141.98 108.22,144.21 109.36,144.21 110.1,144.95 v3(110.1,145.66)
  BOTTOM w0.089: CPU1.D24 112.98,99.97 v3(113.31,99.63)
CPU_HDMI_P1: length 83.1
  TOP w0.127: v3(111.86,146.5) 111.73,146.37 111.73,145.9 CV39.2
  IN1 w0.099: v3(111.73,101.7) 111.97,101.7 112.1,101.57 112.1,101.21 111.88,100.98 111.48,100.98 111.14,100.65 95.95,100.65 95.28,99.97 94.69,99.97 89.28,105.38 89.28,113.05 90.08,113.85 90.08,129.27 101.17,140.36 102.83,140.36 103.52,141.05 103.52,142.29 106.41,145.18 106.41,146.03 107.17,146.79 109.77,146.79 110.47,146.09 111.45,146.09 v3(111.86,146.5)
  BOTTOM w0.089: CPU1.B25 112.1,101.54 111.94,101.7 v3(111.73,101.7)
CPU_HDMI_P2: length 88.6
  TOP w0.127: CV37.2 113.71,145.03 113.71,145.7 v3(113.76,145.76)
  IN1 w0.099: v3(113.76,145.76) 113.76,146.41 112.51,147.67 106.82,147.67 105.55,146.39 105.55,145.54 101.24,141.23 100.84,141.23 88.42,128.8 88.42,104.84 91.45,101.81 91.45,100.61 93.15,98.91 94.5,98.91 94.88,99.29 95.39,99.29 95.7,98.97 110.22,98.97 110.73,99.48 111.83,99.48 112.29,99.94 112.29,100.13 v3(112.5,100.34)
  BOTTOM w0.089: v3(112.5,100.34) 112.12,99.97 CPU1.D25
CPU_HDMI_P3: length 76.6
  TOP w0.127: CV44.2 108.23,144.97 108.23,145.66 v3(108.27,145.69)
  IN1 w0.099: v3(108.27,145.69) 108.1,145.86 108.1,146.12 107.93,146.29 107.38,146.29 106.91,145.82 106.91,145 105.06,143.15 105.06,141.49 103.4,139.84 101.55,139.84 90.58,128.87 90.58,117.21 90.79,117 90.79,104.58 93.47,101.89 111.23,101.89 111.5,102.16 112.6,102.16 112.88,101.88 113.1,101.88 v3(113.29,101.69)
  BOTTOM w0.089: v3(113.29,101.69) 113.24,101.69 CPU1.B24
CPU_MDP_N0: length 90
  TOP w0.127: v3(146.96,135.51) 146.79,135.68 146.79,135.96 146.56,136.18 145.98,136.18 145.78,135.99 142.52,135.99 142.51,136 141.9,136 141.89,135.99 141.5,135.99 140.78,136.7 140.78,137.76 141.02,138 CV27.1
  IN5 w0.099: v3(114.96,101.05) 114.71,100.8 114.56,100.8 113.9,101.46 113.9,103.51 117.04,106.65 131.21,106.65 138.89,98.97 142.63,98.97 147.13,103.47 149.58,103.47 151.93,105.82 151.93,114.86 146.55,120.24 146.55,134.56 146.78,134.79 146.78,135.33 v3(146.96,135.51)
  BOTTOM w0.089: v3(114.96,101.05) 114.58,100.67 CPU1.C21
CPU_MDP_N1: length 88.2
  TOP w0.127: v3(148.27,135.52) 148.1,135.69 148.1,136.11 147.26,136.95 145.66,136.95 145.46,136.74 144.82,136.74 144.8,136.75 144.22,136.75 144.21,136.74 142.95,136.74 142.51,137.18 142.51,137.57 CV30.1
  IN5 w0.099: v3(114.96,102.49) 114.96,102.35 114.68,102.08 114.61,102.08 114.44,102.25 114.44,102.85 117.56,105.97 130.93,105.97 138.59,98.31 142.96,98.31 147.45,102.79 149.89,102.79 152.67,105.58 152.67,115.14 147.21,120.6 147.21,134.19 148.06,135.04 148.06,135.32 v3(148.27,135.52)
  BOTTOM w0.089: CPU1.A21 v3(114.96,102.49)
CPU_MDP_N2: length 88.4
  TOP w0.127: CV33.1 144.48,137.7 144.48,137.58 144.56,137.5 145.15,137.5 145.35,137.71 147.7,137.71 149.6,135.82 149.6,135.57 149.78,135.39 150.08,135.39 v3(150.27,135.57)
  IN5 w0.099: v3(150.27,135.57) 150.02,135.32 149.8,135.32 149.19,134.71 149.19,128.96 149.91,128.24 149.91,125.39 149.1,124.58 149.1,120.58 153.98,115.7 153.98,105.16 147.62,98.8 145.24,98.8 143.47,97.03 138.09,97.03 131.74,103.38 127.99,103.38 127.5,102.9 125.49,102.9 125.26,103.13 117.95,103.13 117.47,102.65 117.47,102.46 117.47,101.31 116.83,100.67 116.42,100.67 116.41,100.69 115.91,100.69 115.77,100.83 v3(115.77,101.05)
  BOTTOM w0.089: v3(115.77,101.05) 115.39,100.67 CPU1.C20
CPU_MDP_N3: length 83.3
  IN5 w0.099: v3(115.76,102.52) 115.76,102.45 116.02,102.2 116.21,102.2 116.29,102.29 116.29,102.92 117.26,103.89 121.51,103.89 122.91,105.29 130.83,105.29 138.35,97.77 143.18,97.77 147.65,102.24 150.08,102.24 153.19,105.35 153.19,115.39 148.39,120.2 148.39,126.1 148.75,126.47 149.2,126.47 v3(149.43,126.7)
  BOTTOM w0.089: v3(115.76,102.52) 115.35,102.11 CPU1.A20
  BOTTOM w0.127: v3(149.43,126.7) 149.24,126.51 148.92,126.51 148.74,126.69 148.74,126.98 143.96,131.76 143.96,132.82 142.13,134.64 142.13,135.3 CV31.1
CPU_MDP_P0: length 90.2
  TOP w0.127: v3(146.37,135.51) 146.54,135.68 146.54,135.85 146.46,135.94 146.08,135.94 145.88,135.75 v4(142.22,135.75) 141.39,135.75 140.54,136.6 140.54,137.74 CV26.1
  IN5 w0.099: v3(114.96,100.35) 114.96,100.37 114.71,100.62 114.48,100.62 113.72,101.39 113.72,103.58 116.97,106.83 131.29,106.83 138.97,99.15 142.56,99.15 147.06,103.65 149.51,103.65 151.75,105.89 151.75,114.79 146.37,120.17 146.37,134.63 146.6,134.86 146.6,135.29 v3(146.37,135.51)
  BOTTOM w0.089: v3(114.96,100.35) 114.58,99.97 CPU1.D21
CPU_MDP_P1: length 88.3
  TOP w0.127: CV28.1 142.31,137.75 142.31,137.71 142.27,137.67 142.27,137.08 142.85,136.5 v4(144.52,136.5) 145.56,136.5 145.76,136.7 147.15,136.7 147.85,136.01 147.85,135.69 v3(147.68,135.52)
  IN5 w0.099: v3(147.68,135.52) 147.88,135.32 147.88,135.12 147.03,134.27 147.03,120.53 152.49,115.07 152.49,105.65 149.81,102.97 147.37,102.97 142.89,98.49 138.66,98.49 131,106.15 117.48,106.15 114.26,102.93 114.26,102.18 114.54,101.9 114.81,101.9 v3(114.96,101.75)
  BOTTOM w0.089: v3(114.96,101.75) 114.58,101.37 CPU1.B21
CPU_MDP_P2: length 88.6
  TOP w0.127: v3(150.27,134.99) 150.11,135.14 149.68,135.14 149.35,135.47 149.35,135.72 147.6,137.47 145.46,137.47 145.25,137.26 144.45,137.26 144.23,137.48 144.23,137.66 CV32.1
  IN5 w0.099: v3(115.77,100.35) 115.93,100.51 116.33,100.51 116.35,100.49 116.9,100.49 117.65,101.24 117.65,102.53 117.65,102.57 118.03,102.95 125.18,102.95 125.41,102.72 127.58,102.72 128.06,103.2 131.66,103.2 138.01,96.85 143.55,96.85 145.32,98.62 147.69,98.62 154.16,105.08 154.16,115.77 149.28,120.65 149.28,124.5 150.09,125.31 150.09,128.31 149.37,129.03 149.37,134.63 149.88,135.14 150.11,135.14 v3(150.27,134.99)
  BOTTOM w0.089: CPU1.D20 115.39,99.97 v3(115.77,100.35)
CPU_MDP_P3: length 83.3
  IN5 w0.099: v3(115.77,101.75) 116.04,102.02 116.28,102.02 116.47,102.21 116.47,102.85 117.34,103.71 121.58,103.71 122.98,105.11 130.75,105.11 138.27,97.59 143.26,97.59 147.73,102.06 150.16,102.06 153.37,105.27 153.37,115.47 148.57,120.27 148.57,126.02 148.83,126.29 149.26,126.29 v3(149.43,126.11)
  BOTTOM w0.089: v3(115.77,101.75) 115.39,101.37 CPU1.B20
  BOTTOM w0.127: v3(149.43,126.11) 149.28,126.26 148.82,126.26 148.5,126.59 148.5,126.88 143.71,131.66 143.71,132.72 141.89,134.54 CV29.1
CPU_PLTRST#: length 236.3
  TOP w0.127: v2(86.3,97.06) v3(85.79,96.55)
  IN1 w0.099: v3(85.79,96.55) 86.24,96.1 86.24,94.61 74.05,82.42 74.05,65.23 70.44,61.63 70.44,54.68 72.2,52.92 72.2,44.43 72.56,44.07 72.56,31.01 v3(73.55,30.01)
  IN6 w0.099: v3(73.55,30.01) 74.13,29.43 75.59,29.43 77.75,27.27 79.95,27.27 82.5,24.72 143.69,24.72 146.1,22.31 149.33,22.31 149.75,21.88 154.99,21.88 155.44,21.43 165.9,21.43 166.98,22.52 167.49,22.52 169.27,20.74 175.91,20.74 176.28,20.37 180.28,20.37 180.93,21.02 190.05,21.02 193.53,24.5 197.07,24.5 198.03,23.54 200.74,23.54 201.47,24.27 205.26,24.27 205.85,24.86 206.79,24.86 207.16,24.49 211.53,24.49 214.96,27.92 v3(214.96,28.53)
  BOTTOM w0.089: v3(214.96,28.53) 215.26,28.82 215.26,29.19 215.11,29.34 215.11,29.65 215.38,29.91 UH1.AU4
  BOTTOM w0.127: v3(85.79,96.55) 86.55,97.31 88.93,97.31 90.93,95.31 CPU1.L54
CPU_PWR_DEBUG: length 11.4
  TOP w0.127: v3(116.52,98.92) 116.96,99.37 116.96,105.53 v2(116.58,105.92) 116.14,106.35 RC50.1 RC52.2
  BOTTOM w0.089: v3(116.52,98.92) CPU1.F19
CR_GPIO: length 6
  TOP w0.127: v1(319.9,18.79) 320.14,19.03 320.83,19.03 321.13,18.72 321.95,18.72 322.28,18.39 RR4.8 323.17,18.39 323.99,19.21 UR1.28
CR_WAKE#: length 3.6
  TOP w0.127: UR1.32 324.84,17.61 324.64,17.41 324.64,17.13 324.31,16.8 v1(324.07,16.8) 323.95,16.8 322.87,17.89 RR4.7
CRX_N8: length 23.6
  IN6 w0.119: v3(159.35,136.13) 159.53,135.95 159.53,135.71 159.79,135.45 160.29,135.45 162,137.15 163.39,137.15 165.3,139.07 166.9,139.07 167.32,139.49 174.98,139.49 v3(175.1,139.37)
  BOTTOM w0.14: UM8.42 159.35,135.56 159.44,135.65 159.44,136.04 v3(159.35,136.13) ; v3(175.1,139.37) 175.25,139.52 175.6,139.52 v4(175.82,139.75) 176.7,140.63 JCDRA.16
CRX_N9: length 30.9
  IN6 w0.119: v3(156.95,136.27) 157.11,136.43 157.11,139.21 157.79,139.9 163.75,139.9 166.44,142.58 175.69,142.58 177.14,141.14 178.35,141.14 v3(178.55,141.34)
  BOTTOM w0.14: v3(178.55,141.34) 178.53,141.34 178.19,140.99 177.92,140.99 177.74,141.17 177.74,141.34 177.87,141.47 177.87,141.71 177.74,141.84 177.74,142.09 177.9,142.25 JCDRA.19 ; UM8.37 156.85,136.17 v3(156.95,136.27)
CRX_N10: length 30
  IN6 w0.119: v3(158.01,137.42) 158.27,137.42 158.5,137.19 160.47,137.19 161.57,138.29 163.46,138.29 166.29,141.13 175.54,141.13 176.6,140.08 179.74,140.08 180.12,140.46 180.12,141.59 v3(180.37,141.84)
  BOTTOM w0.14: v3(180.37,141.84) 180.23,141.99 180.23,142.21 180.3,142.28 JCDRA.25 ; v3(158.01,137.42) 158.19,137.42 158.33,137.28 158.33,136.77 157.96,136.4 157.96,136.08 157.85,135.96 UM8.39
CRX_N11: length 28.6
  IN6 w0.119: v3(181.55,140.61) 181.49,140.55 181.49,140.54 180.18,139.24 176.32,139.24 175.39,138.31 165.6,138.31 163.68,136.39 162.5,136.39 162.34,136.24 162.34,136.05 v3(162.5,135.89)
  BOTTOM w0.14: JCDRA.31 182.7,141.12 182.22,140.64 181.58,140.64 v3(181.55,140.61) ; v3(162.5,135.89) 162.35,136.05 162.35,136.31 161.98,136.68 161.88,136.68 161.85,136.7 v4(161.42,136.7) 161.15,136.7 160.45,136.01 160.45,135.7 160.35,135.6 UM8.44
CRX_P8: length 23.4
  IN6 w0.119: v3(175.1,140.06) 175.1,139.96 174.84,139.7 167.23,139.7 166.81,139.28 165.21,139.28 163.3,137.37 161.91,137.37 160.21,135.66 159.88,135.66 159.74,135.8 159.74,135.94 v3(159.93,136.13)
  BOTTOM w0.14: JCDRA.15 176.3,142.19 176.46,142.04 176.46,141.78 176.34,141.67 176.34,141.42 176.46,141.3 176.46,140.73 175.86,140.12 175.83,140.12 175.47,139.77 175.27,139.77 175.1,139.94 v3(175.1,140.06) ; v3(159.93,136.13) 159.93,136.1 159.68,135.84 159.68,135.69 159.85,135.52 UM8.43
CRX_P9: length 30.9
  IN6 w0.119: v3(157.53,136.27) 157.32,136.49 157.32,139.12 157.88,139.69 163.84,139.69 166.53,142.37 175.6,142.37 177.05,140.93 178.38,140.93 v3(178.55,140.75)
  BOTTOM w0.14: v3(178.55,140.75) 177.82,140.75 177.5,141.07 JCDRA.18 ; v3(157.53,136.27) 157.53,136.25 157.09,135.8 157.09,135.73 157.16,135.65 157.27,135.65 157.35,135.57 UM8.38
CRX_P10: length 29.9
  IN6 w0.119: v3(179.79,141.84) 179.91,141.72 179.91,140.54 179.65,140.29 176.68,140.29 175.63,141.34 166.21,141.34 163.37,138.5 161.48,138.5 160.38,137.4 158.59,137.4 158.42,137.56 v3(158.42,137.83)
  BOTTOM w0.14: v3(179.79,141.84) 179.79,141.86 179.99,142.05 179.99,142.25 179.9,142.34 JCDRA.24 ; UM8.40 158.35,135.56 158.26,135.64 158.2,135.64 158.09,135.76 158.09,135.86 158.21,135.98 158.21,136.3 158.57,136.67 158.57,137.38 158.42,137.53 v3(158.42,137.83)
CRX_P11: length 28.4
  IN6 w0.119: v3(161.92,135.89) 162.13,136.1 162.13,136.32 162.41,136.61 163.59,136.61 165.51,138.52 175.3,138.52 176.23,139.45 180.1,139.45 181.13,140.49 181.13,140.86 181.47,141.2 v3(181.55,141.2)
  BOTTOM w0.14: JCDRA.30 182.3,142.23 182.46,142.07 182.46,141.87 182.3,141.71 182.3,141.57 182.46,141.41 182.46,141.22 182.12,140.88 181.89,140.88 181.58,141.2 v3(181.55,141.2) ; UM8.45 160.85,135.63 160.7,135.78 160.7,135.91 161.23,136.44 161.88,136.44 162.1,136.21 162.1,136.07 v3(161.92,135.89)
CS1: length 5.6
  TOP w0.127: PR106.2 20.47,32.63 20.47,34.1 v1(20.61,34.24)
  TOP w0.203: PR106.2 20.96,31.97 21.69,31.23 21.69,30.67 21.34,30.32 21.34,30.01 21.52,29.83 PU100.1
CS2: length 3.4
  TOP w0.203: PR105.2 21.35,26.08 v1(21.63,26.35) 21.63,28.15 21.72,28.23 PU100.5
CS_1.35V: length 6
  TOP w0.127: PR201.2 154.19,32.9 v2(153.84,33.25)
  TOP w0.203: PR201.2 154.19,29.38 153.74,28.92 153.03,28.92 152.96,28.98 PU200.13
CSON_1: length 30
  TOP w0.127: v1(66.07,46.1) 65.43,46.1 v3(65.22,46.32)
  TOP w0.254: PC717.2 48.55,37.24 PR723.2 ; PC717.2 49.91,37.24 v3(50.1,37.05) ; PC717.2 49.47,37.23 PC721.1
  IN2 w0.254: v3(65.22,46.32) 65.03,46.13 51.78,46.13 50.76,45.11 50.33,45.11 48.87,43.66 48.87,42.93 48.87,37.52 49.29,37.11 50.04,37.11 v3(50.1,37.05)
  BOTTOM w0.254: PR712.3 65.6,45.94 v3(65.22,46.32)
CSOP_1: length 29.1
  TOP w0.127: v1(64.23,46.12) 64.72,45.62 v3(65.22,45.62)
  TOP w0.254: PC717.1 49.63,38.15 v3(50.1,37.68) ; PC717.1 49.46,39.07 PC716.2 ; PC717.1 PR722.2
  IN2 w0.254: v3(65.22,45.62) 65.09,45.75 51.93,45.75 50.92,44.73 50.48,44.73 49.25,43.5 49.25,37.68 49.44,37.49 49.91,37.49 v3(50.1,37.68)
  BOTTOM w0.254: v3(65.22,45.62) 64.9,45.94 PR712.2
CSSN_1: length 11.5
  TOP w0.254: PR702.3 47.88,22.95 47.69,23.14 47.69,25.3 46.99,26 46.99,26.57 44.76,28.81 v1(44.13,28.81) 42.38,28.81 42.1,29.08 42.1,29.42 PR704.1
CSSN_2: length 17.3
  TOP w0.127: PR704.2 43.16,30.58 43.39,30.36 v1(43.39,30.34)
  TOP w0.203: 39.38,39.97 40.35,39 40.35,38.72 40.48,38.59 PU700.1
  TOP w0.254: v3(39.92,40.44) 39.92,40.88 PC709.1 38.81,40.24 PC708.2 39.06,39.97 39.38,39.97 ; PR704.2 v3(42.36,31.21)
  IN1 w0.254: v3(39.92,40.44) 39.92,39.36 40.96,38.32 40.96,32.09 41.34,31.71 41.98,31.71 42.36,31.33 v3(42.36,31.21)
CSSN_B+: length 25.5
  TOP w0.254: v3(163.76,42.12) 163.62,42.25 v1(163.62,43.55) 162.79,44.38 157.26,44.38 156.91,44.72 156.91,45.38 PR603.2 ; RV542.1 158.37,33.43 v3(157.86,32.92)
  BOTTOM w0.254: v3(163.76,42.12) 163.65,42.12 163.14,41.6 163.14,41.56 161.65,40.07 161.65,39.59 161,38.94 161,35.23 161.6,34.63 161.6,33.13 161.27,32.79 157.99,32.79 v3(157.86,32.92)
CSSN_VGA: length 9.6
  TOP w0.254: RV544.1 166.45,37.04 166.58,37.16 167.11,37.16 167.59,37.64 167.59,39.79 v2(166.18,41.2) 166.18,43.52 166.44,43.78 166.63,43.78 167.1,43.31 PR604.2
CSSP_1: length 11.5
  TOP w0.254: PR702.2 47.09,22.95 47.31,23.17 47.31,25.11 46.61,25.81 46.61,26.41 44.64,28.39 v1(42.47,28.39) 42.26,28.39 41.72,28.93 41.72,29.42 PR703.1
CSSP_2: length 17.1
  TOP w0.127: v3(41.72,31.21) v1(41.1,31.83)
  TOP w0.203: PC708.1 39.13,39.32 40.26,38.19 PU700.2
  TOP w0.254: PR703.2 41.47,30.95 v3(41.72,31.21) ; PC708.1 37.86,39.32 PC707.2 37.72,39.52 38,39.8 v3(38,40.14)
  IN1 w0.254: v3(41.72,31.21) 41.28,31.21 40.58,31.9 40.58,38.06 38.5,40.14 v3(38,40.14)
CSSP_B+: length 26.1
  TOP w0.254: RV540.1 158.23,32.29 v3(157.86,32.29) ; v3(163.76,41.53) 163.63,41.53 163.2,41.96 v1(163.2,41.99) 163.16,42.03 163.16,43.46 162.63,43.99 157.1,43.99 156.53,44.56 156.53,45.35 PR603.3
  BOTTOM w0.254: v3(157.86,32.29) 157.99,32.41 161.47,32.41 161.98,32.92 161.98,34.79 161.38,35.39 161.38,38.76 162.04,39.42 162.04,39.92 163.65,41.53 v3(163.76,41.53)
CSSP_VGA: length 10.2
  TOP w0.254: RV543.1 166.45,37.68 166.58,37.56 166.94,37.56 167.21,37.82 167.21,39.5 165.72,40.98 165.72,43.14 v2(165.71,43.16) 165.71,42.95 165.74,42.98 165.74,43.72 166.18,44.16 166.56,44.16 167.1,44.7 PR604.3
CTL1: length 275.4
  TOP w0.127: v3(12.17,21.99) 12.13,22.03 JIO.23 ; UE6.7 242.51,44.27 242.74,44.05 v3(243.58,44.05) v1(243.58,43.22)
  IN6 w0.099: v3(12.17,21.99) 12.88,21.99 16.67,18.2 21.17,18.2 23.52,15.85 25.34,15.85 26.27,14.91 26.27,14.14 26.82,13.58 27.67,13.58 27.91,13.35 30.97,10.29 34.38,10.29 36.07,8.6 56.91,8.6 57.51,9.2 58.59,9.2 59.18,8.6 61.78,8.6 64.71,11.52 69.27,11.52 72.16,8.64 72.19,8.64 72.22,8.61 144.69,8.61 144.96,8.61 146.35,10 149.03,10 153.43,5.6 193.34,5.6 198.33,10.6 201.49,10.6 202.74,9.35 203.86,9.35 204.57,8.64 222.43,8.64 223.98,10.18 229.34,10.18 237.63,18.47 237.63,19.84 238.42,20.63 238.42,23.64 241.44,26.67 241.44,28.85 242.94,30.34 242.94,31.94 242.64,32.23 242.64,43.11 v3(243.58,44.05)
CTL2: length 280.1
  TOP w0.127: v3(243.14,44.71) 243.08,44.77 UE6.8 ; JIO.14 v3(12.84,26.53)
  IN6 w0.099: v3(12.84,26.53) 14.48,24.89 14.48,21.03 16.86,18.65 21.36,18.65 23.71,16.3 25.53,16.3 26.72,15.1 26.72,14.33 27.01,14.04 27.86,14.04 31.16,10.74 34.56,10.74 36.25,9.05 56.51,9.05 57.11,9.65 58.8,9.65 59.4,9.06 61.6,9.06 64.52,11.98 69.49,11.98 72.38,9.09 72.38,9.09 72.41,9.06 144.77,9.06 146.16,10.45 149.22,10.45 153.62,6.05 193.15,6.05 198.15,11.05 201.68,11.05 202.93,9.8 204.05,9.8 204.76,9.09 222.24,9.09 223.79,10.64 229.16,10.64 237.18,18.66 237.18,20.07 237.94,20.83 237.94,23.81 240.99,26.86 240.99,29.03 242.48,30.53 242.48,31.75 242.19,32.05 242.19,39.16 240.26,41.09 240.26,42.7 242.27,44.71 v3(243.14,44.71)
DAT_SMB: length 7
  TOP w0.127: v2(68.35,28.81) 69.01,28.15 PR21.1
  TOP w0.254: v3(70.26,28.18) 70.22,28.15 PR21.1
  BOTTOM w0.254: PBATT1.6 66.23,27.28 66.23,27.28 69.73,27.28 70.26,27.82 v3(70.26,28.18)
DBC_EN: length 305.6
  TOP w0.127: v3(279.69,25.88) 280.42,25.88 281.01,25.29 281.01,23.17 281.85,22.33 282.26,22.33 285.17,19.42 285.17,15.83 285.73,15.27 285.73,12.83 285.6,12.7 UE5.89
  IN2 w0.099: v3(95.76,131.98) 95.76,131.36 96.08,131.04 96.88,131.04 101.83,135.99 105.21,135.99 107.02,134.18 114.8,134.18 116.9,136.28 133.56,136.28 134.68,137.4 138.44,137.4 139.41,138.37 142.42,138.37 143.03,137.76 149.13,137.76 150.13,138.76 150.13,140.26 151.63,141.76 153.27,141.76 153.87,142.37 158.02,142.37 158.68,141.7 160.97,141.7 162.24,140.43 164.49,140.43 166.52,142.46 166.52,144.37 170.25,148.09 186.59,148.09 190.15,144.53 190.15,144.01 193.75,140.41 194.21,140.41 194.5,140.12 195.58,140.12 200.16,135.54 200.74,135.54 202.95,133.33 202.95,132.44 207.98,127.41 218.18,127.41 221.07,124.51 221.07,122 223.1,119.96 223.1,107.74 229.1,101.74 233.81,101.74 234.34,101.21 234.34,98.94 v3(234.2,98.8)
  IN6 w0.099: v3(279.69,25.88) 279.34,25.53 274.55,25.53 266.42,33.66 264.98,33.66 253.38,45.26 251.9,45.26 242.1,55.07 236.23,55.07 232.77,58.53 232.77,63.64 234.12,64.99 234.12,66.16 234.47,66.51 234.47,70.66 235.16,71.36 235.16,97.83 v3(234.2,98.8)
  BOTTOM w0.127: v3(234.2,98.8) 234.46,99.05 v1(234.46,99.62) ; RV46.1 96.06,130.78 95.76,131.08 v3(95.76,131.98)
DBC_EN_R: length 8.9
  TOP w0.127: v3(97.83,126.85) 97.84,126.86 RV14.1 98.81,127.41 v1(98.43,127.79) JEDP1.19
  BOTTOM w0.127: v3(97.83,126.85) 97.21,126.85 96.28,127.78 96.28,129.38 RV46.2
DDR3_DRAMRST#: length 86.6
  TOP w0.127: v3(79.53,67.93) 91.2,67.93 92.01,67.12 92.01,64.59 R1.2 RC12.1 CC28.1 ; v3(85.87,33.43) 85.87,31.4 86.74,30.52 86.74,21.09 v3(86.16,20.51)
  IN6 w0.099: v3(85.87,33.43) 85.87,31.98 85.41,31.52 78.36,31.52 75.76,34.13 75.76,35.21 77.44,36.89 77.44,42.41 79.53,44.5 v3(79.53,67.93)
  BOTTOM w0.127: JDIMM1.30 87.34,31.3 87.34,31.62 86.37,32.59 86.37,32.92 v3(85.87,33.43) ; JDIMM2.30 87.35,18.48 86.62,19.22 86.62,20.06 v3(86.16,20.51)
DDR_A_BS0: length 52.3
  IN6 w0.089: 114.21,68.29 114.21,71.71 114.64,72.14 115.7,72.14 115.83,72.27 115.83,74.2 115.7,74.32 115.21,74.32 115.09,74.2 v3(115.09,73.92)
  IN6 w0.155: v3(113.67,37.36) 113.67,37.21 113.96,36.92 114.29,36.92 114.42,37.05 114.42,37.43 114.85,37.86 114.85,52.37 114.21,53.02 114.21,53.4 114.03,53.58 113.79,53.58 113.66,53.7 113.66,54.07 113.79,54.2 114.05,54.2 114.21,54.35 114.21,54.66 114.05,54.82 113.79,54.82 113.66,54.94 113.66,55.31 113.79,55.44 114.05,55.44 114.21,55.59 114.21,55.9 114.05,56.06 113.79,56.06 113.66,56.18 113.66,56.55 113.79,56.68 114.05,56.68 114.21,56.83 114.21,57.14 114.05,57.3 113.79,57.3 113.66,57.42 113.66,57.79 113.79,57.92 114.05,57.92 114.21,58.07 114.21,58.38 114.05,58.54 113.79,58.54 113.66,58.66 113.66,59.03 113.79,59.16 114.08,59.16 114.21,59.28 114.21,59.65 114.08,59.78 113.79,59.78 113.66,59.9 113.66,60.27 113.79,60.39 114.05,60.39 114.21,60.55 114.21,60.86 114.05,61.01 113.79,61.01 113.66,61.14 113.66,61.51 113.79,61.63 114.05,61.63 114.21,61.79 114.21,62.1 114.05,62.25 113.79,62.25 113.66,62.38 113.66,62.75 113.79,62.87 114.05,62.87 114.21,63.03 114.21,63.34 114.05,63.49 113.79,63.49 113.66,63.62 113.66,63.99 113.79,64.11 114.05,64.11 114.21,64.27 114.21,64.58 114.05,64.73 113.79,64.73 113.66,64.86 113.66,65.23 113.79,65.35 114.05,65.35 114.21,65.51 114.21,65.82 114.05,65.97 113.79,65.97 113.66,66.1 113.66,66.47 113.79,66.59 114.05,66.59 114.21,66.75 114.21,67.06 114.05,67.21 113.79,67.21 113.66,67.34 113.66,67.71 113.79,67.83 114.05,67.83 114.21,67.99 114.21,68.29
  BOTTOM w0.089: CPU1.BC20 115.35,73.58 115.09,73.85 v3(115.09,73.92)
  BOTTOM w0.206: JDIMM1.109 113.44,37.58 v3(113.67,37.36)
DDR_A_BS1: length 52.8
  IN6 w0.089: v3(114.16,72.53) 114.16,72.23 113.19,71.26 113.19,68.55 113.2,68.54 113.2,68.1
  IN6 w0.155: v3(113.67,34.31) 113.67,34.19 113.54,34.06 113.24,34.06 113.12,34.19 113.12,37.16 112.96,37.31 112.76,37.31 112.61,37.47 112.61,37.78 112.76,37.93 114.26,37.93 114.39,38.06 114.39,38.43 114.26,38.55 112.73,38.55 112.61,38.68 112.61,39.05 112.73,39.17 112.99,39.17 113.11,39.3 113.11,40.12 113.24,40.24 113.61,40.24 113.73,40.12 113.73,39.3 113.86,39.17 114.26,39.17 114.39,39.3 114.39,52.11 113.2,53.3 113.2,68.1
  BOTTOM w0.089: v3(114.16,72.53) 114.52,72.88 CPU1.BD21
  BOTTOM w0.206: JDIMM1.108 113.14,32.04 113.35,32.25 113.95,32.25 114.32,32.62 114.32,34.08 114.08,34.31 v3(113.67,34.31)
DDR_A_BS2: length 51.5
  IN6 w0.089: v3(106.9,73.25) 106.28,72.63 105.9,71.7 105.35,71.15 105.34,71.15 104.13,69.94
  IN6 w0.155: v3(103.04,32.78) 101.71,34.12 101.71,38.8 101.39,39.12 101.39,56.34 102.89,57.84 102.89,68.69 104.13,69.94
  BOTTOM w0.089: v3(106.9,73.25) 106.93,73.25 107.3,72.88 CPU1.BD32
  BOTTOM w0.206: v3(103.04,32.78) 102.48,33.34 102.48,36.85 102.75,37.11 103.58,37.11 104.44,37.97 JDIMM1.79
DDR_A_CAS#: length 51
  IN6 w0.089: v3(114.96,70.96) 115.45,70.48 115.45,69.4 115.57,69.27
  IN6 w0.155: v3(115.78,34.58) 116.53,34.58 116.65,34.7 116.65,35.14 116.53,35.27 116.34,35.27 116.21,35.39 116.21,35.76 116.34,35.89 116.53,35.89 116.65,36.01 116.65,42.03 117.09,42.46 117.09,50.84 116.96,50.97 116.38,50.97 116.25,51.09 116.25,51.46 116.38,51.59 116.96,51.59 117.09,51.71 117.09,52.08 116.96,52.2 116.38,52.2 116.25,52.33 116.25,52.7 116.38,52.82 116.96,52.82 117.09,52.95 117.09,53.32 116.96,53.44 115.81,53.44 115.6,53.65 115.6,69.24 115.57,69.27
  BOTTOM w0.089: v3(114.96,70.96) 114.72,70.96 114.59,70.83 114.59,70.22 114.5,70.12 114.37,70.12 114.27,70.22 114.27,71.83 CPU1.BE21
  BOTTOM w0.206: JDIMM1.115 115.24,37.62 115.53,37.34 116.11,37.34 116.29,37.15 116.29,35.08 v3(115.78,34.58)
DDR_A_D0: length 66.5
  IN6 w0.089: 90.81,85.21 90.91,85.21 91.78,84.34 v3(92.02,84.34)
  IN6 w0.099: 90.81,85.21 88.48,85.21 82.62,79.35 82.62,78.31 78.27,73.96 78.27,70.83 80.58,68.53 80.58,41.47 80.45,41.34 79.86,41.34 79.74,41.21 79.74,39.57 79.64,39.47 78.62,39.47 78.49,39.34 78.49,39.09 78.62,38.96 79.64,38.96 79.74,38.86 79.74,38.56 79.64,38.46 78.59,38.46 78.47,38.33 78.47,38.08 78.59,37.95 79.64,37.95 79.74,37.85 79.74,37.24 79.61,37.11 78.87,37.11 v3(78.66,37.33)
  BOTTOM w0.089: v3(92.02,84.34) 92.37,83.99 CPU1.AH54
  BOTTOM w0.127: JDIMM1.5 79.84,37.58 79.59,37.33 v3(78.66,37.33)
DDR_A_D1: length 68.4
  IN6 w0.089: v3(94.06,84.35) 93.34,84.35 92.97,83.98 91.87,83.98 90.94,84.91 90.81,84.91
  IN6 w0.099: 90.81,84.91 88.76,84.91 82.92,79.07 82.92,78.18 78.57,73.83 78.57,70.95 80.9,68.63 80.9,41.29 80.03,40.43 80.03,36.94 79.91,36.81 79.16,36.81 79.06,36.71 79.06,36.41 79.16,36.31 79.76,36.31 79.89,36.18 79.89,35.93 79.66,35.7 79.66,35.33 79.53,35.21 79.19,35.21 79.06,35.33 79.06,35.68 78.93,35.8 v3(78.66,35.8)
  BOTTOM w0.089: CPU1.AH52 94.06,84.23 v3(94.06,84.35)
  BOTTOM w0.127: v3(78.66,35.8) 78.85,35.8 80.44,37.4 JDIMM1.7
DDR_A_D2: length 68.4
  IN6 w0.089: v3(94.82,81.92) 94.4,82.34 92.5,82.34 92.33,82.51 92.33,82.83 92.14,83.02 90.81,83.02
  IN6 w0.099: 90.81,83.02 89.7,83.02 84.94,78.26 84.94,75.99 86.53,74.41 86.53,64.18 82.72,60.37 82.72,51.77 82.84,51.64 83.38,51.64 83.5,51.51 83.5,51.26 83.38,51.14 82.84,51.14 82.72,51.01 82.72,50.76 82.84,50.63 83.86,50.63 83.99,50.5 83.99,50.25 83.86,50.12 82.84,50.12 82.72,50 82.72,49.75 82.84,49.62 83.86,49.62 83.99,49.49 83.99,49.24 83.86,49.11 82.84,49.11 82.72,48.99 82.72,48.74 82.84,48.61 83.86,48.61 83.99,48.48 83.99,48.23 83.86,48.1 82.84,48.1 82.72,47.98 82.72,47.72 82.84,47.6 83.86,47.6 83.99,47.47 83.99,41.81 83.42,41.24 83,41.24 82.72,40.96 82.72,37.96 82.09,37.33 v3(82.09,37.33)
  BOTTOM w0.089: v3(94.82,81.92) 94.47,82.27 CPU1.AK51
  BOTTOM w0.127: v3(82.09,37.33) 82.45,37.33 82.84,37.72 JDIMM1.15
DDR_A_D3: length 66.5
  IN6 w0.089: 90.81,83.41 91.28,83.41 91.46,83.22 92.51,83.22 92.71,83.02 v3(92.71,82.7)
  IN6 w0.099: v3(82.09,35.8) 81.76,35.8 81.68,35.89 81.68,37.5 82.42,38.24 82.42,41.62 82.55,41.75 83.51,41.75 83.64,41.87 83.64,42.16 83.51,42.29 83.05,42.29 82.92,42.41 82.92,42.66 83.05,42.79 83.51,42.79 83.64,42.92 83.64,45.09 83.51,45.22 83.32,45.22 83.19,45.35 83.19,45.6 83.32,45.72 83.51,45.72 83.64,45.85 83.64,46.16 83.51,46.29 82.55,46.29 82.42,46.42 82.42,46.67 82.55,46.79 83.57,46.79 83.69,46.92 83.69,47.17 83.57,47.3 82.55,47.3 82.42,47.43 82.42,60.5 86.23,64.31 86.23,74.28 84.65,75.87 84.65,78.39 89.67,83.41 90.81,83.41
  BOTTOM w0.089: v3(92.71,82.7) 92.65,82.64 92.65,82.59 CPU1.AK54
  BOTTOM w0.127: v3(82.09,35.8) 82.39,35.8 83.44,36.86 83.44,37.5 JDIMM1.17
DDR_A_D4: length 67.4
  IN6 w0.089: 90.81,85.5 90.88,85.5 91.68,84.7 92.36,84.7 v3(92.72,84.34)
  IN6 w0.099: v3(78.66,32.76) 78.53,32.63 78.3,32.63 78.17,32.76 78.17,42.06 80.26,44.15 80.26,68.42 77.98,70.71 77.98,74.08 82.33,78.43 82.33,79.47 88.36,85.5 90.81,85.5
  BOTTOM w0.089: v3(92.72,84.34) 93.07,83.99 CPU1.AH53
  BOTTOM w0.127: JDIMM1.4 79.54,31.87 v3(78.66,32.76)
DDR_A_D5: length 69.6
  IN6 w0.089: 90.81,84.61 90.97,84.61 91.79,83.79 93.05,83.79 93.23,83.96 93.66,83.96 v3(94.11,83.51)
  IN6 w0.099: 90.81,84.61 88.99,84.61 83.27,78.89 83.27,78.04 78.87,73.64 78.87,71.08 81.21,68.73 81.21,41.19 80.67,40.64 80.67,39.88 80.83,39.72 81.09,39.72 81.21,39.59 81.21,39.34 81.09,39.22 80.43,39.22 80.33,39.12 80.33,38.81 80.43,38.71 80.68,38.71 80.81,38.58 80.81,38.33 80.68,38.2 80.43,38.2 80.33,38.11 80.33,35.95 79.96,35.58 79.96,34.44 79.79,34.28 v3(78.66,34.28)
  BOTTOM w0.089: v3(94.11,83.51) 94.11,83.58 CPU1.AH51
  BOTTOM w0.127: JDIMM1.6 80.14,31.56 80.14,31.9 79.69,32.35 79.69,33.43 78.84,34.28 v3(78.66,34.28)
DDR_A_D6: length 68
  IN6 w0.089: 90.81,82.2 91.49,82.2 91.72,81.96 92.2,81.96 92.58,81.58 93.75,81.58 v3(94.12,81.95)
  IN6 w0.099: v3(82.09,32.76) 82.95,33.62 82.95,37.36 83.31,37.71 83.31,40.29 84.59,41.56 84.59,50.52 84.71,50.65 85.37,50.65 85.47,50.75 85.47,51.05 85.37,51.15 84.71,51.15 84.59,51.28 84.59,51.53 84.71,51.66 85.37,51.66 85.47,51.76 85.47,52.07 85.37,52.16 84.71,52.16 84.59,52.29 84.59,52.54 84.71,52.67 85.37,52.67 85.47,52.77 85.47,53.08 85.37,53.18 84.71,53.18 84.59,53.3 84.59,54.13 84.46,54.26 83.44,54.26 83.31,54.38 83.31,60.13 87.12,63.94 87.12,74.65 85.54,76.24 85.54,78.02 89.72,82.2 90.81,82.2
  BOTTOM w0.089: v3(94.12,81.95) 94.09,81.95 93.77,82.27 CPU1.AK52
  BOTTOM w0.127: v3(82.09,32.76) 83.14,31.7 JDIMM1.16
DDR_A_D7: length 67.8
  IN6 w0.089: 90.81,82.64 91.31,82.64 91.8,82.15 92.53,82.15 v3(92.73,81.95)
  IN6 w0.099: 90.81,82.64 89.74,82.64 85.24,78.14 85.24,76.11 86.82,74.53 86.82,64.06 83.01,60.25 83.01,54.09 83.14,53.96 84.16,53.96 84.29,53.83 84.29,53.58 84.16,53.45 83.14,53.45 83.01,53.33 83.01,53.08 83.14,52.95 84.16,52.95 84.29,52.82 84.29,52.57 84.16,52.44 83.14,52.44 83.01,52.32 83.01,52.07 83.14,51.94 84.16,51.94 84.29,51.81 84.29,51.56 84.16,51.43 83.93,51.43 83.8,51.31 83.8,51.05 83.92,50.93 84.16,50.93 84.29,50.8 84.29,41.69 83.01,40.41 83.01,37.84 82.66,37.48 82.66,34.85 v3(82.09,34.28)
  BOTTOM w0.089: CPU1.AK53 93.07,82.29 v3(92.73,81.95)
  BOTTOM w0.127: JDIMM1.18 83.74,31.66 82.74,32.67 82.74,33.62 v3(82.09,34.28)
DDR_A_D8: length 59.1
  IN6 w0.089: v3(92.02,81.09) 91.65,80.72 91.14,80.72 90.81,81.05
  IN6 w0.099: v3(84.16,36.85) 84.41,37.11 84.41,39 86.99,41.58 86.99,46.99 87.09,47.09 88.12,47.09 88.25,47.22 88.25,47.47 88.12,47.6 87.09,47.6 86.99,47.7 86.99,48 87.09,48.1 88.52,48.1 88.65,48.23 88.65,48.48 88.52,48.61 87.09,48.61 86.99,48.71 86.99,49.08 87.12,49.2 89.28,49.2 89.41,49.33 89.41,60.2 88.22,61.38 88.22,79.14 90.13,81.05 90.81,81.05
  BOTTOM w0.089: CPU1.AN54 92.37,80.74 v3(92.02,81.09)
  BOTTOM w0.127: v3(84.16,36.85) 84.16,37.32 84.64,37.81 JDIMM1.21
DDR_A_D9: length 60.8
  IN6 w0.089: v3(93.42,81.03) 92.59,81.03 92.04,81.58 91.33,81.58 91.1,81.35 90.81,81.35
  IN6 w0.099: 90.81,81.35 90.01,81.35 87.92,79.27 87.92,61.26 89.11,60.07 89.11,51.61 88.66,51.16 88.66,51.02 89.11,50.57 89.11,50.39 88.93,50.21 88.75,50.21 88.3,50.66 88.16,50.66 87.94,50.45 87.94,50.31 88.39,49.86 88.39,49.68 88.21,49.5 88.03,49.5 87.58,49.95 87.44,49.95 86.69,49.2 86.69,41.71 84.11,39.13 84.11,37.38 83.76,37.02 83.76,35.74 v3(84.16,35.33)
  BOTTOM w0.089: CPU1.AN52 93.77,80.76 93.5,81.03 v3(93.42,81.03)
  BOTTOM w0.127: JDIMM1.23 85.24,37.77 84.58,37.11 84.58,35.75 v3(84.16,35.33)
DDR_A_D10: length 60.3
  IN6 w0.089: 90.81,78.45 90.82,78.45 90.95,78.58 91.7,79.33 92.34,79.33 92.61,79.06 93.56,79.06 93.78,78.83 93.78,78.42 93.99,78.21 94.37,78.21 v3(94.82,78.67)
  IN6 w0.099: v3(87.15,36.85) 87.15,38.16 88.81,39.82 88.81,42.83 89.07,43.09 89.07,43.23 88.86,43.43 88.86,43.61 89.04,43.79 89.22,43.79 89.42,43.58 89.56,43.58 89.78,43.8 89.78,43.94 89.2,44.53 89.2,44.71 89.37,44.88 89.55,44.88 90.14,44.3 90.28,44.3 90.5,44.52 90.5,44.66 89.45,45.7 89.45,45.88 89.63,46.06 89.81,46.06 90.85,45.01 90.99,45.01 91.21,45.23 91.21,45.41 90.19,46.43 90.19,46.61 90.39,46.82 90.56,46.82 90.96,46.42 91.14,46.42 91.32,46.61 91.32,46.79 90.97,47.13 90.97,47.4 91.21,47.63 91.21,60.94 90.64,61.51 90.64,65.92 90.02,66.53 90.02,77.67 90.81,78.45
  BOTTOM w0.089: CPU1.AR51 94.47,79.02 v3(94.82,78.67)
  BOTTOM w0.127: v3(87.15,36.85) 87.44,36.85 88.24,37.66 JDIMM1.33
DDR_A_D11: length 59.6
  IN6 w0.089: 90.81,77.94 90.81,78.17 91.78,79.14 92.11,79.14 92.62,78.64 v3(92.67,78.64)
  IN6 w0.099: v3(87.15,35.33) 87.59,35.77 87.59,38.01 89.62,40.03 89.62,40.63 89.52,40.73 89.26,40.73 89.16,40.83 89.16,41.14 89.26,41.24 89.52,41.24 89.62,41.34 89.62,41.64 89.52,41.74 89.26,41.74 89.16,41.84 89.16,42.15 89.26,42.25 89.52,42.25 89.62,42.35 89.62,43.22 91.5,45.1 91.5,45.36 91.63,45.49 91.89,45.49 92.01,45.61 92.01,45.86 91.89,45.99 91.63,45.99 91.5,46.12 91.5,46.37 91.63,46.5 91.89,46.5 92.02,46.62 92.02,46.88 91.89,47 91.63,47 91.5,47.13 91.5,47.38 91.63,47.51 91.89,47.51 92.02,47.63 92.02,47.91 91.92,48.01 91.6,48.01 91.5,48.11 91.5,48.42 91.6,48.52 91.92,48.52 92.02,48.62 92.02,48.93 91.92,49.02 91.6,49.02 91.5,49.12 91.5,49.43 91.6,49.53 91.92,49.53 92.02,49.63 92.02,49.94 91.92,50.04 91.6,50.04 91.5,50.13 91.5,50.44 91.6,50.54 91.92,50.54 92.02,50.64 92.02,50.95 91.92,51.05 91.6,51.05 91.5,51.15 91.5,51.45 91.6,51.55 91.92,51.55 92.02,51.65 92.02,51.96 91.92,52.06 91.6,52.06 91.5,52.16 91.5,60.16 91.89,60.54 91.89,62.16 90.96,63.09 90.96,66.76 90.32,67.4 90.32,77.45 90.81,77.94
  BOTTOM w0.089: CPU1.AR53 93.07,79.03 92.68,78.64 v3(92.67,78.64)
  BOTTOM w0.127: JDIMM1.35 88.84,37.69 87.6,36.44 87.6,35.78 v3(87.15,35.33)
DDR_A_D12: length 60
  IN6 w0.089: v3(92.72,80.31) 92.61,80.42 91.12,80.42 90.81,80.74
  IN6 w0.099: 90.81,80.74 90.24,80.74 88.52,79.02 88.52,61.5 89.7,60.32 89.7,48.26 87.29,45.84 87.29,41.46 86.34,40.51 86.34,40.37 86.7,40.02 86.7,39.84 86.52,39.66 86.34,39.66 85.98,40.02 85.84,40.02 85.63,39.8 85.63,39.66 85.98,39.3 85.98,39.12 85.81,38.94 85.63,38.94 85.29,39.28 85.11,39.28 84.87,39.04 84.87,38.86 85.22,38.51 85.22,38.36 84.71,37.85 84.71,32.83 v3(84.16,32.28)
  BOTTOM w0.089: v3(92.72,80.31) 93.07,80.65 CPU1.AN53
  BOTTOM w0.127: JDIMM1.22 84.94,31.84 84.5,32.28 v3(84.16,32.28)
DDR_A_D13: length 62
  IN6 w0.089: 90.81,81.69 90.81,81.69 91.12,81.69 91.21,81.77 92.12,81.77 92.5,81.39 93.79,81.39 94.12,81.06 v3(94.12,81.03)
  IN6 w0.099: 90.81,81.69 89.93,81.69 86.04,77.81 86.04,76.44 87.63,74.86 87.63,61.13 88.81,59.95 88.81,51.74 86.4,49.32 86.4,41.83 83.82,39.25 83.82,37.51 83.46,37.15 83.46,34.51 v3(84.16,33.81)
  BOTTOM w0.089: CPU1.AN51 94.47,80.76 94.2,81.03 v3(94.12,81.03)
  BOTTOM w0.127: JDIMM1.24 85.54,32.42 v3(84.16,33.81)
DDR_A_D14: length 59.6
  IN6 w0.089: v3(94.15,78.66) 94.15,79.02 93.82,79.34 92.59,79.34 92.42,79.52 91.56,79.52 91,78.96 90.89,78.96 90.81,78.87
  IN6 w0.099: v3(87.15,32.54) 86.87,32.54 86.75,32.66 86.75,34.18 86.65,34.28 86.41,34.28 86.28,34.41 86.28,34.66 86.41,34.79 86.65,34.79 86.75,34.89 86.75,35.19 86.65,35.29 86.5,35.29 86.37,35.42 86.37,35.67 86.5,35.8 86.65,35.8 86.75,35.9 86.75,36.2 86.65,36.3 86.37,36.3 86.27,36.4 86.27,36.71 86.37,36.81 86.65,36.81 86.75,36.91 86.75,37.21 86.65,37.31 86.39,37.31 86.26,37.44 86.26,37.69 86.39,37.82 86.65,37.82 86.75,37.92 86.75,38.18 88.51,39.94 88.51,43.84 88.8,44.13 88.8,44.77 88.52,45.05 88.52,45.37 90.91,47.76 90.91,60.82 90.34,61.39 90.34,65.79 89.72,66.41 89.72,77.79 90.81,78.87
  BOTTOM w0.089: v3(94.15,78.66) 93.77,79.03 CPU1.AR52
  BOTTOM w0.127: v3(87.15,32.54) 87.51,32.54 88.27,31.78 88.27,31.78 88.54,31.5 JDIMM1.34
DDR_A_D15: length 58.5
  IN6 w0.089: 90.81,76.86 91.12,77.18 91.12,78.09 91.81,78.77 v3(91.93,78.77)
  IN6 w0.099: 90.81,76.86 90.62,76.67 90.62,67.52 91.26,66.88 91.26,63.21 92.31,62.15 92.31,60.06 92.22,59.96 91.92,59.96 91.8,59.84 91.8,59.58 91.92,59.46 92.22,59.46 92.31,59.36 92.31,59.05 92.22,58.95 91.92,58.95 91.82,58.85 91.82,58.54 91.92,58.45 92.22,58.45 92.31,58.35 92.31,58.04 92.22,57.94 91.92,57.94 91.82,57.84 91.82,57.53 91.92,57.43 92.22,57.43 92.31,57.34 92.31,57.03 92.22,56.93 91.92,56.93 91.82,56.83 91.82,56.52 91.92,56.42 92.22,56.42 92.31,56.32 92.31,56.02 92.22,55.92 91.92,55.92 91.82,55.82 91.82,55.51 91.92,55.41 92.22,55.41 92.31,55.31 92.31,54.07 92.22,53.97 91.9,53.97 91.8,53.87 91.8,53.56 91.9,53.46 92.22,53.46 92.31,53.37 92.31,53.06 92.22,52.96 91.9,52.96 91.8,52.86 91.8,52.55 91.9,52.45 92.22,52.45 92.31,52.35 92.31,45.49 89.92,43.09 89.92,39.91 87.89,37.88 87.89,34.54 v3(87.15,33.81)
  BOTTOM w0.089: v3(91.93,78.77) 92.21,79.06 CPU1.AR54
  BOTTOM w0.127: JDIMM1.36 89.15,31.53 88.9,31.78 88.78,31.78 88.27,32.29 88.27,32.79 87.25,33.81 v3(87.15,33.81)
DDR_A_D16: length 53.7
  IN6 w0.089: v3(94.13,77.84) 93.83,77.54 92.14,77.54 92.03,77.65 91.72,77.65 91.51,77.44 91.51,76.94 91.04,76.47 91.04,73.65 92.18,72.5 92.18,69.94
  IN6 w0.099: 92.18,69.94 92.18,63.42 93.12,62.49 93.12,44.1 92.94,43.92 92.8,43.92 92.41,44.31 92.27,44.31 92.05,44.1 92.05,43.96 92.44,43.57 92.44,43.43 92.23,43.21 92.09,43.21 91.7,43.6 91.56,43.6 91.34,43.38 91.34,43.24 91.73,42.85 91.73,42.71 91.59,42.58 91.59,42.46 91.47,42.33 90.85,42.33 90.72,42.21 90.72,41.96 90.85,41.83 91.47,41.83 91.59,41.7 91.59,41.45 91.47,41.32 90.85,41.32 90.72,41.2 90.72,39.58 89.02,37.88 v3(89.02,36.88)
  BOTTOM w0.089: v3(94.13,77.84) 94.13,77.79 CPU1.AV52
  BOTTOM w0.127: v3(89.02,36.88) 89.43,36.88 90.04,37.49 JDIMM1.39
DDR_A_D17: length 53.4
  IN6 w0.089: 91.88,69.94 91.88,72.53 90.85,73.57 90.85,76.55 91.32,77.01 91.32,78.01 91.71,78.4 92.35,78.4 92.48,78.27 93.05,78.27 v3(93.42,77.9)
  IN6 w0.099: v3(89.02,35.35) 88.57,35.35 88.39,35.52 88.39,37.67 90.42,39.7 90.42,42.5 90.55,42.63 90.91,42.63 91.04,42.76 91.04,43.51 92.82,45.28 92.82,62.36 91.88,63.3 91.88,69.94
  BOTTOM w0.089: v3(93.42,77.9) 93.07,77.55 CPU1.AV53
  BOTTOM w0.127: v3(89.02,35.35) 89.37,35.7 89.83,36.16 89.83,36.56 90.64,37.38 JDIMM1.41
DDR_A_D18: length 52.4
  IN6 w0.089: 95.1,69.94 94.46,70.58 94.46,72.43 93.95,72.94 93.95,74.52 94.46,75.03 94.46,75.64 94.29,75.81 93.63,75.81 93.46,75.64 v3(93.46,75.41)
  IN6 w0.099: v3(92.24,36.88) 92.15,36.97 92.15,37.2 92.27,37.32 92.71,37.32 92.84,37.19 92.84,36.34 92.97,36.21 93.2,36.21 93.33,36.34 93.33,37.45 92.52,38.25 92.52,38.41 92.75,38.64 92.89,38.64 93.24,38.28 93.38,38.28 93.6,38.5 93.6,38.64 93.24,38.99 93.24,39.13 93.46,39.35 93.6,39.35 93.96,39 94.1,39 94.31,39.22 94.31,39.36 93.96,39.71 93.96,39.85 94.18,40.07 94.32,40.07 94.67,39.71 94.81,39.71 95.03,39.93 95.03,40.07 94.67,40.42 94.67,40.57 95.21,41.11 95.21,69.82 95.1,69.94
  BOTTOM w0.089: CPU1.AY52 93.77,75.72 v3(93.46,75.41)
  BOTTOM w0.127: v3(92.24,36.88) 92.91,36.88 93.64,37.61 JDIMM1.51
DDR_A_D19: length 53.5
  IN6 w0.089: v3(94.1,75.44) 94.1,74.94 93.22,74.06 93.22,73.11 94.27,72.07 94.27,70.35 94.68,69.94
  IN6 w0.099: v3(92.24,35.35) 92.24,35.14 92.05,34.95 91.52,34.95 91.4,35.07 91.4,35.72 91.52,35.85 91.69,35.85 91.84,36 91.84,36.21 91.69,36.35 91.44,36.35 91.3,36.5 91.3,36.71 91.44,36.86 91.72,36.86 91.85,36.99 91.85,37.24 91.72,37.37 91.56,37.37 91.43,37.49 91.43,37.75 91.56,37.87 91.95,37.87 92.07,38 92.07,38.39 93.71,40.02 93.71,40.55 93.81,40.65 94.34,40.65 94.46,40.78 94.46,41.03 94.34,41.15 93.8,41.15 93.7,41.26 93.7,41.56 93.8,41.66 94.79,41.66 94.92,41.79 94.92,42.04 94.79,42.16 94.24,42.16 94.13,42.27 94.13,42.57 94.24,42.67 94.79,42.67 94.92,42.8 94.92,69.7 94.68,69.94
  BOTTOM w0.089: CPU1.AY51 94.46,75.81 v3(94.1,75.44)
  BOTTOM w0.127: JDIMM1.53 94.24,37.49 93.01,36.25 93.01,36.12 v3(92.24,35.35)
DDR_A_D20: length 54.4
  IN6 w0.089: v3(94.78,77.06) 94.49,77.35 92.56,77.35 92.14,76.93 92.04,76.93 91.42,76.31 91.42,74.03 93.29,72.16 93.29,69.94
  IN6 w0.099: 93.29,69.94 93.29,66.15 92.94,65.8 92.94,63.51 93.71,62.73 93.71,43.85 92.19,42.33 92.19,40.21 89.73,37.75 89.73,33.23 v3(89.02,32.3)
  BOTTOM w0.089: v3(94.78,77.06) 94.78,77.21 94.55,77.43 CPU1.AV51
  BOTTOM w0.127: v3(89.02,32.3) 89.88,32.3 90.34,31.84 JDIMM1.40
DDR_A_D21: length 52.8
  IN6 w0.089: 92.48,69.94 92.48,72.65 91.23,73.9 91.23,76.39 91.88,77.04 v3(91.88,77.29)
  IN6 w0.099: v3(89.02,33.83) 89.43,34.23 89.43,37.86 91.02,39.45 91.02,39.92 91.11,40.02 91.58,40.02 91.7,40.14 91.7,40.39 91.58,40.52 91.11,40.52 91.02,40.62 91.02,40.93 91.11,41.03 91.76,41.03 91.89,41.15 91.89,42.45 93.41,43.98 93.41,62.61 92.48,63.55 92.48,69.94
  BOTTOM w0.089: v3(91.88,77.29) 92.02,77.43 CPU1.AV54
  BOTTOM w0.127: v3(89.02,33.83) 89.39,33.83 90.94,32.27 JDIMM1.42
DDR_A_D22: length 51.2
  IN6 w0.089: 95.81,69.94 95.81,70.08 95.32,70.57 95.15,70.57 94.88,70.84 94.88,75.77 94.1,76.55 93.23,76.55 92.87,76.19 v3(92.71,76.19)
  IN6 w0.099: v3(92.24,32.3) 93.41,33.47 93.41,35.33 93.92,35.84 93.92,37.98 95.81,39.87 95.81,69.94
  BOTTOM w0.089: v3(92.71,76.19) 92.37,75.84 CPU1.AY54
  BOTTOM w0.127: JDIMM1.50 93.34,31.76 92.8,32.3 v3(92.24,32.3)
DDR_A_D23: length 52.1
  IN6 w0.089: v3(93.41,76.19) 94.18,76.19 94.68,75.69 94.68,74.9 94.14,74.36 94.14,73.02 94.65,72.51 94.65,70.8 95.51,69.94
  IN6 w0.099: 95.51,69.94 95.51,39.99 93.62,38.1 93.62,36.04 93.5,35.91 92.78,35.91 92.65,35.79 92.65,35.53 92.78,35.41 92.99,35.41 93.12,35.28 93.12,35.03 92.99,34.9 92.75,34.9 92.65,34.8 92.65,34.5 92.75,34.4 93.02,34.4 93.12,34.3 93.12,34.02 92.92,33.83 v3(92.24,33.83)
  BOTTOM w0.089: CPU1.AY53 93.07,75.84 v3(93.41,76.19)
  BOTTOM w0.127: JDIMM1.52 93.94,32.39 92.5,33.83 v3(92.24,33.83)
DDR_A_D24: length 52.3
  IN6 w0.089: v3(96.65,75.34) 96.51,75.2 95.5,75.2 95.31,75.01 95.31,74.67 95.9,74.07 95.9,71.2 96.61,70.49 96.61,69.94
  IN6 w0.099: v3(95.13,35.08) 94.72,34.68 94.72,33.24 94.6,33.11 94.34,33.11 94.22,33.24 94.22,35 94.72,35.5 94.72,37.65 96.61,39.54 96.61,69.94
  BOTTOM w0.089: CPU1.AY47 97,75.68 v3(96.65,75.34)
  BOTTOM w0.127: v3(95.13,35.08) 94.63,35.58 94.63,36.86 95.44,37.67 95.44,37.97 JDIMM1.57
DDR_A_D25: length 51.3
  IN6 w0.089: v3(95.74,74.84) 96.63,74.84 96.76,74.71 96.76,70.77 96.91,70.62
  IN6 w0.099: v3(95.13,36.61) 95.02,36.72 95.02,37.53 95.34,37.84 95.48,37.84 95.7,37.62 95.88,37.63 96.05,37.81 96.05,37.98 95.84,38.2 95.84,38.34 96.91,39.41 96.91,60.68 97.04,60.8 97.64,60.8 97.77,60.93 97.77,61.18 97.64,61.31 97.04,61.31 96.91,61.44 96.91,61.69 97.04,61.81 97.64,61.81 97.77,61.94 97.77,62.84 97.37,63.23 97.04,63.23 96.91,63.36 96.91,67.64 97.04,67.77 97.64,67.77 97.77,67.89 97.77,68.15 97.64,68.27 97.04,68.27 96.91,68.4 96.91,68.65 97.04,68.78 97.64,68.78 97.77,68.9 97.77,69.16 97.64,69.28 97.04,69.28 96.91,69.41 96.91,69.66 97.04,69.79 97.6,69.79 97.73,69.92 97.73,70.17 97.6,70.29 97.04,70.29 96.91,70.42 96.91,70.62
  BOTTOM w0.089: CPU1.AY49 95.74,75.22 v3(95.74,74.84)
  BOTTOM w0.127: v3(95.13,36.61) 95.13,36.86 96.05,37.78 JDIMM1.59
DDR_A_D26: length 50.7
  IN6 w0.089: v3(97.61,75.45) 97.61,75.74 97.79,75.91 98.87,75.91 99.25,75.53 99.25,75.08 99.13,74.96 99.13,74.2 99.17,74.15 99.17,70.91 99.57,70.51 99.57,69.94
  IN6 w0.099: v3(97.96,36.61) 97.96,37.92 98.71,38.67 98.71,59.15 99.57,60.02 99.57,60.44 99.7,60.57 100.03,60.57 100.16,60.69 100.16,60.95 100.03,61.07 99.7,61.07 99.57,61.2 99.57,61.45 99.7,61.58 100.03,61.58 100.16,61.71 100.16,64.91 100.06,65.01 99.67,65.01 99.57,65.11 99.57,65.42 99.67,65.52 100.06,65.52 100.16,65.61 100.16,65.92 100.06,66.02 99.67,66.02 99.57,66.12 99.57,66.43 99.67,66.53 100.06,66.53 100.16,66.63 100.16,66.93 100.06,67.03 99.67,67.03 99.57,67.13 99.57,67.44 99.67,67.54 100.06,67.54 100.16,67.64 100.16,67.94 100.06,68.04 99.67,68.04 99.57,68.14 99.57,69.94
  BOTTOM w0.089: CPU1.BA47 v3(97.61,75.45)
  BOTTOM w0.127: JDIMM1.67 98.44,38.77 98.44,37.62 98.7,37.37 98.7,36.39 98.61,36.31 98.26,36.31 v3(97.96,36.61)
DDR_A_D27: length 53.3
  IN6 w0.089: v3(99.53,74.74) 100.01,74.26 100.01,71.78
  IN6 w0.099: 100.01,71.78 100.01,71.63 100.14,71.51 100.36,71.51 100.46,71.41 100.46,71.1 100.36,71 100.01,71 99.88,70.87 99.88,70.59 100.01,70.46 100.36,70.46 100.46,70.36 100.46,70.05 100.36,69.95 100.02,69.95 99.92,69.86 99.92,69.55 100.02,69.45 100.36,69.45 100.46,69.35 100.46,69.04 100.36,68.94 100.02,68.94 99.92,68.84 99.92,68.54 100.02,68.44 100.36,68.44 100.46,68.34 100.46,60.48 99.01,59.03 99.01,38.05 98.88,37.92 98.39,37.92 98.26,37.8 98.26,37.55 98.39,37.42 98.88,37.42 99.01,37.29 99.01,37.04 98.88,36.91 98.5,36.91 98.37,36.79 98.37,36.53 98.5,36.41 98.88,36.41 99.01,36.28 99.01,36.03 98.88,35.9 98.51,35.9 98.36,35.75 98.36,35.55 98.51,35.4 98.88,35.4 99.01,35.27 99.01,35 98.88,34.87 98.18,34.87 v3(97.96,35.08)
  BOTTOM w0.089: CPU1.BA45 99.29,74.98 v3(99.53,74.74)
  BOTTOM w0.127: JDIMM1.69 99.04,37.75 99.04,37.75 99.04,35.13 98.8,34.89 98.16,34.89 v3(97.96,35.08)
DDR_A_D28: length 53.5
  IN6 w0.089: v3(99.53,76.04) 99.28,76.29 98.36,76.29 97.86,76.8 97.28,76.8 96.84,76.35 96.33,76.35 96.14,76.16 96.14,75.61 95.95,75.42 95.4,75.42 95.12,75.14 95.12,74.59 95.71,73.99 95.71,70.97 96.31,70.37 96.31,69.94
  IN6 w0.099: 96.31,69.94 96.31,39.66 94.43,37.77 94.43,35.63 93.92,35.12 93.92,32.24 94.12,32.04 v3(95.13,32.04)
  BOTTOM w0.089: v3(99.53,76.04) 99.17,75.68 CPU1.AY45
  BOTTOM w0.127: v3(95.13,32.04) 95.14,32.02 JDIMM1.56
DDR_A_D29: length 55
  IN6 w0.089: v3(100.42,76.04) 100.04,76.04 99.68,75.68 99.38,75.68 98.95,76.1 98.28,76.1 97.78,76.61 97.36,76.61 97.16,76.41 97.16,74.57 97.54,74.19 97.54,70.83 98.07,70.3 98.07,69.94
  IN6 w0.099: 98.07,69.94 98.07,67.6 97.94,67.47 97.33,67.47 97.21,67.34 97.21,67.09 97.33,66.96 97.94,66.96 98.07,66.84 98.07,66.59 97.94,66.46 97.33,66.46 97.21,66.33 97.21,63.82 98.07,62.96 98.07,60.64 97.21,59.78 97.21,39.29 96.35,38.44 96.35,37.42 96.22,37.3 95.66,37.3 95.53,37.17 95.53,33.97 v3(95.13,33.56)
  BOTTOM w0.089: v3(100.42,76.04) 100.06,75.68 CPU1.AY43
  BOTTOM w0.127: v3(95.13,33.56) 95.13,33.49 95.74,32.87 95.74,31.79 95.74,31.79 JDIMM1.58
DDR_A_D30: length 49.8
  IN6 w0.089: v3(97.6,74.83) 97.6,74.86 98.42,75.67 98.79,75.67 98.94,75.53 98.94,70.88 99.27,70.54 99.27,69.94
  IN6 w0.099: v3(97.96,32.04) 97.56,32.44 97.56,37.94 98.41,38.79 98.41,59.28 99.27,60.14 99.27,69.94
  BOTTOM w0.089: v3(97.6,74.83) 97.46,74.69 96.5,74.69 CPU1.BA49
  BOTTOM w0.127: v3(97.96,32.04) 98.29,32.04 98.75,31.59 JDIMM1.68
DDR_A_D31: length 53.6
  IN6 w0.089: 100.76,69.94 100.76,74.11 100.97,74.31 100.97,74.57 100.84,74.7 v3(100.4,74.7)
  IN6 w0.099: 100.76,69.94 100.76,60.37 99.3,58.91 99.3,34.7 99.18,34.57 98.52,34.57 98.37,34.42 98.37,34.21 98.52,34.07 99.18,34.07 99.3,33.94 99.3,31.9 99.18,31.78 98.5,31.78 98.37,31.9 98.37,32.6 98.68,32.92 98.68,33.43 98.55,33.56 v3(97.96,33.56)
  BOTTOM w0.089: v3(100.4,74.7) 100.11,74.98 CPU1.BA43
  BOTTOM w0.127: JDIMM1.70 99.34,33.09 98.88,33.56 v3(97.96,33.56)
DDR_A_D32: length 48.1
  IN6 w0.089: v3(119.86,71.84) 119.49,71.48 119.49,70.96 119.89,70.57 119.89,69.94
  IN6 w0.099: v3(120.29,32.54) 121.27,33.51 121.47,34.19 121.47,35.29 121.86,35.68 121.86,49.96 121.29,50.53 121.29,65.9 119.89,67.3 119.89,69.94
  BOTTOM w0.089: CPU1.BF14 119.51,71.52 119.82,71.84 v3(119.86,71.84)
  BOTTOM w0.127: JDIMM1.129 119.44,33.67 119.77,33.06 v3(120.29,32.54)
DDR_A_D33: length 50
  IN6 w0.089: 119,69.94 119,70.19 118.75,70.45 118.75,73.8 118.87,73.93 v3(119.85,73.93)
  IN6 w0.099: v3(120.29,37.11) 120.04,37.36 120.04,37.75 120.14,37.85 120.3,37.85 120.4,37.95 120.4,38.26 120.3,38.36 120.14,38.36 120.04,38.45 120.04,38.76 120.17,38.89 120.27,38.89 120.4,39.02 120.4,42.61 120.5,42.71 120.84,42.71 120.97,42.84 120.97,43.09 120.84,43.21 120.5,43.21 120.4,43.31 120.4,43.62 120.5,43.72 120.84,43.72 120.97,43.85 120.97,44.1 120.84,44.22 120.5,44.22 120.4,44.32 120.4,44.63 120.5,44.73 120.84,44.73 120.97,44.86 120.97,45.11 120.84,45.24 120.5,45.24 120.4,45.33 120.4,45.64 120.5,45.74 120.84,45.74 120.97,45.87 120.97,46.12 120.84,46.25 120.5,46.25 120.4,46.35 120.4,46.65 120.5,46.75 120.84,46.75 120.97,46.88 120.97,47.13 120.84,47.26 120.5,47.26 120.4,47.36 120.4,47.66 120.5,47.76 120.84,47.76 120.97,47.89 120.97,48.14 120.84,48.27 120.5,48.27 120.4,48.37 120.4,48.67 120.5,48.77 120.84,48.77 120.97,48.9 120.97,49.15 120.84,49.28 120.5,49.28 120.4,49.38 120.4,64.23 120.27,64.36 119.93,64.36 119.81,64.48 119.81,64.74 119.93,64.86 120.27,64.86 120.4,64.99 120.4,65.31 120.27,65.44 119.04,65.44 118.91,65.56 118.91,65.82 119.04,65.94 119.32,65.94 119.45,66.07 119.45,66.32 119.32,66.45 119.13,66.45 119,66.58 119,69.94
  BOTTOM w0.089: CPU1.BC14 119.55,73.58 119.85,73.88 v3(119.85,73.93)
  BOTTOM w0.127: v3(120.29,37.11) 120.04,37.35 JDIMM1.131
DDR_A_D34: length 49.6
  IN6 w0.089: 121.69,69.94 121.69,70.43 121.35,70.76 121.35,73.34 v3(120.78,73.92)
  IN6 w0.099: 121.69,69.94 121.69,69.65 123.09,68.25 123.09,55.33 124.23,54.19 124.23,36.78 124.33,36.68 124.54,36.68 124.67,36.56 124.67,36.3 124.54,36.18 124.33,36.18 124.23,36.08 124.23,35.77 124.33,35.67 124.54,35.67 124.67,35.54 124.67,35.29 124.54,35.17 124.18,35.17 124.08,35.06 124.08,34.74 124.18,34.63 124.54,34.63 124.67,34.51 124.67,34.19 124.54,34.06 v3(123.68,34.06)
  BOTTOM w0.089: v3(120.78,73.92) 120.78,73.88 121.07,73.58 CPU1.BC11
  BOTTOM w0.127: v3(123.68,34.06) 123.19,34.37 123.19,36.71 123.04,36.86 JDIMM1.141
DDR_A_D35: length 47.5
  IN6 w0.089: v3(120.79,71.84) 121.16,71.47 121.16,70.64 121.39,70.41 121.39,69.94
  IN6 w0.099: 121.39,69.94 121.39,68.87 121.49,68.77 122.15,68.77 122.28,68.65 122.28,68.4 122.15,68.27 121.55,68.27 121.42,68.14 121.42,67.89 121.55,67.76 122.49,67.76 122.79,67.46 122.79,54.22 122.92,54.09 123.64,54.09 123.76,53.97 123.76,53.72 123.64,53.59 122.92,53.59 122.79,53.46 122.79,53.21 122.92,53.08 123.8,53.08 123.93,52.96 123.93,52.71 123.8,52.58 122.92,52.58 122.79,52.45 122.79,52.2 122.92,52.07 123.8,52.07 123.93,51.95 123.93,51.69 123.8,51.57 122.92,51.57 122.79,51.44 122.79,51.19 122.92,51.06 123.8,51.06 123.93,50.94 123.93,40.06 123.83,39.96 123.7,39.96 123.57,39.84 123.57,39.59 123.7,39.46 123.83,39.46 123.93,39.36 123.93,39.05 123.83,38.95 123.7,38.95 123.57,38.83 123.57,38.58 123.7,38.45 123.8,38.45 123.93,38.32 123.93,37.94 123.8,37.81 123.7,37.81 123.57,37.68 123.57,37.22 v3(123.68,37.11)
  BOTTOM w0.089: CPU1.BF11 121.13,71.5 v3(120.79,71.84)
  BOTTOM w0.127: v3(123.68,37.11) 123.64,37.25 JDIMM1.143
DDR_A_D36: length 48.5
  IN6 w0.089: 119.59,69.94 119.59,70.36 119.23,70.72 119.23,71.92 v3(119.86,72.54)
  IN6 w0.099: v3(120.29,34.06) 120.29,33.82 120.39,33.72 120.89,33.72 120.99,33.82 120.99,34.44 120.89,34.54 120.8,34.54 120.7,34.64 120.7,34.95 120.8,35.05 120.89,35.05 120.99,35.15 120.99,35.75 121.09,35.85 121.46,35.85 121.56,35.95 121.56,36.25 121.46,36.36 121.09,36.36 120.99,36.46 120.99,36.76 121.09,36.86 121.44,36.86 121.56,36.99 121.56,37.24 121.44,37.37 121.09,37.37 120.99,37.47 120.99,37.77 121.09,37.87 121.44,37.87 121.56,38 121.56,49.84 120.99,50.41 120.99,65.62 119.59,67.01 119.59,69.94
  BOTTOM w0.089: CPU1.BE14 119.51,72.29 119.76,72.54 v3(119.86,72.54)
  BOTTOM w0.127: v3(120.29,34.06) 120.84,33.51 120.84,32.5 120.38,32.03 120.02,32.03 119.74,31.76 JDIMM1.130
DDR_A_D37: length 49.3
  IN6 w0.089: v3(119.84,73.23) 119.04,72.44 119.04,70.6 119.3,70.34 119.3,69.94
  IN6 w0.099: v3(120.29,35.58) 120.7,35.99 120.7,38.17 120.79,38.27 121.14,38.27 121.27,38.4 121.27,38.65 121.14,38.77 120.79,38.77 120.7,38.87 120.7,39.18 120.79,39.28 121.14,39.28 121.27,39.41 121.27,39.66 121.14,39.78 120.79,39.78 120.7,39.88 120.7,40.19 120.79,40.29 121.14,40.29 121.27,40.42 121.27,40.67 121.14,40.8 120.79,40.8 120.7,40.89 120.7,41.2 120.79,41.3 121.14,41.3 121.27,41.43 121.27,41.68 121.14,41.81 120.79,41.81 120.7,41.91 120.7,42.21 120.79,42.31 121.14,42.31 121.27,42.44 121.27,49.72 120.7,50.29 120.7,65.49 119.3,66.89 119.3,69.94
  BOTTOM w0.089: CPU1.BD14 119.57,72.88 119.84,73.16 v3(119.84,73.23)
  BOTTOM w0.127: JDIMM1.132 120.34,31.53 120.53,31.71 120.53,31.72 121.22,32.42 121.22,33.68 120.72,34.19 120.72,35.16 v3(120.29,35.58)
