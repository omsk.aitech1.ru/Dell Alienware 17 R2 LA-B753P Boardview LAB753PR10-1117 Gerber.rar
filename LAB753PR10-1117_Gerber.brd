# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO5: length 193.5
  TOP w0.127: v3(104.35,12.84) 103.89,13.3 v2(103.88,13.3) ; v3(279.78,17.44) 279.06,18.16 279.06,19.39 277.34,21.11 275.63,21.11 275.29,21.45 UE5.44
  IN4 w0.091: v3(279.78,17.44) 279.53,17.69 274.34,17.69 273.91,17.27 268.96,17.27 268.84,17.39 267.87,17.39 267.59,17.1 260.82,17.1 258.62,14.89 251.33,14.89 250.55,14.11 240.28,14.11 239.66,13.49 226.94,13.49 226.04,12.6 221.55,12.6 220.28,11.33 217.49,11.33 216.47,12.35 208.71,12.35 205.95,15.11 195.87,15.11 193.61,12.85 174.95,12.85 174.12,12.02 170.25,12.02 169.97,11.74 167.61,11.74 167.26,12.09 157.99,12.09 156.75,13.33 154.11,13.33 153.39,14.06 152.6,14.06 151.34,15.32 140.99,15.32 140.9,15.23 130.7,15.23 130.44,14.97 106.48,14.97 v3(104.35,12.84)
  BOTTOM w0.127: JKB1.15 v3(104.35,12.84)
KSO6: length 193.1
  TOP w0.127: v2(106.06,11.91) 106.35,12.21 v3(106.35,12.85) ; v3(279.4,16.69) 279.4,17.11 278.72,17.79 278.72,19.14 277.04,20.82 275.47,20.82 275.23,21.05 UE5.45
  IN4 w0.091: v3(106.35,12.85) 108.03,14.53 120.22,14.53 121.11,13.65 126.93,13.65 127.03,13.75 129.92,13.75 130.9,14.73 141.15,14.73 141.28,14.86 151.1,14.86 152.4,13.56 153.18,13.56 153.91,12.83 156.55,12.83 157.79,11.59 166.63,11.59 167.78,10.44 171.2,10.44 171.52,10.76 171.52,11.13 171.96,11.58 174.3,11.58 175.07,12.35 193.84,12.35 196.1,14.61 205.82,14.61 209.84,10.58 220.59,10.58 221.86,11.85 226.35,11.85 227.25,12.75 249.81,12.75 251.51,14.44 258.87,14.44 260.33,15.91 268.1,15.91 268.95,16.76 274.1,16.76 274.44,17.09 279,17.09 v3(279.4,16.69)
  BOTTOM w0.127: JKB1.11 v3(106.35,12.85)
KSO7: length 195.3
  TOP w0.127: v2(96.74,13.31) 96.74,13.25 97.14,12.84 v3(97.35,12.84) ; v3(277.62,19.52) 276.63,20.51 275.36,20.51 275.23,20.65 UE5.46
  IN4 w0.091: v3(97.35,12.84) 97.35,12.86 101.86,17.37 130.37,17.37 130.64,17.63 147.01,17.63 147.28,17.9 152.43,17.9 153.04,17.29 155.48,17.29 158.92,13.86 167.34,13.86 167.5,14.03 169.86,14.03 170.29,13.59 173.4,13.59 174.4,14.59 191.45,14.59 192.54,15.68 193.95,15.68 195.12,16.85 203.91,16.85 204.52,17.45 205.66,17.45 206.26,16.85 206.83,16.85 207.82,15.86 216.65,15.86 216.79,15.72 224.28,15.72 224.76,15.24 232.29,15.24 232.98,15.93 234.07,15.93 235.05,16.9 240.17,16.9 241.05,16.02 250.03,16.02 250.46,16.45 257.71,16.45 260.1,18.84 266.84,18.84 267.7,19.71 277.44,19.71 v3(277.62,19.52)
  BOTTOM w0.127: JKB1.29 v3(97.35,12.84)
KSO8: length 198.6
  TOP w0.127: v3(105.85,10.28) 105.85,10.09 v2(105.08,9.32) ; v3(280.1,14.44) 279.55,14.99 279.55,15.76 278.98,16.33 278.98,17.12 278.37,17.74 278.37,18.63 277.92,19.08 277.43,19.08 276.26,20.25 UE5.47
  IN4 w0.091: v3(280.1,14.44) 280.1,13.02 275.47,8.39 275.47,8.15 273.13,5.82 208.26,5.82 204.82,9.26 204.32,9.26 202.72,10.86 198.44,10.86 196.95,9.36 196.04,9.36 192.53,5.86 152.83,5.86 151.19,7.5 151.19,8.31 149.25,10.25 146.67,10.25 145.27,8.86 107.28,8.86 v3(105.85,10.28)
  BOTTOM w0.127: v3(105.85,10.28) 105.85,10.28 JKB1.12
KSO9: length 194
  TOP w0.127: v2(98.94,13.29) 98.94,13.26 v3(99.35,12.84) ; v3(277.74,18.48) 277.59,18.48 276.22,19.85 UE5.48
  IN4 w0.091: v3(99.35,12.84) 99.35,13.03 103.46,17.14 130.5,17.14 130.74,17.38 148.21,17.38 148.57,17.03 150.34,17.03 150.97,17.65 152.03,17.65 154.92,14.76 157.43,14.76 158.59,13.61 167.44,13.61 167.63,13.8 169.76,13.8 170.2,13.37 173.5,13.37 174.47,14.34 191.55,14.34 192.65,15.43 194.06,15.43 195.22,16.6 204.02,16.6 204.62,17.2 205.56,17.2 206.16,16.6 206.73,16.6 207.44,15.89 207.72,15.61 216.55,15.61 216.69,15.47 224.17,15.47 224.66,14.99 232.39,14.99 233.12,15.71 234.2,15.71 235.15,16.65 240.07,16.65 240.93,15.8 250.16,15.8 250.59,16.23 257.84,16.23 260.2,18.59 266.94,18.59 267.81,19.46 276.76,19.46 v3(277.74,18.48)
  BOTTOM w0.127: JKB1.25 v3(99.35,12.84)
KSO10: length 191.2
  TOP w0.127: v2(271.99,19.92) 272.45,19.45 UE5.49 276.17,19.45 278.55,17.07 278.55,16.67 v3(278.55,16.67)
  IN4 w0.091: v3(107.35,12.84) 107.35,13.19 108.47,14.31 120.1,14.31 121.01,13.4 127.03,13.4 127.16,13.53 130.01,13.53 130.39,13.91 136.73,13.91 136.79,13.85 140.58,13.85 141.37,14.64 150.97,14.64 152.29,13.31 153.08,13.31 153.81,12.59 156.44,12.59 157.68,11.35 166.48,11.35 167.64,10.19 171.26,10.19 171.74,10.67 171.74,11 172.09,11.35 174.38,11.35 175.13,12.1 180.87,12.1 181.62,11.35 191.41,11.35 192.13,12.07 193.91,12.07 196.2,14.36 205.72,14.36 209.75,10.33 220.69,10.33 221.96,11.6 226.46,11.6 227.35,12.5 249.88,12.5 251.6,14.22 258.95,14.22 260.42,15.69 268.33,15.69 269.14,16.51 274.2,16.51 274.54,16.84 278.38,16.84 v3(278.55,16.67)
  BOTTOM w0.127: JKB1.9 v3(107.35,12.84)
KSO11: length 194.4
  TOP w0.127: v3(106.85,10.28) v2(106.85,9.39) ; UE5.50 276.19,19.05 278.07,17.17 278.07,16.56 279.13,15.5 v3(279.13,14.02)
  IN4 w0.091: v3(279.13,14.02) 279.13,12.99 272.18,6.03 251.17,6.03 250.43,6.77 247.78,6.77 247.33,6.33 209.24,6.33 209.11,6.45 207.98,6.45 204.92,9.51 204.42,9.51 202.82,11.11 198.34,11.11 196.84,9.61 195.93,9.61 192.43,6.11 152.93,6.11 151.44,7.6 151.44,8.41 149.35,10.5 146.56,10.5 145.17,9.11 108.03,9.11 v3(106.85,10.28)
  BOTTOM w0.127: JKB1.10 106.85,10.28 v3(106.85,10.28)
KSO12: length 190.1
  TOP w0.127: v3(278.66,14.98) 278.66,15.61 276.55,17.71 276.29,17.71 275.35,18.65 UE5.51 ; v3(107.85,10.28) v2(108.69,9.45)
  IN4 w0.091: v3(107.85,10.28) 108.23,10.66 113.38,10.66 113.62,10.89 122.2,10.89 123.23,9.85 144.86,9.85 146.25,11.25 149.66,11.25 151.52,9.39 156.02,9.39 158.54,6.87 192.14,6.87 195.63,10.36 196.51,10.36 198.02,11.87 203.14,11.87 204.66,10.35 206.14,10.35 209.45,7.05 247.1,7.05 249.2,9.14 249.76,9.14 252.6,11.98 259.89,11.98 260.26,12.36 275.77,12.36 277.38,13.97 277.99,13.97 278.66,14.64 v3(278.66,14.98)
  BOTTOM w0.127: v3(107.85,10.28) 107.85,10.28 JKB1.8
KSO13: length 192.1
  TOP w0.127: UE5.52 275.37,18.25 276.25,17.37 276.51,17.37 278.01,15.88 278.01,14.61 v3(277.78,14.38) ; v2(103.18,9.39) 103.85,10.06 v3(103.85,10.28)
  IN4 w0.091: v3(103.85,10.28) 104.45,10.88 113.25,10.88 113.49,11.11 126.46,11.11 126.66,10.91 138.56,10.91 139.37,10.1 144.72,10.1 146.11,11.5 149.76,11.5 151.65,9.61 156.11,9.61 158.62,7.1 192.02,7.1 195.52,10.61 196.4,10.61 197.92,12.12 203.24,12.12 204.76,10.6 206.34,10.6 208.85,8.09 221.62,8.09 222.89,9.36 249.66,9.36 252.51,12.21 259.81,12.21 260.18,12.58 275.66,12.58 277.46,14.38 v3(277.78,14.38)
  BOTTOM w0.127: JKB1.16 v3(103.85,10.28)
KSO14: length 185.9
  TOP w0.127: v3(277.57,15.49) 277.57,15.64 275.36,17.85 UE5.53 ; v2(108.05,11.93) 108.44,12.31 v3(108.44,12.84)
  IN4 w0.091: v3(277.57,15.49) 277.09,15.97 274.92,15.97 272.68,13.73 259.7,13.73 259.3,13.32 252.06,13.32 249.19,10.45 222.22,10.45 221.1,9.34 209.38,9.34 205.35,13.36 196.53,13.36 193.52,10.36 176.64,10.36 176.29,10 172.98,10 172.12,9.15 167.12,9.15 166.57,9.7 157.92,9.7 156.03,11.59 153.39,11.59 152.66,12.32 151.87,12.32 150.52,13.66 143.77,13.66 142.16,12.05 127.28,12.05 126.93,12.4 120.6,12.4 119.58,13.42 110.71,13.42 109.65,12.36 108.92,12.36 v3(108.44,12.84)
  BOTTOM w0.127: v3(108.44,12.84) 108.35,12.75 JKB1.7
KSO15: length 188.2
  TOP w0.127: UE5.54 275.34,17.45 277.14,15.65 277.14,14.19 v3(277.99,13.34) ; v3(108.85,10.26) 109,10.26 109.71,10.96 109.72,10.96 v2(109.77,11.01)
  IN4 w0.091: v3(277.99,13.34) 277.99,12.84 277.07,11.91 260.52,11.91 260.14,11.54 252.79,11.54 249.95,8.7 249.38,8.7 247.24,6.55 209.33,6.55 206.03,9.84 204.44,9.84 202.93,11.35 198.23,11.35 196.74,9.86 195.83,9.86 192.33,6.35 153.04,6.35 151.69,7.7 151.69,8.52 149.45,10.75 146.46,10.75 145.06,9.35 109.75,9.35 v3(108.85,10.26)
  BOTTOM w0.127: JKB1.6 108.85,10.25 v3(108.85,10.26)
KSO16: length 225.7
  TOP w0.127: v3(79,11) 80.01,9.98 v2(89.44,9.98) 90.01,9.98 91.4,11.38 108.79,11.38 109.35,11.94 v3(109.35,12.84) ; v3(282.75,16.47) 282.75,15.65 282.4,15.29 UE5.81
  IN4 w0.091: v3(109.35,12.84) 110.15,13.64 119.71,13.64 120.7,12.65 127.07,12.65 127.45,12.27 130.22,12.27 131.19,13.25 136.45,13.25 136.51,13.19 140.85,13.19 141.65,13.98 150.52,13.98 151.94,12.57 152.77,12.57 153.5,11.84 156.13,11.84 158.03,9.95 166.67,9.95 167.22,9.4 172.02,9.4 172.85,10.23 176.2,10.23 176.58,10.61 191.72,10.61 192.44,11.32 194.13,11.32 196.42,13.61 205.43,13.61 209.46,9.59 221,9.59 222.09,10.67 249.02,10.67 251.9,13.55 259.21,13.55 259.61,13.95 272.32,13.95 274.61,16.25 277.76,16.25 277.98,16.03 282.32,16.03 v3(282.75,16.47)
  BOTTOM w0.127: JKB2.4 v3(79,11) JKB2.3 ; v3(109.35,12.84) 109.35,12.84 JKB1.5
KSO17: length 188.8
  TOP w0.127: UE5.82 282.8,14.46 v3(282.84,14.51) ; v2(110.66,9.44) 110.64,9.45 110.64,9.45 v3(109.85,10.24)
  IN4 w0.091: v3(282.84,14.51) 282.5,14.85 279.19,14.85 278.08,13.74 277.47,13.74 275.86,12.13 260.35,12.13 259.98,11.76 252.69,11.76 249.85,8.92 249.29,8.92 247.14,6.77 209.42,6.77 206.09,10.09 204.57,10.09 203.04,11.62 198.12,11.62 196.61,10.11 195.73,10.11 192.19,6.57 153.17,6.57 151.94,7.81 151.94,8.62 149.56,11 146.36,11 144.96,9.6 110.49,9.6 v3(109.85,10.24)
  BOTTOM w0.127: JKB1.4 v3(109.85,10.24)
LAN_ACTIVITY#: length 97.4
  TOP w0.127: v3(321.76,66.83) 320.64,65.71 320.64,51.27 317.91,48.54 317.91,43.17 314.66,39.92 314.66,38.86 314.08,38.28 311.56,38.28 309.03,35.75 309.03,32.79 310.46,31.36 313.35,31.36 313.61,31.1 314.77,31.1 315.01,31.35 315.01,32.59 315.42,33 UL1.38 ; v3(322.14,87.48) 322.14,88.5 CL27.1 320.88,89.75 v2(320.88,99.62) 320.88,104.24 323.7,107.06 325.07,107.06 JLAN.10
  IN4 w0.091: v3(322.14,87.48) 323.2,86.41 323.2,77.55 324.8,75.95 324.8,72.9 323.09,71.19 323.09,68.16 v3(321.76,66.83)
LAN_LED2#: length 45
  TOP w0.127: RL15.1 CL29.1 324.31,74.92 325.49,74.92 325.85,75.27 325.85,76.6 325.3,77.14 324.34,77.14 323.93,77.55 323.93,81.14 325.24,82.45 v2(331.31,82.45) 336.82,82.45 338,83.63 338,88.27 337.19,89.08 332.19,89.08 328.81,92.47 328.81,93.72 328.41,94.11 JLAN.13
LAN_LED2#_R: length 39.5
  TOP w0.127: UL1.23 319.45,37.25 318.65,38.06 v1(318.65,45.62) 318.65,48.6 321.03,50.99 321.03,65.34 323.34,67.65 323.34,72.04 322.9,72.48 RL15.2
LAN_LINK#: length 42.3
  TOP w0.127: v3(337.36,87.63) 337.36,84.6 336.39,83.62 v1(335.13,83.62) 325.25,83.62 323.28,81.65 323.28,77.83 324.22,76.89 324.49,76.89 324.68,76.7 CL28.1 RL13.1 ; JLAN.11 329.17,96.4 v3(329.35,96.22)
  IN2 w0.122: v3(337.36,87.63) 336.16,88.84 332.42,88.84 329.35,91.91 v3(329.35,96.22)
LAN_LINK#_R: length 52.8
  TOP w0.127: UL1.39 315.47,32.6 315.27,32.4 315.27,31.24 314.66,30.63 RL4.2 313.25,31.1 310.35,31.1 308.78,32.68 308.78,35.86 311.45,38.53 313.97,38.53 314.4,38.97 314.4,40.02 317.65,43.28 317.65,48.65 320.26,51.25 v1(320.26,58.05) 320.26,69.7 QL3.2
LAN_MDIN0: length 59.7
  TOP w0.097: v3(322.45,32.32) 322.16,32.03 321.96,32.03 321.39,32.6 UL1.12
  IN1 w0.089: v3(322.45,32.32) 322.12,31.99 317.48,31.99 316.36,33.11 316.36,42.09 319.69,45.42 319.69,49.52 320.03,49.86 320.03,55.86 319.09,56.8 319.09,63.91 320.61,65.43 320.61,69.24 324.91,73.53 324.91,77.66 v3(325.24,78)
  BOTTOM w0.097: v3(325.24,78) 325.03,78.2 325.03,78.4 325.45,78.81 TL1.11
LAN_MDIN1: length 53.4
  TOP w0.097: v3(321.86,33.88) 321.86,33.85 321.67,33.65 321.54,33.65 321.4,33.8 UL1.15
  IN1 w0.089: v3(321.86,33.88) 321.7,33.72 320.97,33.72 320.77,33.92 320.77,35.75 318.14,38.38 318.14,41.49 321.92,45.28 321.92,64.2 322.46,64.73 322.46,68.8 326.52,72.87 326.52,75.65 327.88,77 327.88,77.68 v3(328.21,78.01)
  BOTTOM w0.097: v3(328.21,78.01) 328.07,78.14 328.02,78.2 328.02,78.41 328.45,78.84 TL1.8
LAN_MDIN2: length 52.4
  TOP w0.097: UL1.18 321.38,35 321.46,35.08 321.95,35.08 322.36,35.49 v3(322.44,35.49)
  IN6 w0.089: v3(322.44,35.49) 322.64,35.49 322.83,35.68 322.83,69.52 325.66,72.34 325.66,74.73 330.12,79.2 330.74,79.2 331.23,78.71 v3(331.23,78.03)
  BOTTOM w0.097: TL1.5 331.45,78.79 331.08,78.42 331.08,78.18 v3(331.23,78.03)
LAN_MDIN3: length 60.4
  TOP w0.097: UL1.21 320.25,37.01 320.36,37.11 320.55,37.11 v3(320.74,36.92)
  IN6 w0.089: v3(334.24,78.04) 334.08,78.21 334.08,79.95 332.79,81.24 325.14,81.24 323.99,80.09 323.99,72.99 321.1,70.1 321.1,38.3 320.93,38.13 320.93,37.11 v3(320.74,36.92)
  BOTTOM w0.097: v3(334.24,78.04) 334.08,78.21 334.08,78.42 334.45,78.8 TL1.2
LAN_MDIP0: length 59.6
  TOP w0.097: UL1.11 320.95,32.2 321.44,32.2 321.85,31.78 322.42,31.78 v3(322.45,31.74)
  IN1 w0.089: v3(324.66,78) 324.66,73.64 320.36,69.34 320.36,65.54 318.84,64.01 318.84,56.69 319.78,55.75 319.78,49.97 319.43,49.62 319.43,45.52 316.1,42.19 316.1,33.01 317.37,31.74 v3(322.45,31.74)
  BOTTOM w0.097: v3(324.66,78) 324.78,78.12 324.78,78.48 324.45,78.81 TL1.12
LAN_MDIP1: length 53.5
  TOP w0.097: UL1.14 321.76,33.4 v3(321.86,33.3)
  IN1 w0.089: v3(321.86,33.3) 321.69,33.47 320.86,33.47 320.51,33.82 320.51,35.65 317.88,38.28 317.88,41.49 317.89,41.5 317.89,41.6 321.67,45.38 321.67,64.31 322.2,64.84 322.2,68.9 326.27,72.97 326.27,75.75 327.62,77.11 v3(327.62,78.01)
  BOTTOM w0.097: v3(327.62,78.01) 327.76,78.15 327.76,78.44 327.45,78.75 TL1.9
LAN_MDIP2: length 52.2
  TOP w0.097: v3(322.44,34.91) 322.31,34.91 322.11,34.7 321.55,34.7 321.45,34.6 UL1.17
  IN6 w0.089: v3(322.44,34.91) 322.74,35.21 322.74,35.23 323.09,35.57 323.09,69.41 325.91,72.24 325.91,74.63 330.23,78.95 330.63,78.95 330.97,78.6 330.97,78.36 v3(330.64,78.03)
  BOTTOM w0.097: v3(330.64,78.03) 330.82,78.21 330.82,78.45 330.45,78.83 TL1.6
LAN_MDIP3: length 60.3
  TOP w0.097: v3(321.37,36.92) 321.69,36.6 321.69,35.97 321.52,35.8 UL1.20
  IN6 w0.089: v3(321.37,36.92) 321.19,37.11 321.19,38.02 321.36,38.19 321.36,70 324.25,72.89 324.25,79.99 325.25,80.99 332.68,80.99 333.82,79.85 333.82,78.21 v3(333.66,78.04)
  BOTTOM w0.097: v3(333.66,78.04) 333.82,78.21 333.82,78.44 333.45,78.81 TL1.3
LANCLK_REQ#: length 117.8
  TOP w0.127: UL1.4 317.85,30.42 v1(317.52,30.09) 317.25,29.82 316.72,29.82 316.35,29.45 316.35,28.21 v3(316.17,28.03)
  IN1 w0.099: v3(238.13,26.03) 238.61,26.03 244.44,31.86 255.73,31.86 264.95,22.65 273.48,22.65 273.95,22.18 279.93,22.18 280.52,22.77 283.2,22.77 284.09,23.66 286.63,23.66 290.1,27.13 301.79,27.13 301.97,27.31 311.57,27.31 312.65,28.39 315.81,28.39 v3(316.17,28.03)
  IN4 w0.091: v3(219.62,28.51) 220.03,28.51 222.31,26.23 224.67,26.23 225.22,26.79 231.73,26.79 232.14,26.37 234.94,26.37 234.99,26.42 237.74,26.42 v3(238.13,26.03)
  BOTTOM w0.089: UH1.AF3 219.75,29.88 219.75,29.41 219.55,29.22 219.55,28.57 v3(219.62,28.51) 219.84,28.28 219.84,27.27 219.84,27.27
  BOTTOM w0.127: RH77.2 219.76,24.73 220.11,25.07 220.11,26.14 219.84,26.4 219.84,27.27
LCD_TEST: length 327.6
  TOP w0.127: v3(278.61,13.7) 279,13.31 279,12.89 278.8,12.69 UE5.72 ; JEDP1.33 91.45,124.87 v3(91.17,124.87)
  IN2 w0.099: v3(233.3,49.51) 231.64,51.17 226.48,51.17 225.04,52.61 220.54,52.61 219.66,51.72 209.87,51.72 204.13,45.99 202.23,45.99 200.95,44.71 200.95,33.89 189.77,22.71 180.13,22.71 179.55,22.13 174.62,22.13 172.27,24.47 170.46,24.47 169.06,25.88 169.06,27.46 161.5,35.01 161.5,36.75 158.55,39.7 158.55,40.39 157.13,41.81 157.13,44.52 148.01,53.65 143.79,53.65 139.04,58.39 139.04,65.09 136.2,67.93 136.2,82.77 134.53,84.44 134.53,88.6 133.17,89.96 133.17,102.48 129.81,105.84 113.69,105.84 110.49,102.64 110.49,102.2 110.3,102.01 91.89,102.01 91.25,101.37 86.98,101.37 85.01,103.34 85.01,120.59 89.29,124.87 v3(91.17,124.87)
  IN6 w0.099: v3(278.61,13.7) 278.61,14.22 278.16,14.67 278.16,15.58 277.84,15.9 277.56,15.9 273.37,20.09 272.24,20.09 269.42,22.91 265.84,22.91 260.17,28.59 259.65,28.59 256.93,31.31 256.93,34.36 252.26,39.03 251.31,39.03 250.48,39.86 250.48,40.81 248.97,42.32 248.97,43.06 245.34,46.69 243.25,46.69 242.34,47.59 242.34,48.92 240.53,50.74 238.64,50.74 238.25,51.12 234.2,51.12 233.3,50.21 v3(233.3,49.51)
  BOTTOM w0.127: v3(278.61,13.7) v1(278.61,14.31)
LED_B_7313#_A#: length 61.1
  TOP w0.127: JPWR1.13 179.15,146.9 180,146.05 180,145.02 180.22,144.81 180.22,143.29 181.12,142.39 181.12,139.32 181.42,139.02 181.42,134.62 181.79,134.25 181.79,132.86 181.47,132.54 v3(181.47,132.2) ; v2(211.44,117.18) 211.76,116.87 v3(213.28,116.87) 213.28,116.77 213.6,116.45 214.56,116.45 214.76,116.24 UE3.14
  IN6 w0.099: v3(181.47,132.2) 181.47,132.36 181.74,132.63 184.93,132.63 185.71,131.85 196.18,131.85 199.13,128.9 199.13,126.99 201,125.11 204.51,125.11 212.75,116.87 v3(213.28,116.87)
LED_G_7313#_A#: length 60.8
  TOP w0.127: v3(213.87,116.87) v2(213.87,117.57) 214.05,117.74 UE3.11 ; JPWR1.12 178.65,147.03 179.74,145.94 179.74,144.89 179.96,144.67 179.96,143.18 180.84,142.31 180.84,141.66 180.62,141.44 180.51,141.44 180.2,141.14 180.2,139.79 181.14,138.85 181.14,134.48 180.89,134.23 v3(180.89,132.2)
  IN6 w0.099: v3(213.87,116.87) 213.43,117.31 212.63,117.31 204.59,125.35 201.13,125.35 199.4,127.08 199.4,128.94 196.27,132.08 185.81,132.08 185.03,132.86 181.41,132.86 180.89,132.34 v3(180.89,132.2)
LED_R_7313#_A#: length 59.9
  TOP w0.127: JPWR1.11 178.15,145.92 178.95,145.12 178.95,143.83 179.34,143.44 179.34,139.75 180.22,138.88 180.22,133.81 v3(180.43,133.59) ; v2(212.37,118.7) 212.8,118.27 v3(214.31,118.27) 214.33,118.24 UE3.10
  IN6 w0.099: v3(214.31,118.27) 211.11,121.46 208.79,121.46 204.66,125.59 201.22,125.59 199.64,127.17 199.64,129.03 196.44,132.22 196.44,132.23 196.38,132.3 185.94,132.3 185.08,133.16 180.86,133.16 v3(180.43,133.59)
LG_3V:
  vias: v1(26.09,27.31)
LG_5V: length 7.3
  IN1 w1.016: 33.34,30.13 33.21,30.25 27.12,30.25
  BOTTOM w0.127: v1(25.14,29.34) 25.16,29.36 v3(25.16,30.32)
  vias: v3(25.77,30.32) v3(34.27,30.48) v3(34.27,29.87)
LG_+1.05VSP: length 9.4
  TOP w0.127: v2(246.22,29.99) 245.81,29.58 v3(245.81,29.05)
  IN2 w1.016: 246.95,28.86 248.99,28.86 251.21,26.63 254.28,26.63
  vias: v3(245.18,29) v3(255.4,27.08) v3(255.4,26.44)
LG_+1.35VS_VGAP: length 2.9
  TOP w0.127: v3(134.69,111.41) v2(134.01,111.41)
  IN2 w1.016: 136.97,113.57 136.97,112.3 136.27,111.6
  vias: v3(135.38,111.41) v3(136.84,115.03) v3(136.84,114.33)
LGATE1: length 4.9
  TOP w0.127: v3(133.92,124.23) v2(133.02,124.23)
  IN2 w1.016: 129.73,122.33 131.13,122.33 132.84,124.04 132.97,124.04
  vias: v3(127.7,122.52) v3(128.21,126.46) v3(128.28,122.52) v3(128.79,126.46) v3(134.5,124.55)
LGATE2: length 15.7
  TOP w0.127: v3(134.18,126.2) v2(133.11,126.2)
  IN2 w1.016: 119.64,128.49 119.89,128.74 126.56,128.74 127.64,127.66 130.62,127.66 132.53,125.76 132.91,125.76
  vias: v3(118.8,127.73) v3(118.99,122.58) v3(119.38,127.73) v3(119.57,122.58) v3(134.75,126.39)
LGATE3: length 6.9
  TOP w0.127: v3(104.9,118.39) 105.13,118.16 v1(105.49,118.16)
  IN2 w1.016: 105.79,118.77 106.43,119.41 108.71,119.41 110.87,121.57
  vias: v3(104.9,117.81) v3(110.61,127.66) v3(110.61,122.52) v3(111.19,127.66) v3(111.19,122.52)
LID_SW: length 83
  TOP w0.127: v3(221.66,126.32) 222.07,125.9 222.07,124.21 222.3,123.99 JLOGO1.3 ; v3(169.17,135.74) 168.71,135.74 167.31,137.14 v2(163.58,137.14) 159.6,137.14 158.92,136.45 158.92,135.68 RE38.2 157.71,134.47 QE14.2
  IN4 w0.091: v3(169.17,135.74) 170.68,135.74 171.2,135.23 174.26,135.23 174.8,134.69 183.68,134.69 186.26,137.28 v3(187.14,137.28)
  IN6 w0.099: v3(221.66,126.32) 221.38,126.6 214.96,126.6 214.2,127.36 208.4,127.36 204.16,131.6 202.09,131.6 199.52,134.16 198.26,134.16 197.66,134.76 197.66,135.42 194.21,138.88 188.74,138.88 v3(187.14,137.28)
  BOTTOM w0.127: QE10.1 172.2,135.26 171.72,135.74 v3(169.17,135.74)
LID_SW_IN#: length 431.7
  TOP w0.127: RE70.2 CE43.1 291.14,8.71 291.78,9.36 291.78,10.9 289.6,13.08 288.22,13.08 287.12,14.18 287.12,16.07 286.08,17.11 286.08,18.37 286.67,18.95 v3(286.67,19.04) 286.25,19.46 286.25,19.94 286.53,20.22 288.71,20.22 289.14,20.65 UE5.115 290.96,20.65 291.21,20.4 293.38,20.4 294.41,21.43 294.41,22.2 295.07,22.86 295.99,22.86 296.81,23.69 296.81,28.27 298.49,29.95 v1(298.49,30.77) 298.49,31.75 v3(298.96,32.22) ; RH102.2 231.99,15.39 232.85,16.25 232.85,16.64 v3(232.86,16.64)
  IN2 w0.099: v3(232.86,16.64) 233.91,16.64 234.04,16.76 240.07,16.76 240.84,16 241.97,16 242.46,15.51 257.33,15.51 261.36,19.53 266.54,19.53 268.25,21.24 270.91,21.24 271.6,21.93 272.65,21.93 v3(273.08,21.49) ; v3(230.2,52.9) 229.77,53.33 229.77,53.68 229.21,54.24 226.94,54.24 224.26,56.93 211.29,56.93 207.5,53.13 207.5,51.63 203.44,47.57 201.38,47.57 198.95,45.14 198.95,36.63 198.62,36.3 198.62,33.93 189.13,24.44 178.75,24.44 177.71,25.48 173.94,25.48 172.02,27.4 172.02,28.64 171.24,29.42 171.24,30.12 167.44,33.93 167.44,34.9 165.68,36.66 164.54,36.66 161.52,39.68 161.52,40.82 161.04,41.3 161.04,46.66 158.04,49.67 158.04,55.31 157.65,55.7 157.65,56.78 157.14,57.29 157.14,65.64 155.93,66.85 155.93,76.92 156.26,77.25 156.26,77.92 155.59,78.59 155.59,90.38 154.14,91.83 154.14,115.47 149.73,119.88 149.73,124.24 151.59,126.1 151.59,127.3 150.7,128.18 150.7,129.91 151.34,130.54 151.34,134.23 151.91,134.8 151.91,136.96 153.72,138.77 153.72,139.13 154.28,139.69 156.89,139.69 158.31,138.27 160.47,138.27 160.85,137.89 160.85,137.73 161.49,137.09 166.6,137.09 167.31,137.8 169.9,137.8 170.33,137.37 170.33,136.83 170.9,136.27 174.87,136.27 v3(175.05,136.45)
  IN6 w0.099: v3(298.96,32.22) 299.13,32.05 305.22,32.05 307.9,29.37 308.72,29.37 308.87,29.22 325.12,29.22 329.14,33.24 334.41,33.24 v3(335.43,34.27) ; v3(286.67,19.04) 286.49,18.86 278.52,18.86 278.27,19.11 275.93,19.11 273.88,21.15 273.42,21.15 v3(273.08,21.49) 273.08,21.95 270.97,24.06 270.48,24.06 264.46,30.09 260.66,30.09 258.15,32.59 258.15,35.72 250.73,43.14 250.56,43.14 241.3,52.41 238.63,52.41 238.24,52.03 231.07,52.03 v3(230.2,52.9)
  BOTTOM w0.127: v3(273.08,21.49) 273.48,21.49 DE1.1 ; v3(175.05,136.45) 174.6,136 QE10.2
LID_SW_IN#_D: length 6
  BOTTOM w0.127: UE1.23 269.15,21.34 v1(270.12,21.34) RE8.2 271.75,22.03 DE1.2
LOGO_LED_B_DRV#: length 12.1
  TOP w0.127: JLOGO1.6 219.9,124.02 219.13,124.79 v3(218.63,124.79) ; v2(213.91,119.61) 213.91,119.28 v3(214.31,118.87) 214.44,118.74 UE3.9
  IN1 w0.099: v3(218.63,124.79) 214.31,120.47 v3(214.31,118.87)
LOGO_LED_G_DRV#: length 14.6
  TOP w0.127: JLOGO1.5 220.7,124.05 219.5,125.25 218.04,125.25 217.16,124.37 215.06,124.37 213.53,122.84 v2(213.53,121.35) 213.84,121.03 215.08,121.03 216.18,119.93 UE3.8
LOGO_LED_R_DRV#: length 11.8
  TOP w0.127: JLOGO1.4 221.5,124.63 v3(221.66,124.79) ; v2(215.33,121.49) 216.21,121.49 v3(217.11,120.58) 217.18,120.51 UE3.6
  IN1 w0.099: v3(221.66,124.79) 220.18,124.79 217.11,121.73 v3(217.11,120.58)
LPBK: length 8.4
  TOP w0.127: v3(151.49,135.66) 151.63,135.8 RM78.2 150.71,137.77 RM74.2 149.49,137.77 v1(149.35,137.63)
  BOTTOM w0.127: UM8.23 152.15,132.37 152.44,132.65 152.44,134.28 152.03,134.69 152.03,135.12 v3(151.49,135.66)
LPC_AD0: length 63.8
  TOP w0.127: v3(284.66,26.21) 284.8,26.35 UE5.10
  IN4 w0.089: 231.65,37.52 231.59,37.46
  IN4 w0.091: 231.65,37.52 231.93,37.8 235.89,37.8 236.65,38.56 239.43,38.56 241.76,36.24 243.8,36.24 244.46,35.58 244.46,34.15 246.66,31.96 254.41,31.96 258.89,27.47 261.26,27.47 264.42,24.31 275.38,24.31 275.38,24.32 275.93,24.32 275.93,24.31 278.69,24.31 280.2,25.82 284.27,25.82 v3(284.66,26.21) ; 231.59,37.46 v3(231.43,37.3)
  BOTTOM w0.089: UH1.A20 230.51,37.04 231.17,37.04 v3(231.43,37.3)
LPC_AD1: length 66.5
  TOP w0.127: UE5.8 285.6,25.99 v3(285.18,25.58) ; v1(234.6,36.54) 234.19,36.13 v3(233.81,36.13)
  IN4 w0.091: v3(233.81,36.13) 233.94,36.26 239.68,36.26 240.38,35.56 242.26,35.56 243.31,34.51 243.31,33.82 245.67,31.46 254.2,31.46 258.68,26.98 261.1,26.98 264.23,23.84 273.24,23.84 273.25,23.84 274.36,23.84 275.19,23.01 279.73,23.01 281.07,24.34 281.07,24.94 281.47,25.35 284.96,25.35 v3(285.18,25.58)
  BOTTOM w0.089: 232.35,36.73 232.14,36.73 232.04,36.83 230.28,36.83 229.94,37.17 UH1.C20
  BOTTOM w0.127: 232.35,36.73 233.21,36.73 v3(233.81,36.13)
LPC_AD2: length 67.4
  TOP w0.089: v1(231.24,36.04) 231.59,35.7 v3(231.84,35.7)
  TOP w0.127: v3(286.44,24.69) 286,25.13 UE5.7
  IN4 w0.089: 232.35,35.3 232.24,35.3 v3(231.84,35.7)
  IN4 w0.091: 232.35,35.3 233.87,35.3 234.25,35.69 239.62,35.69 240.19,35.12 242.08,35.12 242.87,34.33 242.87,33.63 245.51,30.99 254.01,30.99 258.49,26.51 260.91,26.51 264.01,23.4 264.32,23.4 264.99,22.73 270.96,22.73 271.16,22.93 273.92,22.93 274.12,22.73 274.76,22.73 274.98,22.51 279.94,22.51 281.55,24.12 282.6,24.12 283.17,24.69 v3(286.44,24.69)
  BOTTOM w0.089: UH1.A18 231.39,36.36 231.84,35.9 v3(231.84,35.7)
LPC_AD3: length 67.3
  TOP w0.127: UE5.5 286.8,25.85 v3(286.72,25.77)
  IN4 w0.091: v3(286.72,25.77) 286.05,25.1 281.53,25.1 281.29,24.86 281.29,24.26 279.79,22.76 275.13,22.76 274.27,23.62 264.11,23.62 261,26.73 258.58,26.73 254.1,31.21 245.6,31.21 243.09,33.72 243.09,34.42 242.17,35.34 240.28,35.34 239.71,35.9 234.16,35.9 233.96,35.7 v3(232.42,35.7)
  BOTTOM w0.089: 232.35,36.16 v1(232.07,36.45) 231.87,36.64 230.19,36.64 230.01,36.46 229.58,36.46 UH1.C18
  BOTTOM w0.127: v3(232.42,35.7) 232.42,36.09 232.35,36.16
LPC_FRAME#: length 68.2
  TOP w0.089: v1(230.1,37.29) 230.22,37.4 v3(230.82,37.4)
  TOP w0.127: v3(287.23,26.08) 287.2,26.1 UE5.4
  IN4 w0.091: v3(230.82,37.4) 230.82,37.18 231.14,36.86 231.66,36.86 232.36,37.56 236.08,37.56 236.86,38.34 239.32,38.34 241.67,35.99 243.74,35.99 244.24,35.49 244.24,34.04 246.57,31.71 254.3,31.71 258.78,27.23 261.2,27.23 264.36,24.07 275.48,24.07 275.48,24.07 275.83,24.07 275.83,24.07 278.75,24.07 280.27,25.58 284.6,25.58 285.21,26.19 287.11,26.19 v3(287.23,26.08)
  BOTTOM w0.089: v3(230.82,37.4) 230.63,37.6 UH1.B21
LTRON_LED_B_DRV#: length 203.5
  TOP w0.127: JTRONF.8 188.61,13.06 188.15,12.6 188.15,10.89 190.64,8.4 193.42,8.4 196.64,11.61 v2(196.64,14.2) 196.64,23.12 195.26,24.49 195.26,28.68 201.03,34.44 201.03,48.39 201.99,49.35 201.99,50.58 v3(202.33,50.92)
  IN2 w0.099: v3(175.69,133.66) 174.31,135.04 166.46,135.04 166.25,135.26 162.31,135.26 161.77,134.72 156.37,134.72 154.23,132.57 154.23,127.03 158,123.26 158,114.42 156.2,112.62 156.2,102.85 157.67,101.38 157.67,100.3 156.15,98.78 156.15,93.57 157.81,91.91 157.81,81.06 159.62,79.26 159.62,66.8 159.78,66.64 159.78,65.53 161.54,63.77 163.42,63.77 167.99,59.19 193.53,59.19 201.8,50.92 v3(202.33,50.92)
  BOTTOM w0.127: v3(175.69,133.66) 175.69,134.69 176.5,135.5 UE8.9
LTRON_LED_G_DRV#: length 207.1
  TOP w0.127: v3(202.96,50.92) 202.25,50.21 202.25,49.24 201.32,48.31 201.32,34.38 195.52,28.57 195.52,24.62 197.06,23.09 v2(197.06,17.72) 197.06,11.67 193.52,8.14 190.39,8.14 187.81,10.72 JTRONF.7
  IN2 w0.099: v3(202.96,50.92) 202.56,50.52 201.88,50.52 193.43,58.97 167.9,58.97 163.35,63.52 161.43,63.52 159.54,65.41 159.54,66.58 159.39,66.72 159.39,79.16 157.58,80.97 157.58,91.82 155.9,93.5 155.9,98.85 157.44,100.39 157.44,101.29 155.97,102.76 155.97,112.74 157.77,114.54 157.77,123.17 154,126.94 154,133.55 155.4,134.95 161.65,134.95 162.18,135.48 166.34,135.48 166.55,135.27 175.73,135.27 v3(177.34,133.66)
  BOTTOM w0.127: v3(177.34,133.66) 177.34,133.97 177.68,134.31 UE8.8
LTRON_LED_R_DRV#: length 211.8
  TOP w0.127: JTRONF.6 187.01,12.93 186.69,12.61 186.69,11.39 190.2,7.89 193.63,7.89 197.47,11.73 v2(197.47,20.3) 197.47,20.39 199.36,22.27 201.46,22.27 203.52,24.32 203.52,24.48 204.2,25.16 204.2,30.36 201.58,32.98 201.58,48.07 202.67,49.17 v3(202.67,50.03)
  IN2 w0.099: v3(202.67,50.03) 202.05,50.03 193.34,58.74 167.81,58.74 163.28,63.27 161.33,63.27 159.31,65.29 159.31,66.48 159.14,66.64 159.14,79.09 157.36,80.88 157.36,91.73 155.67,93.41 155.67,98.94 157.22,100.49 157.22,101.2 155.75,102.67 155.75,112.91 157.54,114.71 157.54,123.07 153.77,126.84 153.77,133.65 155.3,135.18 160.23,135.18 161.67,136.62 166.82,136.62 167.21,136.23 170.26,136.23 170.77,135.73 176.24,135.73 v3(178.31,133.66)
  BOTTOM w0.127: UE8.6 178.68,134.03 v3(178.31,133.66)
LX_3V: length 4.9
  IN1 w1.016: 28.6,22.86 28.59,22.87 27.07,22.87 24.7,25.24
  vias: v1(23.24,26.09) v3(23.75,26.35) v3(23.75,25.74) v3(29.72,23.01) v3(29.72,22.38) v3(29.72,21.74) v3(30.36,23.65) v3(30.36,23.01) v3(30.36,22.38) v3(30.36,21.74) v3(30.36,21.11) v3(30.99,23.65) v3(30.99,23.01) v3(30.99,22.38) v3(30.99,21.74) v3(30.99,21.11) v3(31.63,23.65) v3(31.63,23.01) v3(32.26,23.65) v3(32.26,23.01) v3(33.21,23.59) v3(33.21,22.95) v3(33.78,23.27)
LX_5V: length 7.4
  TOP w0.127: 29.05,36.31 29.05,36.34 29.72,37.01 v1(30.3,37.01)
  IN6 w1.016: 30.16,32.79 24.32,32.79
  vias: v3(23.43,31.99) v3(23.43,31.4) v3(30.99,34.63) v3(30.99,33.99) v3(30.99,33.36) v3(30.99,32.73) v3(31.63,34.63) v3(31.63,33.99) v3(31.63,33.36) v3(31.63,32.73) v3(32.26,34.63) v3(32.26,33.99) v3(32.26,33.36) v3(32.26,32.73) v3(32.9,34.63) v3(32.9,33.99) v3(32.9,33.36) v3(32.9,32.73)
LX_+1.05V_GPUP:
  vias: v1(146.2,89.99)
LX_CHG: length 11.1
  IN4 w1.016: 43.88,42.7 44.26,43.08 45.79,43.08 46.67,43.97 48.58,43.97 50.29,42.25 53.72,42.25
  vias: v2(60.8,41.98) v3(41.85,40.98) v3(41.85,40.35) v3(54.68,42.57) v3(54.68,41.94) v3(54.68,41.3) v3(54.68,40.67) v3(54.99,40.16) v3(55.31,42.57) v3(55.31,41.94) v3(55.31,41.3) v3(55.31,40.67) v3(55.63,40.16) v3(55.95,42.57) v3(55.95,41.94) v3(55.95,41.3) v3(55.95,40.67)
M_CLK_DDR0: length 46.8
  IN6 w0.099: v3(111.62,70.15) 111.89,69.88 112.08,69.88 112.28,69.68 112.28,68.7 111.97,68.4 111.97,51.97 112.1,51.84 112.92,51.84 113.16,51.6 113.16,51.19 112.92,50.94 112.1,50.94 111.97,50.82 111.97,50.57 112.1,50.44 112.92,50.44 113.16,50.2 113.16,49.78 112.92,49.54 112.1,49.54 111.97,49.41 111.97,49.16 112.1,49.04 112.91,49.04 113.13,48.82 113.13,48.35 112.91,48.14 112.19,48.14 112.06,48.01 112.06,47.76 112.19,47.63 112.91,47.63 113.13,47.42 113.13,46.4 113.09,46.35 113.09,45.27 113.13,45.23 113.13,43.31 112.92,43.11 112.38,43.11 111.78,43.72 111.26,43.72 111.13,43.59 111.13,43.25 111.23,43.15 111.43,43.15 111.67,42.91 111.67,42.49 111.43,42.25 111.26,42.25 111.13,42.12 111.13,41.51 111.26,41.38 111.97,41.38 112.08,41.49 v3(112.08,41.75)
  BOTTOM w0.089: CPU1.BF25 112.37,71.48 112.46,71.39 112.46,71.09 112.13,70.76 112.13,69.93 112.01,69.82 111.64,69.82 111.54,69.92 111.54,70.06 v3(111.62,70.15)
  BOTTOM w0.127: v3(112.08,41.75) 111.84,41.51 111.53,41.51 111.19,41.17 111.19,40.13 111.04,39.98 JDIMM1.101
M_CLK_DDR1: length 51
  IN6 w0.099: v3(111.83,35.46) 111.83,35.65 111.7,35.78 111.43,35.78 111.19,36.02 111.19,38.94 111.05,39.07 110.67,39.07 110.42,39.31 110.42,39.72 110.67,39.97 111.35,39.97 111.48,40.09 111.48,40.34 111.35,40.47 110.48,40.47 110.23,40.71 110.23,44.38 110.53,44.68 112.1,44.68 112.19,44.76 112.19,46.65 112.1,46.74 111.3,46.74 111.07,46.96 111.07,68.77 111.06,68.78 111.06,73.36 111.32,73.62 111.63,73.62 111.76,73.75 v3(111.76,73.88)
  BOTTOM w0.089: CPU1.BC25 112.06,73.58 v3(111.76,73.88)
  BOTTOM w0.127: v3(111.83,35.46) 112.07,35.7 112.22,35.7 112.33,35.59 112.33,34.06 111.51,33.24 111.51,31.9 111.34,31.73 JDIMM1.102
M_CLK_DDR2: length 64.6
  IN1 w0.099: v3(111.97,28.56) 111.97,28.28 111.88,28.2 111.51,28.2 111.44,28.27 111.44,29.5 111.08,29.86 111.08,30.37 111.2,30.49 111.44,30.49 111.87,30.06 112.27,30.06 112.52,30.32 112.52,31.17 112.31,31.39 111.2,31.39 111.08,31.51 111.08,31.76 111.2,31.89 112.31,31.89 112.52,32.11 112.52,32.57 112.31,32.79 111.2,32.79 111.08,32.92 111.08,33.17 111.2,33.29 112.31,33.29 112.52,33.51 112.52,33.98 112.31,34.19 111.19,34.19 111.08,34.3 111.08,35.2 111.38,35.5 111.38,36.56 111.08,36.86 111.08,37.23 111.23,37.39 112.32,37.39 112.56,37.63 112.56,38.04 112.32,38.28 111.57,38.28 111.38,38.47 111.38,39.17 110.97,39.58 110.97,40.4 110.51,40.86 110.51,70.59 110.81,70.89 110.81,75.34 110.39,75.76 110.39,76.17 110.53,76.31 110.53,76.53 v3(110.71,76.7)
  BOTTOM w0.089: v3(110.71,76.7) 110.68,76.7 CPU1.AV27
  BOTTOM w0.127: v3(111.97,28.56) 111.7,28.3 111.54,28.3 111.18,27.94 111.18,27.02 111.05,26.89 JDIMM2.101
M_CLK_DDR3: length 65.1
  IN1 w0.099: v3(111.78,20.86) 111.78,20.96 111.64,21.1 111.49,21.1 111.39,21.1 111.16,21.34 111.16,22.61 111.53,22.98 111.53,26.46 111.83,26.76 112.31,26.76 112.51,26.96 112.51,29.28 113.07,29.84 113.07,39.43 112.87,39.62 111.64,39.62 111.48,39.79 111.48,40.61 111.03,41.06 111.03,68.27 110.94,68.37 110.94,70.28 111.13,70.47 111.13,77.17 111.32,77.36 111.52,77.36 v3(111.7,77.54)
  BOTTOM w0.089: CPU1.AV26 111.69,77.54 v3(111.7,77.54)
  BOTTOM w0.127: v3(111.78,20.86) 111.93,21.01 112.05,21.01 112.26,20.8 112.26,19.89 111.68,19.31 111.68,18.94 111.35,18.6 JDIMM2.102
M_CLK_DDR#0: length 46.9
  IN6 w0.099: v3(111.62,69.45) 111.86,69.68 112,69.68 112.08,69.6 112.08,68.78 111.77,68.48 111.77,51.89 112.02,51.65 112.84,51.65 112.97,51.52 112.97,51.27 112.84,51.14 112.02,51.14 111.77,50.9 111.77,50.48 112.02,50.24 112.84,50.24 112.97,50.12 112.97,49.86 112.84,49.74 112.02,49.74 111.77,49.5 111.77,49.08 112.02,48.84 112.83,48.84 112.93,48.74 112.93,48.43 112.83,48.34 112.11,48.34 111.87,48.09 111.87,47.68 112.11,47.44 112.83,47.44 112.93,47.34 112.93,46.48 112.89,46.43 112.89,45.19 112.93,45.15 112.93,43.4 112.84,43.3 112.47,43.3 111.86,43.91 111.18,43.91 110.94,43.67 110.94,43.17 111.15,42.95 111.35,42.95 111.48,42.83 111.48,42.57 111.35,42.45 111.18,42.45 110.94,42.21 110.94,41.43 111.18,41.18 111.89,41.18 112.08,40.99 v3(112.08,40.98)
  BOTTOM w0.089: CPU1.BE25 112.19,71.99 112.69,71.49 112.69,71 112.36,70.66 112.36,69.84 112.1,69.59 111.76,69.59 v3(111.62,69.45)
  BOTTOM w0.127: JDIMM1.103 111.64,39.9 111.46,40.08 111.46,41.06 111.64,41.24 111.83,41.24 v3(112.08,40.98)
M_CLK_DDR#1: length 51.1
  IN6 w0.099: v3(111.83,36.22) 111.83,36.1 111.7,35.97 111.51,35.97 111.38,36.1 111.38,39.02 111.13,39.27 110.75,39.27 110.62,39.39 110.62,39.64 110.75,39.77 111.43,39.77 111.67,40.01 111.67,40.43 111.43,40.67 110.56,40.67 110.43,40.79 110.43,44.3 110.61,44.48 112.18,44.48 112.38,44.68 112.38,46.73 112.18,46.93 111.38,46.93 111.27,47.04 111.27,68.85 111.25,68.86 111.25,73.28 111.4,73.43 111.55,73.43 v3(111.75,73.23)
  BOTTOM w0.089: CPU1.BD25 112.34,73.03 112.34,73.16 112.27,73.23 v3(111.75,73.23)
  BOTTOM w0.127: v3(111.83,36.22) 112.08,35.97 112.33,35.97 112.6,35.7 112.6,33.95 111.78,33.13 111.78,31.9 111.94,31.73 JDIMM1.104
M_CLK_DDR#2: length 64.6
  IN1 w0.099: v3(109.84,76.6) 109.92,76.67 110.17,76.67 110.34,76.51 110.34,76.39 110.19,76.25 110.19,75.68 110.61,75.26 110.61,70.97 110.32,70.68 110.32,40.78 110.78,40.32 110.78,39.49 111.19,39.09 111.19,38.39 111.49,38.09 112.24,38.09 112.37,37.96 112.37,37.71 112.24,37.58 111.15,37.58 110.88,37.31 110.88,36.78 111.19,36.48 111.19,35.58 110.88,35.28 110.88,34.22 111.11,33.99 112.23,33.99 112.33,33.9 112.33,33.59 112.23,33.49 111.12,33.49 110.88,33.25 110.88,32.83 111.12,32.59 112.23,32.59 112.33,32.49 112.33,32.19 112.23,32.09 111.12,32.09 110.88,31.85 110.88,31.43 111.12,31.19 112.23,31.19 112.33,31.09 112.33,30.4 112.19,30.26 111.95,30.26 111.53,30.69 111.11,30.69 110.88,30.45 110.88,29.78 111.24,29.42 111.24,28.19 111.43,28 111.77,28 v3(111.97,27.8)
  BOTTOM w0.089: CPU1.AW27 110.09,76.6 v3(109.84,76.6)
  BOTTOM w0.127: JDIMM2.103 111.65,26.75 111.44,26.95 111.44,27.83 111.65,28.03 111.74,28.03 v3(111.97,27.8)
M_CLK_DDR#3: length 65.1
  IN1 w0.099: v3(111.71,76.95) 111.71,77.04 111.58,77.17 111.4,77.17 111.32,77.09 111.32,70.39 111.13,70.2 111.13,68.45 111.23,68.35 111.23,41.14 111.67,40.69 111.67,39.87 111.72,39.82 112.95,39.82 113.26,39.51 113.26,29.76 112.71,29.2 112.71,26.88 112.39,26.57 111.91,26.57 111.72,26.38 111.72,22.9 111.35,22.52 111.35,21.42 111.47,21.3 111.57,21.3 111.78,21.51 v3(111.78,21.62)
  BOTTOM w0.089: v3(111.71,76.95) 111.24,76.47 CPU1.AW26
  BOTTOM w0.127: v3(111.78,21.62) 111.78,21.53 112.04,21.27 112.16,21.27 112.52,20.91 112.52,19.78 111.95,19.2 JDIMM2.104
M_ODT0: length 49.1
  IN6 w0.089: v3(117.5,73.88) 117.87,73.51 117.87,71.78 118.03,71.63 118.03,70.74 118.02,70.74 118.02,69.94
  IN6 w0.155: 118.02,69.94 118.02,64.71 118.15,64.58 118.79,64.58 118.92,64.46 118.92,64.09 118.79,63.96 118.15,63.96 118.02,63.84 118.02,63.47 118.15,63.34 119.38,63.34 119.51,63.22 119.51,46.34 119.51,46.34 119.51,39.58 119.15,39.23 119.15,34.25 v3(117.75,32.84)
  BOTTOM w0.089: v3(117.5,73.88) 117.5,73.85 117.76,73.58 CPU1.BC16
  BOTTOM w0.206: v3(117.75,32.84) 117.27,32.84 116.4,31.97 115.95,31.97 115.55,31.56 JDIMM1.116
M_ODT1: length 46.9
  IN6 w0.089: v3(117.47,71.17) 117.09,70.79 117.09,69.94
  IN6 w0.155: v3(117.75,35.89) 118.22,36.36 118.22,39.61 118.58,39.97 118.58,59.81 118.45,59.94 117.22,59.94 117.09,60.06 117.09,60.43 117.22,60.56 118.45,60.56 118.58,60.68 118.58,61.05 118.45,61.17 117.22,61.17 117.09,61.3 117.09,69.94
  BOTTOM w0.089: CPU1.BF16 117.78,71.48 v3(117.47,71.17)
  BOTTOM w0.206: JDIMM1.120 116.74,31.5 117.06,31.82 117.64,31.82 118.35,32.52 118.35,35.29 v3(117.75,35.89)
M_ODT2: length 64.6
  IN1 w0.089: 116.18,69.94 115.9,70.21 115.9,71.15 116.18,71.43 116.18,75.3 v3(115.51,75.97)
  IN1 w0.155: v3(118.08,19.34) 119.45,20.7 119.45,26.78 120.13,27.47 120.13,30.68 120.72,31.27 120.72,37.48 120.13,38.07 120.13,43.91 118.85,45.2 118.85,54.88 116.98,56.75 116.98,68.89 116.18,69.69 116.18,69.94
  BOTTOM w0.089: v3(115.51,75.97) 115.22,75.68 CPU1.AY20
  BOTTOM w0.206: JDIMM2.116 115.55,18.41 116.6,19.46 117.96,19.46 v3(118.08,19.34)
M_ODT3: length 66.1
  IN1 w0.089: 115.71,69.94 115.71,71.36 115.85,71.5 115.85,75 v3(115.52,75.33)
  IN1 w0.155: 115.71,69.94 115.71,69.5 116.51,68.7 116.51,56.55 118.38,54.69 118.38,45.01 118.83,44.56 118.83,44.35 118.38,43.91 118.38,43.73 118.73,43.38 118.91,43.38 119.23,43.7 119.41,43.7 119.67,43.44 119.67,43.26 119.37,42.96 119.37,42.74 119.67,42.44 119.67,32.11 119.82,31.96 120.13,31.96 120.26,31.83 120.26,31.46 120.13,31.34 119.82,31.34 119.67,31.18 119.67,28.25 118.98,27.56 118.98,21.02 118.82,20.86 v3(118.08,20.86)
  BOTTOM w0.089: CPU1.BA19 115.87,74.98 v3(115.52,75.33)
  BOTTOM w0.206: JDIMM2.120 116.75,18.49 117.08,18.82 118.37,18.82 119.06,19.52 119.06,20.54 118.74,20.86 v3(118.08,20.86)
M_THERMAL#: length 177.4
  TOP w0.127: RE77.2 279.36,9.29 v3(278.78,9.87) 278.78,10.01 278,10.79 UE5.70 ; v3(139.51,14.33) 140.17,14.99 140.17,16.32 138.5,18 138.5,26.82 137.92,27.4 v2(137.92,28.16) v3(137.92,28.94)
  IN2 w0.099: v3(278.78,9.87) 278.24,10.42 271.39,10.42 269.43,12.38 261.23,12.38 260.57,11.72 254.12,11.72 251.91,9.51 240.77,9.51 237.4,6.14 210.68,6.14 206.51,10.3 203.47,10.3 202.63,11.14 197.7,11.14 192.81,6.26 153.69,6.26 149.3,10.65 147.69,10.65 146.94,11.39 146.94,12.34 145.64,13.64 144.84,13.64 144.02,14.45 139.64,14.45 v3(139.51,14.33)
  BOTTOM w0.127: v3(137.92,28.94) 139.47,28.94 140.15,29.62 JDIMM1.198 ; JDIMM2.198 140.15,15.91 139.51,15.27 v3(139.51,14.33)
MDP_LANE_N0_C: length 5.4
  TOP w0.127: JDP1.5 140.85,143.72 140.85,141.96 140.86,141.95 140.86,141.27 140.85,141.26 v4(140.85,139.96) 140.85,139.23 CV27.2
MDP_LANE_N1_C: length 3.4
  TOP w0.127: CV30.2 142.62,139.23 v4(142.62,140.26) 142.62,141.7 JDP1.11
MDP_LANE_N2_C: length 5.5
  TOP w0.127: JDP1.17 144.44,143.72 144.44,143.19 144.55,143.08 144.55,142.29 144.56,142.28 144.56,141.54 144.55,141.53 v4(144.55,140.13) 144.55,139.14 CV33.2
MDP_LANE_N3_C: length 3.5
  BOTTOM w0.127: CV31.2 142.49,137.26 v4(142.49,137.89) 142.49,138.38 142.61,138.5 142.61,138.9 142.8,139.09 JDP1.12
MDP_LANE_P0_C: length 5.5
  TOP w0.127: JDP1.3 140.6,143.68 v4(140.6,141.59) 140.6,140.29 140.59,140.28 140.59,139.56 140.6,139.55 140.6,139.24 CV26.2
MDP_LANE_P1_C: length 3.5
  TOP w0.127: JDP1.9 142.38,141.7 142.38,140.55 142.37,140.54 142.37,139.89 142.38,139.88 142.38,139.24 CV28.2
MDP_LANE_P2_C: length 5.5
  TOP w0.127: JDP1.15 144.2,143.68 144.2,143.09 144.31,142.98 v4(144.31,141.94) 144.31,140.42 144.3,140.41 144.3,139.32 CV32.2
MDP_LANE_P3_C: length 3.5
  BOTTOM w0.127: JDP1.10 142.2,139.05 142.37,138.88 142.37,138.6 142.25,138.48 142.25,138.19 142.24,138.18 142.24,137.28 CV29.2
ME_EN: length 76.9
  TOP w0.127: v3(245.09,37.77) 244.83,38.03 239.88,38.03 239.43,38.48 239.07,38.48 238.74,38.81 238.74,39.71 238.42,40.03 238.42,41.4 238.01,41.81 v1(235.84,41.81) 235.47,41.44 RH16.1 ; UE5.99 291.32,14.25 v3(291.44,14.12) 291.61,13.96 RE81.1
  IN6 w0.099: v3(291.44,14.12) 291.14,13.82 283.79,13.82 282.03,12.05 274.18,12.05 273.46,12.77 273.46,13.2 273.69,13.43 273.69,16.18 272.32,17.55 269.17,17.55 259.59,27.13 258.75,27.13 251.07,34.81 246.55,34.81 245.73,35.63 245.73,37.12 v3(245.09,37.77)
ME_SUS_PWR_ACK: length 75.7
  TOP w0.127: v1(272.76,25.45) UE5.34 276.01,25.45 276.8,24.67 276.8,23.24 277.13,22.91 278.27,22.91 280.13,21.06 282.12,21.06 283.15,20.03 v3(283.15,17.68)
  IN1 w0.099: v3(283.15,17.68) 282.76,18.07 279.13,18.07 278.64,17.58 269.4,17.58 268.43,18.55 260.09,18.55 257.83,16.3 241.08,16.3 239.61,17.76 235.19,17.76 234.72,18.23 232.23,18.23 231.97,17.96 231.36,17.96 231.02,18.3 230.48,18.3 v3(229.21,19.57)
  BOTTOM w0.127: RH55.1 229.61,20.86 229.61,19.97 v3(229.21,19.57) 229.11,19.48 RH31.2
ME_SUS_PWR_ACK_R: length 10.4
  BOTTOM w0.089: 226.66,28.41 226.66,29.2 226.46,29.4 226.46,29.63 226.76,29.92 UH1.J4
  BOTTOM w0.127: RH55.2 230.21,22.38 230.21,24.14 RH34.1 229.75,24.84 229.36,25.22 v1(229.36,25.74) 229.36,25.85 228.88,26.33 228.25,26.33 226.66,27.92 226.66,28.41
MEM_SMBCLK: length 17.4
  TOP w0.127: RH95.2 224.21,19.75 v3(224.21,20.37) 224.21,20.7 RH97.2 224.73,21.22 225.71,21.22 225.92,21.01 QH4.6
  IN1 w0.099: v3(224.21,20.37) 224.86,21.02 224.86,23.27 224.16,23.96 224.16,25.24 223.51,25.9 223.51,28.91 223.97,29.37 223.97,30.82 224.12,30.97 224.12,32.28 v3(223.78,32.62)
  BOTTOM w0.089: v3(223.78,32.62) 224.13,32.62 UH1.R10
MEM_SMBDATA: length 22.1
  TOP w0.127: v3(225.38,19.84) 225.92,19.29 228.12,19.29 RH96.2 228.46,18.95 RH99.2 228.25,17.72 227.69,17.72 v1(227.54,17.86) 227.22,18.19 QH4.3
  IN1 w0.099: v3(223.78,33.21) 224.34,32.64 224.34,30.87 224.2,30.72 224.2,29.27 223.74,28.81 223.74,25.99 224.39,25.34 224.39,24.06 225.08,23.36 225.08,20.13 v3(225.38,19.84)
  BOTTOM w0.089: v3(223.78,33.21) 223.59,33.4 UH1.U11
MEM_VREF: length 228.6
  TOP w0.127: v3(200.33,130.79) 201.67,130.79 v2(201.93,131.05)
  TOP w0.254: v3(200.33,130.79) 200.48,130.94 QV24.2 ; v3(160.91,127.04) 158.99,127.04 QV23.2 ; RV38.2 v3(168.4,71.95)
  IN2 w0.254: v3(168.4,71.95) 169.04,71.31 169.85,71.31 170.42,71.88 v3(170.73,71.88) 171.05,71.88 171.78,71.15 171.78,70.66 174.82,67.62 178.22,67.62 179.52,66.32 182.69,66.32 186.87,62.14 197.86,62.14 v3(198.67,61.33)
  IN3 w0.254: v3(160.91,127.04) 160.31,127.04 159.98,127.37 159.98,129.26 161.49,130.77 161.49,132.3 162.13,132.95 167.21,132.95 169.56,130.6 173.78,130.6 174.32,130.06 175.56,130.06 175.82,130.32 181.08,130.32 182.33,131.57 185.07,131.57 185.57,132.08 197.45,132.08 198.91,130.62 200.17,130.62 v3(200.33,130.79) 200.55,131 201.91,131 208.31,124.6 208.31,120.36 v3(210.64,118.02) ; v3(213.17,106.39) 213.17,106.37 213.7,105.84 226.37,105.84 229.49,102.72 234.55,102.72 235.42,101.84 235.42,97.09 234.41,96.08 234.41,68.84 232.96,67.39 232.96,62.31 231.06,60.41 v3(215.39,60.41) 212.57,63.22 202.22,63.22 200.33,61.33 v3(198.67,61.33)
  IN4 w0.254: v3(210.64,118.02) 211.05,117.62 211.05,112.82 212.49,111.38 212.49,109.97 213.95,108.51 213.95,107.16 v3(213.17,106.39)
  BOTTOM w0.254: v3(213.17,106.39) 212.65,105.87 QV21.2 ; v3(170.73,71.88) 170.9,71.88 UV1.AT6 ; v3(215.39,60.41) 215.73,60.75 QV25.2
MIC1: length 32.7
  IN2 w0.254: v3(1.99,11.6) 2.03,11.64 2.61,11.64 3.77,10.47 6.01,10.47 6.58,11.04 9.47,11.04 11.32,9.18 15.42,9.18 15.97,9.73 15.97,10.57 16.63,11.23 21.74,11.23 22.07,10.9 25.69,10.9 v3(26.08,11.28)
  BOTTOM w0.254: UA3.11 1.67,9.68 1.4,9.95 1.4,11.01 v3(1.99,11.6) 1.99,12 RA126.2 ; v3(26.08,11.28) 26.35,11.56 26.35,12.17 26.59,12.4 CA13.2
MIC1_C_L: length 3.6
  TOP w0.203: UA1.45 23.43,13.4 23.48,13.35 23.85,13.35 v3(23.91,13.41) 23.91,13.53 23.64,13.8 UA1.46
  BOTTOM w0.254: CA13.1 24.83,13.29 24.03,13.29 23.91,13.41 v3(23.91,13.41)
MIC_BIAS_B: length 15.8
  TOP w0.203: UA1.42 22.13,11.29 22.64,10.78 v3(22.64,10.41)
  IN1 w0.254: v3(21.81,5.78) 21.81,6.82 22.89,7.9 22.89,9.64 22.64,9.89 v3(22.64,10.41)
  BOTTOM w0.254: CA15.2 21.96,12 22.2,11.76 22.2,10.73 22.52,10.41 v3(22.64,10.41) ; v3(21.81,5.78) 21.81,6.52 QA13.3 22.68,6.85 23.85,5.68 25.2,5.68 26.1,6.58 QA11.3
MIC_BIAS_C: length 6.4
  TOP w0.203: UA1.41 21.73,11.21 21.96,10.98 21.96,10.34
  TOP w0.254: 21.96,10.34 22.42,9.88 22.68,9.88 CA24.2 22.66,9.36 v3(22.24,9.36)
  BOTTOM w0.254: QA12.3 20.42,10.44 20.86,10.01 21.01,10.01 21.66,9.36 v3(22.24,9.36)
MIC_C_PLUG: length 33
  TOP w0.127: v3(2.25,7.28) v1(2.25,6.73)
  TOP w0.254: RA48.1 24.35,12.66 v3(24.49,12.8)
  IN6 w0.254: v3(24.49,12.8) 24.49,11.91 23.94,11.37 22.04,11.37 21.82,11.58 15.78,11.58 15.48,11.29 10.53,11.29 10.01,10.77 7.1,10.77 6.14,11.74 5.5,11.74 4.03,13.21 3.51,13.21 2.91,12.61 2.91,10.75 2.45,10.29 2.45,7.48 v3(2.25,7.28)
  BOTTOM w0.254: UA3.8 2.93,7.56 2.66,7.28 v3(2.25,7.28)
MIC_CLK: length 177.7
  TOP w0.127: LA2.2 26.41,21.16 v3(26.98,21.16) ; v3(85.73,126) 85.88,125.85 87.93,125.85 88.35,126.27 91.61,126.27 92.07,125.81 92.64,125.81 JEDP1.30
  IN1 w0.099: v3(85.73,126) 85.58,125.86 84.36,125.86 82.05,123.54 82.05,112.49 82.91,111.63 82.91,106.31 71.5,94.91 71.5,66.32 68.14,62.96 68.14,53.17 71.09,50.22 71.09,43.75 71.45,43.39 71.45,31.84 71.15,31.54 71.15,29.58 72.53,28.2 72.53,26.45 70.58,24.49 70.58,20.68 69.75,19.85 56.65,19.85 53.06,16.26 50.81,16.26 47.87,13.32 37.71,13.32 36.54,14.49 32.81,14.49 27.88,19.42 27.88,20.55 27.46,20.97 27.17,20.97 v3(26.98,21.16)
  BOTTOM w0.127: RV13.1 85.59,126.14 v3(85.73,126)
MIC_CLK_C: length 6
  TOP w0.127: UA1.55 23.5,17.4 24.56,18.47 24.56,20.07 LA2.1 v1(25.33,22.15)
MIC_DATA: length 185.4
  TOP w0.127: JEDP1.32 91.89,125.14 91.89,125.63 91.51,126.01 88.46,126.01 88.04,125.59 85.9,125.59 v3(85.73,125.41) ; v3(26.98,20.55) 26.98,19.6 28.49,18.09 28.49,16.75 v1(28.18,16.45) 28.15,16.41 27.04,16.41 26.43,15.8 UA1.51
  IN1 w0.099: v3(85.73,125.41) 85.51,125.63 84.46,125.63 82.27,123.45 82.27,112.59 83.13,111.73 83.13,106.22 71.73,94.82 71.73,66.23 68.36,62.86 68.36,53.27 71.32,50.32 71.32,43.84 71.67,43.49 71.67,31.74 71.38,31.45 71.38,29.68 72.76,28.3 72.76,26.35 70.8,24.39 70.8,20.58 69.84,19.62 56.75,19.62 53.15,16.03 50.9,16.03 47.97,13.09 37.62,13.09 36.45,14.26 32.71,14.26 27.65,19.33 27.65,20.46 27.37,20.74 27.17,20.74 v3(26.98,20.55)
MIC_IN: length 8.2
  IN6 w0.254: v3(4.13,11.74) 4.13,11.19 4.76,10.56 4.76,8.65 3.63,7.52 v3(3.63,6.92)
  BOTTOM w0.127: v3(4.13,11.74) 4.13,11.93 v1(4.4,12.19)
  BOTTOM w0.254: v3(4.13,11.74) 3.93,11.54 UA3.15 ; v3(3.63,6.92) 3.63,7.09 3.93,7.39 UA3.6
MIC_LINE_IN_L: length 1.9
  TOP w0.203: UA1.44 23.51,13 23.7,12.82 v3(23.84,12.82)
  BOTTOM w0.254: v3(23.84,12.82) 23.74,12.82 23.52,12.6 CA76.1
MIC_LINE_IN_L2: length 12.5
  TOP w0.203: RA102.2 27.57,8.62 UA6.12
  TOP w0.254: v3(28.83,9.27) 29.39,8.71 v1(29.39,8.28) 28.88,7.77 RA102.2
  IN6 w0.254: v3(23.23,10.4) 24.8,10.4 26.43,8.77 28.33,8.77 v3(28.83,9.27)
  BOTTOM w0.254: RA106.1 28.94,9.37 v3(28.83,9.27) ; CA76.2 23.23,10.87 v3(23.23,10.4)
MIC_LINE_IN_R: length 2.2
  TOP w0.203: UA1.43 23.41,12.6 23.51,12.5 23.51,12.13 v3(23.27,11.89)
  BOTTOM w0.254: CA77.1 23.46,12.05 23.29,11.89 v3(23.27,11.89)
MIC_LINE_IN_R2: length 24.6
  TOP w0.203: UA6.10 27.24,7.82 27.56,7.5 27.56,6.73 v3(28.08,6.21)
  IN4 w0.254: 24.64,7.32 25.06,6.9 27.4,6.9 v3(28.08,6.21) ; 24.64,7.32 24.23,6.91 21.57,6.91 19.88,8.6 18.33,8.6 17.67,9.26 16.75,9.26 16.4,8.9 16.4,8.43 v3(16.6,8.23) ; 24.64,7.32 24.64,8.74 v3(24.04,9.34)
  BOTTOM w0.254: v3(24.04,9.34) 23.79,9.59 23.79,10.33 CA77.2 ; RA100.2 v1(16.04,8.97) 15.58,8.51 15.23,8.51 RA105.1 15.2,8.05 16.42,8.05 v3(16.6,8.23)
MPIO_2: length 16.2
  TOP w0.127: UA1.56 23.49,17.8 23.62,17.93 23.62,18.07 v3(23.43,18.26)
  TOP w0.203: UA6.1 24.56,8.62 24.3,8.88 23.88,8.88 v1(23.86,8.86) 23.72,8.86 23.45,8.59 23.45,8.38 22.73,7.66 RA101.4 22.19,7.66 v3(21.77,8.08)
  IN1 w0.254: v3(23.43,18.26) 22.93,17.76 22.93,12.82 21.66,11.55 21.66,8.19 v3(21.77,8.08)
MPIO_4_PB#_PD: length 12.2
  TOP w0.203: UA6.4 24.56,7.42 24.41,7.27 v1(23.87,7.27) 23.43,7.27 23.29,7.41 v3(23.21,7.41) 22.96,7.16 RA101.3 ; v3(23.9,15.27) 23.9,15.27 23.77,15.4 UA1.50
  IN1 w0.254: v3(23.9,15.27) 23.32,14.69 23.32,12.61 23.75,12.18 23.75,10.23 23.27,9.74 23.27,7.47 v3(23.21,7.41)
MS_INS#: length 27.2
  TOP w0.127: v3(324.07,17.33) 324.76,18.01 UR1.31
  IN6 w0.099: v3(303.71,26.46) 312.83,17.33 v3(324.07,17.33)
  BOTTOM w0.127: v3(303.71,26.46) 303.46,26.7 JCR.8
NC: length 171.5
  GND1 w0.203: H3.1 338.87,116.64 ; H3.1 337.5,113.43 ; H3.1 338.87,113.91 ; H3.1 336.13,116.64 ; H3.1 336.13,113.91 ; H3.1 337.5,117.12 ; H3.1 335.66,115.28 ; H3.1 339.34,115.28 ; H1.1 331.5,117.77 ; H1.1 331.5,112.79 ; H1.1 333.7,115.28 ; H1.1 329.3,115.28 ; H1.1 333.7,112.79 ; H1.1 329.3,112.79 ; H1.1 333.7,117.77 ; 333.63,111.53 JLAN.16 ; JLAN.16 337.17,111.53 ; JLAN.16 335.4,111.53 ; JLAN.16 333.63,110.6 ; JLAN.16 337.17,110.6
  VCC w0.203: 335.66,115.28 H3.1 ; H3.1 339.34,115.28 ; H3.1 338.87,116.64 ; H3.1 337.5,117.12 ; H3.1 337.5,113.43 ; H3.1 338.87,113.91 ; H3.1 336.13,113.91 ; H3.1 336.13,116.64 ; JLAN.16 337.17,110.6 ; JLAN.16 337.17,111.53 ; JLAN.16 333.63,110.6 ; JLAN.16 333.63,111.53 ; JLAN.16 335.4,111.53 ; 329.3,115.28 H1.1 ; H1.1 331.5,117.77 ; H1.1 333.7,117.77 ; H1.1 333.7,115.28 ; H1.1 331.5,112.79 ; H1.1 333.7,112.79 ; H1.1 329.3,112.79
  GND2 w0.203: H1.1 333.7,115.28 ; H1.1 331.5,112.79 ; H1.1 329.3,115.28 ; H1.1 331.5,117.77 ; H1.1 329.3,112.79 ; H1.1 333.7,117.77 ; H1.1 333.7,112.79 ; H3.1 338.87,116.64 ; H3.1 337.5,117.12 ; H3.1 335.66,115.28 ; H3.1 336.13,113.91 ; H3.1 339.34,115.28 ; H3.1 337.5,113.43 ; H3.1 336.13,116.64 ; H3.1 338.87,113.91 ; JLAN.16 335.4,111.53 ; JLAN.16 333.63,110.6 ; JLAN.16 337.17,111.53 ; JLAN.16 333.63,111.53 ; JLAN.16 337.17,110.6
  GND3 w0.203: H1.1 331.5,117.77 ; H1.1 329.3,112.79 ; H1.1 333.7,115.28 ; H1.1 333.7,112.79 ; H1.1 329.3,115.28 ; H1.1 331.5,112.79 ; H1.1 333.7,117.77 ; 333.63,110.6 JLAN.16 ; JLAN.16 333.63,111.53 ; JLAN.16 335.4,111.53 ; JLAN.16 337.17,110.6 ; JLAN.16 337.17,111.53 ; 335.66,115.28 H3.1 ; H3.1 339.34,115.28 ; H3.1 336.13,113.91 ; H3.1 338.87,113.91 ; H3.1 336.13,116.64 ; H3.1 338.87,116.64 ; H3.1 337.5,117.12 ; H3.1 337.5,113.43
  vias: v3(333.89,113.68) v3(334.08,117.02) v3(335.31,115.5) v3(336.07,113.49) v3(336.41,112.27) v3(336.56,117.24) v3(338.8,111.55) v3(338.95,113.44) v3(339.05,117.02) v3(339.78,115.43)
NTC: length 9.3
  IN4 w0.254: v3(140.64,127.82) 140.64,128.02 142.21,129.59 v3(142.21,129.64)
  BOTTOM w0.127: PR525.2 141.84,132.59 v1(140.36,132.59)
  BOTTOM w0.203: v3(140.64,127.82) 139.7,127.82 PU500.6
  BOTTOM w0.254: v3(142.21,129.64) 142.37,129.64 143.02,130.29 143.02,130.98 142.18,131.82 PR525.2
