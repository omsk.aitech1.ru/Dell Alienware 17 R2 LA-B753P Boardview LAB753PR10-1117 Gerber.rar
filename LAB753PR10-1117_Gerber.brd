# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_PCH_GATE: length 1.2
  TOP w0.127: v1(215.53,10.91) RE62.1
+3VALWP: length 8.5
  TOP w0.127: v2(18.44,26.41) 18.44,26.48 v3(18.93,26.96)
  TOP w0.254: PR101.1 v3(18.93,26.96)
  BOTTOM w0.254: v3(18.93,26.96) 19.56,26.33 19.56,24.86 20.47,23.94 22.55,23.94 22.99,23.51 22.99,22.76
+3VLP: length 561.9
  TOP w0.203: UE5.111 v3(288.05,19.05)
  TOP w0.381: v3(18.23,39.97) 17.8,39.54 UU5.5
  TOP w0.508: CU26.1 v3(17.4,40.6) ; v3(62.82,56.63) 63.71,56.63 v2(63.94,56.87) 64.44,57.37 66.88,57.37 69.74,54.51 76.39,54.51 77.6,55.72 77.6,60.02 75.81,61.81 75.81,68.39 77.6,70.18 v3(77.6,76.35) ; RE63.2 159.76,139.42 159.76,140.96 v3(159.67,141.05) ; v3(297.82,24.18) PR25.2 ; RU4.1 v3(15.88,32.86)
  IN1 w0.508: v3(288.05,19.05) 289.55,19.05 292.31,21.81 294.65,21.81 296.08,23.23 296.87,23.23 v3(297.82,24.18) ; v3(15.88,32.86) 19.12,32.86 19.81,32.16 v3(19.81,28.86)
  IN2 w0.508: v3(261.24,11.31) 261.94,11.31 262.68,10.57 262.68,9.41 264.84,7.25 271.96,7.25 273.72,9.01 285.45,9.01 285.76,9.32 294.68,9.32 297.82,12.46 v3(297.82,24.18) ; v3(232.82,52.88) 232.82,53.75 231.04,55.53 227.36,55.53 224.82,58.06 210.63,58.06 206.29,53.71 206.29,52.14 203.35,49.2 201.92,49.2 193.04,58.08 165.02,58.08 163.22,56.29 160.23,56.29 158.39,58.12 158.39,63.75 158.65,64.01 158.65,66.17 158.46,66.36 158.46,78.84 156.7,80.6 156.7,91.45 155.02,93.14 155.02,99.23 155.97,100.18 155.97,101.51 155.09,102.39 155.09,115.77 150.67,120.19 150.67,123.51 152.5,125.35 v3(152.5,128.78) 152.5,134.15 152.89,134.53 153.71,134.53 156.06,136.88 156.06,137.34 155.2,138.19 v3(154.64,138.19) ; v3(96,118.94) 99.7,118.94 101.25,120.49 101.25,126.43 v3(101.08,126.6)
  IN3 w0.508: v3(154.64,138.19) 154.13,138.7 154.13,139.33 154.62,139.83 159.3,139.83 159.67,140.2 v3(159.67,141.05)
  IN4 w0.508: v3(101.08,126.6) 102.09,126.6 105.95,130.46 131.22,130.46 134.71,133.95 141.29,133.95 147.15,128.09 151.82,128.09 v3(152.5,128.78) ; v3(96,118.94) 93.96,118.94 93.03,118.01 89.28,118.01 86.23,114.96 86.23,98.32 84.71,96.8 84.71,92.75 77.6,85.64 v3(77.6,76.35)
  IN6 w0.508: v3(15.88,32.86) 15.88,33.75 16.58,34.44 16.58,38.32 v3(18.23,39.97) 22.42,39.97 24.7,37.68 30.86,37.68 34.17,40.98 38.8,40.98 39.98,42.16 41.37,42.16 41.91,42.7 45.79,42.7 47.82,44.73 49.66,44.73 53.22,48.29 54.64,48.29 62.82,56.47 v3(62.82,56.63) ; v3(288.05,19.05) 288.05,19.15 286.23,20.97 275.56,20.97 271.59,24.94 270.84,24.94 264.41,31.38 263.63,31.38 262.55,32.46 259.61,32.46 258.87,33.2 258.87,33.76 258.87,35.99 249.78,45.08 249.78,45.25 241.57,53.46 234.99,53.46 234.41,52.88 v3(232.82,52.88)
  BOTTOM w0.508: PD5.3 259.53,13.02 v3(261.24,11.31)
+3VS: length 847.4
  TOP w0.203: v3(113.51,140.07) 113.36,140.07 113.19,139.9 UV4.37
  TOP w0.254: JIO.28 12.01,19.53 v3(12.14,19.39) ; RPH3.6 233.72,47.78 v3(234.02,48.08) 233.83,48.28 RPH3.7
  TOP w0.305: UN2.14 265.82,7.58 265.93,7.47 CN17.1 ; v3(268.72,8.74) UN2.1
  TOP w0.381: UE7.5 292.7,17.27 292.52,17.45 292.52,18.07 CE50.1 ; QH3.2 230.44,20.12 v3(230.56,20) ; CH6.1 211.39,20.79 211.79,20.4 UH2.5
  TOP w0.406: QH3.5 230.44,19.89 v3(230.56,20) ; QH4.5 226.57,21.41 RH94.1 ; UH3.5 221.69,21.82 222.48,21.03 CH7.1 ; QH4.2 226.57,17.88 RH93.1
  TOP w0.457: v3(235.65,28.87) 234.88,28.87 RH115.1 ; R151.1 119.13,10.87 v3(118.63,10.38) 119,10.01 R155.1 ; CM20.1 222.15,116.08 v3(221.24,116.99) ; v3(219.29,33.6) 219.51,33.6 219.78,33.87 219.78,34.02 CH44.1 ; R161.1 115.76,10.87 v3(115.31,10.42) 115.71,10.01 R163.1
  TOP w0.508: CN40.1 CN41.1 172.52,7.19 172.85,7.52 v3(172.85,7.74) ; RH113.1 209.58,34.03 209.12,34.03 v3(208.96,34.19) 208.8,34.34 RH98.1 208.8,35.36 208.19,35.97 RH112.1 ; PR600.1 174.26,25.06 171.73,25.06 v3(171.01,25.78) ; RE77.1 279.12,7.58 v3(279.12,6.35) ; v3(263.1,7.99) 263.1,7.05 263.46,6.69 CN17.1 ; RL5.2 329.01,30.14 v2(331.05,28.09) 335.18,23.97 335.18,17.96 LR1.1 333.85,14.39 331.31,11.85 329.43,11.85 327.14,9.57 320.31,9.57 319.95,9.92 v3(299.57,9.92) ; R168.1 R170.1 123,10.01 v3(123.36,10.37) ; PR639.1 185.94,27.15 v3(186.18,27.4) ; QN2.2 176.58,18.06 v3(176.58,17.52) ; v3(224.46,41.5) 224.46,41.92 CH24.1 ; v3(212.04,21.13) 211.43,21.13 CH6.1 ; RD15.1 140.85,27.78 v3(140.66,27.6) 140.5,27.43 C16.1 ; v3(159.37,23.64) 158.43,22.7 RN8.1 CN7.1 ; v3(151.5,134.96) 151.53,134.94 RM77.2 154.56,134.94 RM71.1 ; R158.1 134.03,13.6 R164.1 134.55,14.48 v3(134.71,14.31) ; CH7.1 222.63,20.35 v3(222.13,19.84) ; RM26.1 164.01,134.36 v3(164.14,134.48) ; v3(264.89,39.23) 264.89,38.93 RE18.2 266.27,34.5 v3(266.27,32.17) ; PC405.1 207.51,18.84 207.51,17.77 205.6,15.86 204.74,15.86 204.48,16.12 204.48,16.87 204.78,17.16 PR407.2 ; RH85.2 215.7,22.87 v3(215.67,22.85) ; v3(163.13,135.89) 163.13,135.28 RM85.1 ; RN14.1 RN9.1 v3(164.15,10.89) ; R146.1 R144.1 136.78,14.43 v3(136.68,14.33) ; CH43.1 226.11,38.51 225.78,38.84 v3(225.78,39.13) ; R159.1 R157.1 123.83,14.56 122.68,14.56 v3(122.33,14.2) ; RE20.2 253.32,43.78 v3(253.05,43.51) ; v3(155.83,10.85) 156.09,11.1 CN8.1 RN7.2 ; v3(161.65,129.25) 161.05,129.25 RM86.1 ; v3(245.81,7.76) 245.81,7.09 CN22.1 CN20.1 ; R160.1 R162.1 R154.1 R150.1 140.85,10.87 141.16,10.56 v3(141.16,10.52) ; v3(293.13,17.66) 292.71,18.07 CE50.1 ; v3(160.21,22.32) RN10.1 RN11.1 ; CH58.1 218.56,41.48 v3(218.58,41.5) ; v3(87.34,15.05) 87.05,14.76 R148.1 R149.1 ; v3(164.71,131.89) 164.42,131.6 RM79.1 ; v3(208.79,29.94) 208.79,30.65 209.29,31.14 RH118.1 RH33.1 ; RN15.1 RN13.1 v3(159.7,10.87) ; R165.1 R167.1 120.47,13.68 119.23,13.68 118.86,13.31 v3(118.86,12.69) ; RM74.1 150.67,136.58 v3(150.28,136.18) ; RH93.1 226.58,17.77 226.58,16.85 RH78.1 227.47,16.74 v3(227.67,16.94) ; RN29.2 v3(214.33,7.65) ; RA94.1 6.63,9.96 v3(6.85,10.17) ; RN6.2 RN12.1 162.93,21.9 v3(163.34,22.3) ; R147.1 R145.1 126.86,14.43 v3(126.63,14.2) ; v3(131.42,14.33) 131.32,14.43 R156.1 R166.1 ; v3(21.49,23.46) 21.49,23.41 21.5,23.41 RA51.1 ; v3(140.63,42.89) 140.58,42.89 140.91,43.22 CD39.1 ; v3(226.48,22.33) 226.3,22.15 RH94.1 ; v3(85.42,15.05) R172.1 R173.1 ; RN28.2 237.31,8.23 v3(237.02,7.94) ; PR614.1 175.53,29.21 175.17,29.57 v3(174.99,29.57) ; RH134.1 209.58,33.07 208.94,33.07 208.94,33.08 v3(208.94,33.08) ; v3(160.94,27.21) 161.6,27.21 CN1.1 ; v3(111.94,10.15) 112.2,9.88 R171.1 R169.1 ; v3(172.15,7.74) 170.47,6.06 RN33.2 ; RH68.2 RH115.1 ; R153.1 R152.1 77.84,14.18 v3(78.74,15.08)
  IN1 w0.508: v3(140.63,42.89) 142.17,42.89 145.96,39.09 145.96,32.07 144.85,30.95 144.85,27.05 v3(144.08,26.29) ; 235.23,48.52 234.68,49.07 v3(234.68,50.66) 234.68,56.3 233.68,57.3 v3(233.68,59.34) ; v3(150.61,126.38) 148.83,124.6 148.83,119.64 151.73,116.74 151.73,107.49 150.44,106.2 142.45,106.2 142.08,106.57 138.98,106.57 138.63,106.22 134.44,106.22 v3(133.21,107.44) ; v3(148.62,131.62) 148.36,131.88 145.21,131.88 v3(145.02,131.69) 141.06,131.69 v3(140.53,131.15) ; v3(67.07,54.51) 67.48,54.92 v3(67.48,57.66) ; v3(12.14,19.39) 11.22,19.39 10.71,18.89 9.34,18.89 8.72,18.26 7.58,18.26 6.85,17.53 v3(6.85,10.17)
  IN2 w0.508: v3(144.55,135.07) 143.98,134.5 143.98,132.73 v3(145.02,131.69) ; v3(87.62,127.08) 88.36,127.08 92.64,131.36 95.04,131.36 v3(95.15,131.47) 95.15,132.45 95.72,133.02 96.64,133.02 101.7,138.09 101.7,139.04 102.43,139.77 104.51,139.77 v3(105.17,139.11) ; v3(84.14,105.06) 84.14,118.26 82.62,119.79 v3(80.69,119.79) ; v3(144.08,26.29) 144.08,28.03 143.58,28.54 141.61,28.54 v3(140.67,27.6) ; v3(31.15,9.1) 30.74,8.68 29.74,8.68 27.83,6.77 20.08,6.77 18.6,8.25 v3(17.31,8.25) 17.31,8.38 16.85,8.84 16,8.84 15.67,8.51 10.78,8.51 9.12,10.17 v3(6.85,10.17) ; v3(207.65,20.16) 207.65,19.86 208.07,19.45 210.78,19.45 212.04,20.71 v3(212.04,21.13) ; v3(233.68,59.34) 233.02,60 233.02,64.38 233.86,65.22 233.86,66.71 234.33,67.18 234.33,71.06 234.81,71.54 234.81,101.49 234.09,102.21 229.29,102.21 224.82,106.68 v3(224.82,110.64) ; v3(148.62,131.62) v3(148.62,131) 149.58,130.04 149.58,127.41 v3(150.61,126.38)
  IN2 w1.524: 81.65,111.36 82.74,110.26 82.74,107.3 72.71,97.27 72.71,65.88 69.15,62.32 69.15,53.94 71.44,51.65
  IN3 w0.508: v3(164.14,134.48) 164.14,134.6 163.13,135.6 v3(163.13,135.89) 163.13,136.15 162.74,136.54 161.32,136.54 160.02,135.24 152.15,135.24 ; v3(140.53,131.15) 140.07,131.15 139.75,131.47 139.75,133.61 138.85,134.51 v3(131.49,134.51) 129.58,132.6 118.47,132.6 117.73,133.34 106.14,133.34 105.06,134.42 105.06,135.82 105.04,135.83 ; v3(151.5,134.96) 151.87,134.96 152.15,135.24 ; v3(253.05,43.51) 253.33,43.79 253.96,43.79 255.6,42.15 257.88,42.15 258.57,41.45 260.29,41.45 263.23,38.51 264.16,38.51 v3(264.89,39.23) ; v3(236.11,33.91) 236.02,34 233.64,34 233.1,34.55 233.1,36.35 233.49,36.74 v3(233.8,36.74) ; v3(150.28,136.18) 150.41,136.31 151.87,136.31 152.21,135.97 152.21,135.31 152.15,135.24 ; v3(161.65,129.25) 162.68,129.25 162.83,129.4 164.31,129.4 165.34,130.43 165.34,131.26 v3(164.71,131.89) 165.08,132.26 v3(166.37,132.26) ; v3(21.49,23.46) 21,23.95 18.59,23.95 18.01,24.54 15.62,24.54 13.35,22.27 13.35,20.03 12.72,19.39 v3(12.14,19.39)
  IN3 w2.032: 148.96,54.17 148.96,53.13 153.05,49.04 153.06,49.04 157.65,44.45 157.65,38.75 160.12,36.27 160.12,32.16 158.79,30.82 158.79,28.75
  IN4 w0.508: v3(199.77,131.35) 199.65,131.23 199.65,130.28 200.76,129.16 201.74,129.16 203.13,127.78 v3(203.13,127) ; v3(140.63,42.89) 140.13,42.89 137.54,45.48 137.54,66.75 136.17,68.12 136.17,73.69 v3(138.53,76.05)
  IN4 w1.524: 33.55,9.31 53.1,9.31
  IN5 w0.508: v3(164.14,134.48) 164.14,133.73 165.61,132.26 v3(166.37,132.26)
  IN6 w0.508: v3(224.03,125.71) 224.03,124.73 223.47,124.17 215.64,124.17 214.21,125.59 208.45,125.59 203.77,130.27 201.72,130.27 200.59,131.4 199.81,131.4 v3(199.77,131.35)
  BOTTOM w0.254: PR519.2 139.91,130.73 140.34,131.15 v3(140.53,131.15) ; C2498.1 148.86,15.57 148.86,14.78 148.75,14.67 U2407.1
  BOTTOM w0.356: JDIMM1.199 140.44,42.71 v3(140.63,42.89) ; JDIMM2.199 140.45,27.08 140.67,27.29 v3(140.67,27.6)
  BOTTOM w0.381: UM4.9 219.74,113.5 219.14,112.91 CM18.1 ; CF6.1 203.29,129.97 202.66,129.97 202.46,129.78 U2410.1 ; UM4.12 219.74,119.74 218.58,118.58 RM35.2 ; UM4.5 222.34,115.89 v3(221.24,116.99) ; CM21.1 222.15,122.87 222.15,121.92 222.34,121.74 UM4.16
  BOTTOM w0.457: v3(237.44,30.63) 237.44,31.05 RH131.2
  BOTTOM w0.508: RH8.1 RH7.2 v3(209.04,22.72) ; RA92.1 17.67,7.81 17.31,8.17 v3(17.31,8.25) ; CD22.1 138.93,43.65 CD23.1 138.94,43.4 139.45,42.89 v3(140.63,42.89) ; RF2.2 67.54,58.51 RF1.2 67.73,57.91 v3(67.48,57.66) ; v3(150.28,136.18) RM14.1 149.93,136.81 149.62,136.5 149.62,135.3 148.78,134.46 CM31.1 ; RM63.1 166.37,131.7 v3(166.37,132.26) ; v3(145.02,131.69) 144.66,132.05 UV18.1 ; v3(138.53,76.05) 138.55,76.04 RV531.1 ; v3(133.21,107.44) 132.72,106.95 PR318.1 ; CM21.1 222.7,123.04 v3(222.7,122.28) ; RM83.1 165.27,133.01 164.52,133.76 RM66.2 v3(164.14,134.48) ; v3(226.48,22.33) 226.25,22.1 226.25,21.16 226.63,20.78 RH121.1 226.19,20.02 RH43.1 ; RH157.1 RH137.1 v3(215.67,22.85) ; v3(253.05,43.51) 252.91,43.37 251.89,43.37 251.28,43.98 251.28,44.99 250.4,45.87 249.72,45.87 RF4.2 RF5.2 ; RV298.1 105.12,139.05 v3(105.17,139.11) ; v3(95.15,131.47) 91.85,131.47 91.22,130.84 RV81.1 ; 30.62,12.59 30.94,12.91 30.94,15.37 29.96,16.35 RA128.2 ; v3(150.61,126.38) 150.88,126.64 150.88,126.93 RM81.1 RM76.1 ; 90.11,127.85 92.01,125.95 92.01,125.16 RV47.1 CV16.1 ; v3(113.97,143.05) 113.36,143.66 RV42.1 ; CM18.1 218.7,112.55 v3(218.37,112.88) ; v3(210.26,22.82) 210,23.09 RH136.2 RH10.2 ; RM20.1 220.16,112.05 v3(219.84,112.37) ; v3(245.11,25.17) 244.79,24.86 PR301.1 ; RH14.1 236.58,33.44 v3(236.11,33.91) 235.55,33.91 RH151.1 ; v3(107.76,136.98) 108.83,136.98 109.18,137.34 RV302.1 ; v3(113.51,140.07) 113.45,140.13 112.8,140.13 RV294.1 CV429.1 ; QN3.2 150.76,16.72 151.39,16.09 151.91,16.09 v3(152.3,15.7) ; v3(203.13,127) 203.84,127 204.47,127.64 204.47,129 204,129.47 CF6.1 ; v3(131.49,134.51) 130.82,133.85 129.67,133.85 129.31,134.2 RV20.1 ; v3(212.85,22.89) RH130.1 RH119.1 ; RC27.1 87.19,99.4 86.67,99.92 86.67,101.38 86.57,101.48 86.57,102.63 v3(84.14,105.06) ; R181.1 141.1,10.58 v3(141.16,10.52) ; v3(147.35,16.2) 147.77,15.78 C2498.1 ; RV306.1 107.44,141.51 RV303.1 v3(107.29,142.47) ; RT5.1 199.19,130.77 v3(199.77,131.35) ; RM18.1 224.03,125.29 v3(224.03,125.71) CM19.1 ; v3(235.61,30.44) 235.38,30.67 RH61.1 ; RV15.2 144.55,135.79 v3(144.55,135.07) ; RM19.1 225.19,111.01 v3(224.82,110.64) ; RH154.1 236.4,31.97 237.03,31.33 RH131.2 ; v3(234.68,50.66) 234.44,50.9 230.58,50.9 229.5,51.98 RV529.1 RV528.1 ; RM35.2 RM30.2 218.63,117.63 218.82,117.44 220.79,117.44 v3(221.24,116.99)
  vias: v3(31.78,9.1) v3(32.42,9.1) v3(59.06,12.16) v3(59.06,11.53) v3(59.06,10.95) v3(59.06,10.31) v3(59.69,12.16) v3(59.69,11.53) v3(59.69,10.95) v3(59.69,10.31) v3(59.69,9.72) v3(60.33,11.14) v3(60.33,9.77) v3(60.96,11.14) v3(61.33,10.57) v3(61.55,11.14) v3(72.77,51.14) v3(73.34,51.46) v3(73.34,50.83) v3(80.82,120.4) v3(81.07,120.94) v3(87.17,126.63) v3(104.07,141.65) v3(104.65,141.68) v3(150.05,56.2) v3(150.04,55.48) v3(150.71,56.19) v3(150.71,55.48) v3(155.08,7.63) v3(155.49,8.14) v3(158.35,26.84) v3(158.68,27.38) v3(158.93,26.84) v3(159.26,27.38) v3(160.31,27.85) v3(160.31,27.21) v3(160.91,27.87) v3(178.58,7.63) v3(178.89,8.16) v3(195.96,7.65) v3(196.55,7.65) v3(204.65,7.62) v3(205.01,8.09) v3(208.78,28.36) v3(208.76,27.15) v3(221.91,7.65) v3(222.49,7.65) v3(228.14,7.63) v3(228.5,8.13) v3(233.79,38.74) v3(234.43,38.74) v3(238.32,39.08) v3(238.32,37.94) v3(245.18,7.77) v3(264.72,11.46) v3(265.31,11.46) v3(282.37,7.39) v3(282.83,6.99)
+3VS_CAM: length 5.1
  TOP w0.254: JEDP1.29 v3(94.04,125.11) 94.17,125.25 94.17,125.69 JEDP1.28
  BOTTOM w0.127: RV47.2 93.45,127.51 v1(93.59,127.65)
  BOTTOM w0.508: v3(94.04,125.11) 93.45,125.7 RV47.2
+3VS_CARD: length 17.2
  TOP w0.127: v3(321.4,19.93) 321.32,19.93 v2(320.66,20.59)
  TOP w0.203: 323.6,19.79 324.32,19.79 324.5,19.61 UR1.27 ; 330.52,18.41 UR1.11
  TOP w0.254: RR4.2 320.77,17.89 320.52,18.14 v3(320.52,18.58) 320.78,18.58 320.97,18.39 RR4.1
  IN6 w1.016: 323.28,19.59 324.47,19.59 325.77,20.88 330.65,20.88 332.68,18.85
  vias: v3(321.4,19.29) v3(333.5,18.75) v3(334.1,18.75)
+3VS_DP: length 0.6
  TOP w0.127: v2(146.53,138.26) v3(146.1,138.69)
+3VS_TOUCH: length 46.8
  TOP w0.127: v3(188.93,132.81) v2(189.57,132.81)
  TOP w0.254: v3(173.41,146.27) 174.04,146.9 174.04,147.32 174.15,147.42 JPWR1.3
  IN3 w0.508: v3(173.41,146.27) 173.41,145.44 173.8,145.05 173.8,143.66 178.2,139.26 180.95,139.26 182.26,137.95 183.48,137.95 184.09,138.56 187.82,138.56 188.15,138.23 188.15,134.46 188.93,133.68 v3(188.93,132.81)
  IN4 w0.508: v3(188.93,132.81) 189.67,132.07 193.44,132.07 195.15,130.35 v3(195.15,130.04)
  BOTTOM w0.508: v3(195.15,130.04) 195.58,130.04 196.39,130.85 RT6.2 193.64,131.49 CT3.1 193.42,131.96 194.34,132.87 UT1.1 ; RE100.1 RE101.1 187.61,131.5 v3(188.93,132.81)
+3VS_VGA: length 82.9
  TOP w0.457: UV20.4 159.94,39.53 159.67,39.8 CV408.1
  TOP w0.508: CV408.1 159.37,41.15 159.37,42.72 v3(159.4,42.75) ; v3(156.85,32.92) 156.31,33.45 156.31,34.24 RV243.1 RV242.1
  IN2 w0.508: v3(159.4,42.75) 159.54,42.89 159.54,46.85 157.14,49.25 157.14,53.93 156.57,54.49 v3(156.57,54.92) 156.57,56.21 154.84,57.94 154.84,59.51 v3(155.01,59.68) ; v3(163.21,54.79) 160.82,54.79 v3(158.92,52.88)
  IN5 w0.508: v3(138.52,76.99) 138.94,76.57 v3(148.81,76.57) ; v3(158.92,52.88) 157.86,52.88 156.57,54.17 v3(156.57,54.92)
  IN5 w1.524: 156.81,63.49 158.14,63.49 158.96,64.3 158.96,75.35
  IN6 w0.508: v3(159.4,42.75) 159.4,34.52 158.64,33.76 157.82,33.76 156.99,32.92 v3(156.85,32.92)
  BOTTOM w0.254: UV1.AJ10 v3(177.19,74.39) ; v3(171.87,76.28) 172,76.15 UV1.AR11 ; UV1.AW18 169,81.19 v3(168.61,81.59)
  BOTTOM w0.305: v3(177.23,76.28) 176.8,75.85 UV1.AJ11 ; v3(173.17,76.25) 173.6,75.82 UV1.AN11 ; UV1.AK11 176,76.33 v3(176,76.33) ; v3(174.8,76.25) 174.4,75.85 UV1.AM11
  BOTTOM w0.381: UV19.5 138.1,82.33 CV54.1
  BOTTOM w0.508: RV552.1 158.74,52.71 v3(158.92,52.88) ; LV14.2 155.75,63.67 v3(155.55,63.46) ; CV54.1 138.09,80.23 138.31,80.01 138.31,77.21 v3(138.52,76.99) ; RV551.1 162.98,54.56 v3(163.21,54.79)
  vias: v2(167.41,77.07) v3(150.2,78.54) v3(150.2,77.93) v3(150.84,78.55) v3(154.99,60.29) v3(155.58,60.28) v3(167.62,78.36) v3(168.54,78.36) v3(168.54,77.64)
+3VS_WLAN_NGFF: length 186.8
  TOP w0.508: v3(171.1,34.39) 171.1,34.97 CM26.1 ; v3(171.1,32.54) 170.91,32.73 RN25.1 168.04,32.73 QN4.2 ; v3(172.21,29.39) 171.55,28.73 RN26.1 168.08,28.73 QN5.2 ; RE92.2 v3(288.47,31.54)
  IN3 w0.508: v3(288.47,31.54) 288.47,33.54 285.33,36.68 271.49,36.68 270.35,37.82 261.53,37.82 258.54,40.82 254.54,40.82 251.8,43.55 251.8,45.34 242.91,54.23 232.46,54.23 v3(230.3,56.39)
  BOTTOM w0.508: 171.45,35.27 171.1,34.91 v3(171.1,34.39) v3(171.1,32.54) 171.1,29.99 171.69,29.39 v3(172.21,29.39) 172.21,28.68 171.82,28.28 171.82,25.28 169.77,23.23 v3(169.77,21.14) ; 175.05,35.59 175.33,35.31 175.33,32.56 175.96,31.93 175.96,27.5 181.4,22.06 187.01,22.06 192.6,27.65 192.6,28.24 197.29,32.94 199.26,32.94 201.55,35.23 201.55,46.45 206.16,51.06 206.16,53.36 210.81,58 223.71,58 225.95,55.77 229.68,55.77 v3(230.3,56.39)
  vias: v2(169.27,20.04) v3(163.19,18.93) v3(163.54,19.42) v3(163.89,18.93) v3(164.24,19.42) v3(170.41,21.14) v3(171.04,21.14) v3(171.63,21.15)
+5VALW: length 188.1
  TOP w0.203: U18.4 217.01,12.6 216.59,12.18 216.59,11.52
  TOP w0.508: v3(156.85,32.29) 157.34,31.79 157.34,30.37 156.81,29.83 v2(156.81,28.56) 156.47,28.22 PR204.1 PR203.1 ; PR8.1 288.19,32.32 289.19,33.33 v2(289.19,33.97) v3(289.19,34.94) 290.27,36.02 RM91.1 ; RN27.1 163.88,32.63 v3(162.64,32.63) ; v3(296.13,35.03) 296.13,35.14 296.12,35.16 RM93.1 ; 216.59,11.52 216.59,11.03 217.03,10.59 219.55,10.59 219.65,10.68 219.88,10.92 219.88,10.92 220.13,11.17 220.69,11.17 222.75,13.23 222.86,13.23 222.87,13.24 v2(226.33,13.24) 231.84,13.24 237.14,18.53 237.14,22.81 240.68,26.35 240.68,28.3 242.76,30.38 242.76,31.4 244.62,33.25 244.62,33.71 v3(245.38,34.47) ; RM92.1 RM94.1 294.65,31.74 294.3,32.09 v3(294.3,35.02) ; v3(170.48,133.93) 170.48,134.4 170.09,134.79 167.57,134.79 166.96,135.4 166.96,135.94 166.36,136.54 161.3,136.54 159.65,134.89 RE38.1 ; v3(72.9,17.62) 72.72,17.44 72.72,15.26 71.52,14.06 PR14.2 ; v3(313.96,39.38) R175.1
  IN3 w0.508: v3(170.48,133.93) 170.48,133.66 170.1,133.28 168.02,133.28 167.63,133.67 161.23,133.67 160.42,134.48 152.54,134.48 150.81,132.76 146.88,132.76 v3(145.9,133.73)
  IN6 w0.508: v3(156.85,32.29) 157.55,31.59 161.2,31.59 162.24,32.63 v3(162.64,32.63)
  BOTTOM w0.254: PU301.7 135.74,110.37 136.21,110.83 136.21,112.41 v3(135.89,112.73) 135.88,112.74 PC313.1 ; PC308.1 245.99,29.87 246.45,29.42 246.45,28.53 245.93,28.01 PU300.7
  BOTTOM w0.33: v3(52.22,16.66) 52.22,16.04 52.4,15.86 70.38,15.86 71.06,16.54 71.82,16.54 v3(72.9,17.62)
  BOTTOM w0.508: RE28.1 280.04,8.93 QE8.3 283.13,8.93 284.32,10.12 284.32,11.19 283.45,12.05 283.45,14.48 284.66,15.69 284.66,16.76 284.9,17 284.9,22.27 285.26,22.62 285.26,23.93 284.05,25.14 284.05,27.36 284.21,27.52 284.21,29.89 283.33,30.77 283.33,34.01 v3(284.34,35.03) ; PC308.1 245.99,30.67 244.95,31.71 244.95,34.04 v3(245.38,34.47)
  vias: v3(12.09,20.79) v3(12.09,20.21) v3(12.1,21.38) v3(12.68,21.38) v3(12.67,20.79) v3(12.67,20.21) v3(28.01,40.18) v3(28.32,40.76) v3(28.32,39.61) v3(28.64,40.18) v3(28.96,40.76) v3(28.96,39.61) v3(29.28,40.18) v3(29.59,40.76) v3(29.59,39.61) v3(29.91,40.18) v3(30.23,40.76) v3(30.23,39.61) v3(30.55,40.18) v3(30.86,40.76) v3(30.86,39.61) v3(31.18,40.18) v3(49.75,16.98) v3(49.75,16.4) v3(50.33,17.29) v3(50.34,16.66) v3(50.95,17.29) v3(50.95,16.66) v3(51.58,17.93) v3(51.59,17.3) v3(51.59,16.66) v3(52.21,17.93) v3(52.22,17.3) v3(265.81,39.21) v3(266.32,38.83) v3(313.76,44.92) v3(314.39,44.92) v3(315.59,45.11) v3(316.11,45.39) v3(316.11,44.81) v3(316.11,44.22) v3(316.42,57.69) v3(316.74,56.1) v3(317.06,57.69) v3(317.38,56.1)
+5VALW_LED: length 232.6
  TOP w0.127: v2(286.62,38.55) 286.51,38.44 v3(286.01,38.44)
  TOP w0.254: v3(174.86,146.26) 174.86,146.98 175.15,147.27 JPWR1.5
  IN2 w0.508: v3(174.86,146.26) 174.87,146.27 174.87,146.62 175.43,147.18 179.39,147.18 180.44,146.13 181.12,146.13 181.46,145.79 181.46,144.22 182.07,143.61 184.66,143.61 185.02,143.97 185.02,144.91 185.28,145.18 187.92,145.18 188.89,144.21 188.89,143.56 190.12,142.33 190.12,138.19 190.57,137.75 192.27,137.75 193.14,136.87 194.72,136.87 197.66,133.92 198.64,133.92 199.18,133.39 199.89,133.39 211.93,121.35 211.93,113.51 221.32,104.12 223.6,104.12 224.18,103.53 224.18,102.75 232.92,94.01 232.92,72.2 232.64,71.92 232.64,68.01 232.36,67.73 232.36,66.54 230.93,65.1 230.93,59.8 236.69,54.03 240.55,54.03 247.14,47.44 247.14,39.52 248.82,37.85 250.18,37.85 251.67,36.36 252.36,36.36 252.69,36.69 255.56,36.69 256.4,35.85 263.58,35.85 265.56,37.84 270.68,37.84 270.98,37.53 285.09,37.53 v3(286.01,38.44)
  BOTTOM w0.508: QE8.1 283.96,7.96 284.3,8.31 284.3,9.21 284.95,9.86 284.95,15.08 285.29,15.42 285.29,16.49 285.54,16.73 285.54,21.96 285.89,22.32 285.89,24.14 285.83,24.21 285.83,27.19 285.47,27.55 285.47,29.51 285.21,29.77 285.21,37.64 v3(286.01,38.44)
+5VALWP: length 11
  TOP w0.127: v3(19.94,33.68) 19.67,33.95 v2(18.65,33.95)
  TOP w0.203: v3(25.91,29.62) 25.73,29.43 PU100.14
  TOP w0.254: PR102.2 v3(19.94,33.68)
  BOTTOM w0.254: v3(19.94,33.68) 20.45,34.19 21.47,34.19 22.86,35.59 PC108.1
  BOTTOM w0.508: 26.55,31.46 26.55,30 26.16,29.62 v3(25.91,29.62)
+5VS: length 618.8
  TOP w0.203: v3(154.62,55.52) 154.62,55.7 153.33,56.99 UV11.4
  TOP w0.254: JPWR1.4 174.65,147.32 174.47,147.14 174.47,146.6 v3(174.13,146.26) ; PC408.1 205.68,18.44 205.3,18.82 PU401.6
  TOP w0.457: v3(57.53,14.53) 58.65,14.53 58.68,14.51 58.8,14.63
  TOP w0.508: v3(206.84,18.08) 206.83,18.07 PC408.1 ; PR501.2 102.94,120.63 102.94,131.03 v3(102.33,131.64) ; JTRONF.2 183.81,13.29 183.58,13.06 183.25,13.06 183.01,13.3 JTRONF.1 183.01,14.76 181.65,16.12 C27.1 180.84,16.55 180.57,16.82 179.86,16.82 179.22,17.45 v3(179.22,17.5) ; v3(191.47,21.8) 191.47,24.59 192.91,26.04 192.91,29.68 193.8,30.57 PR643.1 193.8,32.09 193.36,32.54 189.24,32.54 188.89,32.9 183.36,32.9 182.37,31.9 PR625.2
  IN1 w0.508: v3(161.84,137.82) 161.84,138.9 ; 161.84,138.9 160.76,139.98 158.75,139.98 158.21,140.53 158.21,141.28 157.52,141.96 157.52,145.09 v3(155.96,146.65) ; 161.84,138.9 162.3,139.36 164.27,139.36 166.03,141.11 167.44,141.11 169.74,143.41 173.43,143.41 174.13,144.11 v3(174.13,146.26) ; v3(269.67,36.79) 269.2,36.32 263.36,36.32 261.46,38.23 259.31,38.23 258.64,38.9 258,38.9 254.71,42.19 254.71,42.82 252.9,44.63 249.39,44.63 243.66,50.36 240.97,50.36 240.16,51.17 v3(240.16,51.46)
  IN1 w3.048: 70.61,17.36 64.57,17.36
  IN2 w0.508: v3(188.72,17.49) 189.18,17.95 200.16,17.95 200.76,18.56 206.36,18.56 v3(206.84,18.08)
  IN3 w0.508: v3(57.53,14.53) 57.53,13.46 55.35,11.28 48.71,11.28 47.17,12.82 29.68,12.82 28.82,13.68 28.82,15.26 v3(29.11,15.55) ; v3(134.27,99.6) 134.27,103.23 131.15,106.34 131.15,109.86 134.57,113.27 134.57,114.11 136.3,115.84 137.47,115.84 v3(138.24,116.61) ; v3(138,136.06) 137.75,135.8 133.75,135.8 132.55,137 129.63,137 129.07,136.44 113.25,136.44 113.12,136.57 v3(112.33,136.57) 111.91,136.15 111.91,135.49 110.78,134.36 106.2,134.36 v3(105.77,134.79) ; v3(174.13,146.26) 174.13,145.86 174.46,145.53 174.46,143.91 178.46,139.92 187.36,139.92 188.81,138.47 188.81,134.95 189.69,134.08 191.24,134.08 v3(191.59,134.43) ; v3(240.16,51.46) 240.16,51.02 240.86,50.32 240.86,47.87 240.13,47.14 237.19,47.14 v3(236.36,46.32)
  IN3 w1.016: 192.6,133.87 192.67,133.95 200.74,133.95 210.43,124.26 211.27,124.26
  IN4 w0.508: v3(146.5,99.72) 145.28,98.5 137.34,98.5 135.89,99.95 134.62,99.95 v3(134.27,99.6)
  IN4 w2.032: 63.12,19.35 63.63,19.86 63.63,25.74 74.3,36.41 74.3,41.52 69.44,46.38 67.82,46.38 66.49,47.72 ; 101.48,134.52 96.94,129.99 96.03,129.99 93.56,127.52 91.01,127.52 84.14,120.66 84.14,108.31 72.29,96.45 72.29,66.37 65.85,59.93 65.85,58.1
  IN5 w0.508: v3(188.72,17.49) 188.72,17.26 188.22,16.75 183.16,16.75 182.41,17.5 v3(179.22,17.5) ; v3(154.62,55.52) 154,55.52 151.36,52.88 144.93,52.88 135.55,62.27 135.55,76.28 133.24,78.59 133.24,98.57 v3(134.27,99.6)
  IN6 w0.508: v3(138.24,116.61) 138.94,116.61 140.65,118.33 143.39,118.33 145.75,120.69 145.75,129 v3(138.67,136.07) ; v3(155.96,146.65) 154.18,144.87 154.18,142.27 149.16,137.25 143.8,137.25 142.34,138.71 139.07,138.71 138.67,138.32 v3(138.67,136.73)
  BOTTOM w0.254: UA5.6 28.81,14.96 29.12,15.26 29.12,15.54 v3(29.11,15.55)
  BOTTOM w0.305: v3(146.5,99.72) 146.5,98.55 147.24,97.81 UV22.3
  BOTTOM w0.381: CV23.1 154.76,147.21 155.12,146.85 UV3.16
  BOTTOM w0.457: v3(57.53,14.53) 56.78,14.53 56.19,13.93 56.19,13.38 56.83,12.73 56.83,11.27 56.45,10.89 55.11,10.89 54.99,10.77 ; v3(161.84,137.82) 161.84,138.06 161.3,138.6 RE39.1
  BOTTOM w0.508: RV32.2 RV31.2 111.9,137 v3(112.33,136.57) ; QH1.2 236.73,36.12 237.35,36.74 v3(237.61,36.74) ; JKB3.5 54.65,9.53 54.99,9.87 54.99,10.77 54.94,10.77 54.15,11.56 JKB3.6 ; v3(269.67,36.79) 269.61,36.73 RE5.1 ; PR520.2 131.14,123.8 131.14,120.18 134.2,117.12 136.92,117.12 PR530.2 138.19,116.61 v3(138.24,116.61) ; v3(152.52,21.45) 152.52,18.11 153.28,17.35 RN24.1 ; RT11.2 191.91,134.11 v3(191.59,134.43) ; v3(191.01,21.3) 191.01,18.77 189.73,17.49 v3(188.72,17.49) ; v3(240.16,51.46) 240.16,51.56 240.65,52.06 CF5.1 239.94,52.61 RF6.2 239.51,52.17 239.51,51.07 239.87,50.71 240.44,50.71 240.96,50.19 240.96,50.12 JFAN2.1 ; JFAN1.1 62.08,52.85 v3(63.39,52.85) ; v3(223.12,125.45) 222.72,125.45 222.35,125.82 CE26.1 ; CV23.1 CV376.1 155.96,147.49 v3(155.96,146.65)
  vias: v2(163.67,25.83) v3(60.07,18.33) v3(60.07,17.67) v3(60.07,17.03) v3(60.67,17.67) v3(60.67,17.03) v3(60.7,18.33) v3(61.28,18.33) v3(61.28,17.67) v3(61.28,17.03) v3(61.88,18.33) v3(61.91,17.63) v3(61.91,17.03) v3(65.14,56.71) v3(65.78,56.71) v3(125.29,14.18) v3(125.87,14.18) v3(162.97,25.12) v3(162.98,24.5) v3(163.26,23.97) v3(163.58,25.12) v3(163.58,24.49) v3(212.34,124.2) v3(212.81,124.6) v3(223.15,124.78) v3(223.36,122.26)
+5VS_TP_LED: length 53.6
  TOP w0.127: v2(202.44,133.87) v3(203.37,133.87)
  IN6 w1.016: 168.12,145.86 168.67,145.86 170.64,147.83 191.25,147.83 193.13,145.95 193.13,141.18 195.28,139.03 195.98,139.03 201.41,133.6 202.47,133.6
  BOTTOM w1.016: 203.33,131.92 207.95,127.29 207.95,126.41 208.92,125.44
  vias: v3(166.51,145.75) v3(167.15,145.75) v3(203.37,133.24)
+AV12_DV12_S: length 15.6
  TOP w0.127: v3(333.42,20.51) 333.64,20.51 334.07,20.09 v2(334.07,19.86)
  TOP w0.203: UR1.10 329.88,18.01 330.21,17.68 330.21,17.16
  TOP w0.254: UR1.14 330.56,19.61 CR8.1
  TOP w0.508: v3(331.61,16.26) 331.08,15.72 CR4.1 330.7,15.52 330.21,16 330.21,17.16 ; CR8.1 CR5.1 v3(333.42,20.51)
  IN2 w0.508: v3(331.61,16.26) 331.61,19.41 332.72,20.51 v3(333.42,20.51)
+AVDDH: length 21.7
  TOP w0.203: CL5.1 322.77,30.81 321.39,30.81 321.21,30.63 320.26,30.63 319.85,31.04 UL1.9 ; CL7.1 319.85,37.75 319.85,37.74 UL1.22
  TOP w0.508: v3(321.99,38.62) v1(321.27,38.62) CL7.1 ; v3(322.44,29.83) 322.72,29.55 CL6.1 CL5.1
  IN4 w0.508: v3(321.99,38.62) 323.31,37.3 324.36,37.3 324.8,36.86 324.8,35.4 324.04,34.63 324.04,31.43 v3(322.44,29.83)
+AVDDL: length 48.5
  TOP w0.127: v3(323.53,36.67) v2(323.53,37.53)
  TOP w0.203: CL24.1 323.1,32.83 321.64,32.83 321.47,33 UL1.13 ; UL1.6 318.65,30.08 v3(318.59,30.01) ; UL1.19 321.7,35.4 322.26,35.97 CL25.1
  TOP w0.254: 313.82,34.52 314.53,34.52 314.61,34.6 UL1.34 ; CL23.1 313.68,36.31 315.08,36.31 315.59,35.8 UL1.31
  TOP w0.508: v3(318.59,30.01) 317.96,29.38 CL19.1 CL18.1 ; 313.82,34.52 CL20.1 CL21.1 312.8,34.51 CL22.1 311.74,34.88 312.13,35.27 v3(312.84,35.27) v3(313.48,35.27) 313.48,35.75 CL23.1 ; CL25.1 323.14,36.15 323.53,36.54 v3(323.53,36.67) ; CL24.1 323.22,32.72 v3(323.22,32.15)
  IN2 w0.508: v3(313.48,35.27) 313.48,32.63 314.52,31.59 316.78,31.59 318.35,30.01 v3(318.59,30.01) 319.59,31.02 322.71,31.02 323.22,31.52 v3(323.22,32.15) ; v3(312.84,35.27) 312.84,35.69 313.57,36.41 317.88,36.41 319.17,37.7 322.95,37.7 323.53,37.11 v3(323.53,36.67)
+DV33_18: length 2.7
  TOP w0.127: CR3.2 328.77,23.67 328.77,25.2 v1(329.11,25.54)
+DVDDL: length 4.5
  TOP w0.127: v1(314.67,31.5) 314.06,31.5 CL3.1
  TOP w0.203: CL4.1 314.7,32.73 315.37,33.4 UL1.37
  TOP w0.508: CL4.1 CL3.1
+PVDD: length 14.8
  IN2 w1.016: 4.35,17.59 4.35,21.64 2.68,23.31 2.68,24.4 3.22,24.93 3.22,31.4 3.25,31.43
  vias: v1(1.56,33.14) v3(2.19,33.26) v3(2.19,32.63) v3(5.4,17.79) v3(5.41,17.21)
+V18R: length 4.3
  TOP w0.127: CE48.1 292.37,24.42 v1(291.64,23.7)
  TOP w0.203: UE5.124 291.13,24.25 291.94,25.06 CE48.1
+VCC_3IN1: length 4.6
  TOP w0.203: v3(330.13,18.95) 329.99,18.81 UR1.12
  BOTTOM w0.508: v3(303.49,30.93) 303.15,31.26 JCR.4 ; v3(304.19,23.71) 303.48,24.42 JCR.11
  vias: v2(302.73,28.55) v3(304.61,23.2) v3(330.72,18.96)
+VCC_CORE: length 7.6
  TOP w0.254: PC901.1 112.99,96.86 113.65,97.53 113.65,98.49 v3(114.08,98.92)
  TOP w0.508: v3(94.11,107.22) RC44.1
  BOTTOM w0.254: CPU1.F22 v3(114.08,98.92) ; CPU1.M6 124.72,94.2 v3(124.37,94.55) 124.72,94.9 CPU1.L6
  vias: v2(125.16,114.7) v3(94.87,109.69) v3(94.87,108.87) v3(94.87,107.98) v3(94.87,107.22) v3(94.81,106.2) v3(94.81,105.37) v3(96.52,110.58) v3(96.52,109.69) v3(96.52,107.98) v3(96.67,102.48) v3(96.67,101.02) v3(96.67,99.62) v3(96.67,98.22) v3(96.67,96.82) v3(97.46,102.48) v3(97.46,101.02) v3(97.46,99.62) v3(97.46,98.22) v3(97.46,96.82) v3(97.5,96.08) v3(98.24,112.3) v3(98.24,109.69) v3(98.24,108.87) v3(98.24,108.1) v3(98.24,107.47) v3(98.25,102.48) v3(98.25,101.02) v3(98.25,99.62) v3(98.25,98.22) v3(98.25,96.82) v3(98.28,96.08) v3(98.68,111.66) v3(98.77,91.1) v3(98.77,89.7) v3(98.77,88.3) v3(98.77,84.1) v3(98.77,82.7) v3(98.87,109.69) v3(98.87,108.87) v3(98.87,108.1) v3(98.87,107.47) v3(98.81,81.38) v3(98.83,79.89) v3(98.89,94.86) v3(98.89,93.76) v3(98.95,85.51) v3(99.02,86.99) v3(99.19,106.2) v3(99.19,105.37) v3(99.32,111.66) v3(99.32,111.03) v3(99.35,92.76) v3(99.36,91.93) v3(99.34,80.83) v3(99.46,83.2) v3(99.43,82.49) v3(99.51,81.85) v3(99.71,87.88) v3(99.71,84.4) v3(99.82,102.48) v3(99.82,101.02) v3(99.82,99.62) v3(99.82,98.22) v3(99.82,96.82) v3(99.95,111.03) v3(100.01,112.61) v3(100.16,86.07) v3(100.15,81.21) v3(100.21,93.02) v3(100.22,92.14) v3(100.4,82.05) v3(100.59,109.76) v3(100.59,107.91) v3(100.61,102.48) v3(100.61,101.02) v3(100.61,99.62) v3(100.61,98.22) v3(100.61,96.82) v3(100.71,112.68) v3(100.95,86.1) v3(101.03,93.34) v3(101.04,92.59) v3(101.06,81.19) v3(101.09,111.66) v3(101.29,82.18) v3(101.51,88.94) v3(101.51,88.31) v3(101.6,111.03) v3(101.73,112.68) v3(101.73,111.66) v3(101.82,93.02) v3(101.92,89.91) v3(101.89,86.28) v3(101.95,81.57) v3(102.05,106.2) v3(102.05,105.37) v3(102.18,102.48) v3(102.18,101.02) v3(102.18,99.62) v3(102.18,98.21) v3(102.15,88.31) v3(102.3,109.76) v3(102.3,109.12) v3(102.3,107.98) v3(102.3,107.28) v3(102.53,85.01) v3(102.62,111.03) v3(102.61,93.34) v3(102.61,92.64) v3(102.61,82.13) v3(102.64,81.19) v3(102.75,112.68) v3(102.75,111.66) v3(102.97,102.48) v3(102.97,101.02) v3(102.97,99.62) v3(102.97,98.22) v3(102.93,91) v3(103.11,86.43) v3(103.26,85.08) v3(103.38,93.02) v3(103.37,82.09) v3(103.36,81.2) v3(103.63,111.03) v3(103.76,113.69) v3(103.76,112.68) v3(103.76,111.66) v3(104.08,109.76) v3(104.08,107.91) v3(104,86) v3(104.08,82.17) v3(104.14,93.34) v3(104.11,92.64) v3(104.09,81.17) v3(104.36,83.94) v3(104.36,83.3) v3(104.54,102.48) v3(104.54,101.02) v3(104.54,99.62) v3(104.54,98.22) v3(104.65,111.03) v3(104.64,95.78) v3(104.64,94.95) v3(104.64,94.25) v3(104.66,82.57) v3(104.78,113.69) v3(104.78,112.68) v3(104.78,111.66) v3(104.76,90.34) v3(104.69,85.03) v3(104.84,93.31) v3(104.81,91.18) v3(104.79,81.66) v3(104.89,86.38) v3(105.33,102.48) v3(105.33,101.02) v3(105.33,99.62) v3(105.33,98.22) v3(105.41,111.09) v3(105.48,92.9) v3(105.53,95.74) v3(105.51,94.57) v3(105.51,93.76) v3(105.55,89.3) v3(105.55,88.03) v3(105.55,85.41) v3(105.5,82.2) v3(105.49,81.19) v3(105.79,114.71) v3(105.79,113.69) v3(105.79,112.68) v3(105.79,111.66) v3(105.79,109.76) v3(105.79,109.12) v3(105.79,107.91) v3(105.79,107.28) v3(106.18,88.66) v3(106.18,87.39) v3(106.18,86.12) v3(106.18,84.85) v3(106.18,83.63) v3(106.17,81.87) v3(106.3,116.49) v3(106.3,115.47) v3(106.36,90.14) v3(106.43,111.09) v3(106.49,106.2) v3(106.49,105.37) v3(106.54,95.75) v3(106.62,82.62) v3(106.81,114.71) v3(106.81,113.69) v3(106.81,112.68) v3(106.81,111.66) v3(106.87,93.18) v3(106.82,84.23) v3(106.91,102.48) v3(106.91,101.02) v3(106.91,99.62) v3(106.91,98.22) v3(107.32,116.49) v3(107.32,115.47) v3(107.44,111.09) v3(107.57,109.76) v3(107.57,107.91) v3(107.63,112.61) v3(107.68,92.83) v3(107.76,111.98) v3(107.69,102.48) v3(107.69,101.02) v3(107.69,99.62) v3(107.69,98.22) v3(108.52,111.09) v3(108.98,94.76) v3(108.98,94.12) v3(109.18,95.57) v3(109.27,102.48) v3(109.27,101.02) v3(109.27,99.62) v3(109.27,98.22) v3(109.29,109.69) v3(109.29,109.06) v3(109.29,107.91) v3(109.29,107.28) v3(109.35,106.2) v3(109.35,105.31) v3(109.54,111.09) v3(110.08,102.48) v3(110.08,101.02) v3(110.08,99.62) v3(110.08,98.22) v3(110.06,81.44) v3(110.43,111.41) v3(110.68,81.22) v3(111.39,81.44) v3(111.75,95.7) v3(112.15,81.44) v3(112.38,95.7) v3(112.4,116.36) v3(112.4,115.34) v3(112.4,114.26) v3(112.4,113.25) v3(112.4,112.23) v3(112.4,111.28) v3(113.11,81.37) v3(113.41,116.36) v3(113.41,115.34) v3(113.41,114.26) v3(113.41,113.25) v3(113.41,112.23) v3(113.41,111.28) v3(114.43,116.36) v3(114.43,115.34) v3(114.43,114.26) v3(114.43,113.25) v3(114.43,112.23) v3(114.43,111.28) v3(114.43,110.33) v3(114.77,81.39) v3(115.12,95.75) v3(115.4,81.39) v3(115.51,116.36) v3(115.51,115.34) v3(115.51,114.26) v3(115.51,113.25) v3(115.76,95.75) v3(117.36,81.44) v3(118.24,81.37) v3(118.3,95.6) v3(118.81,116.3) v3(118.87,81.37) v3(119.66,82.97) v3(119.65,81.92) v3(119.87,99.61) v3(119.95,116.3) v3(119.95,115.28) v3(120.05,96) v3(120.07,81.19) v3(120.27,88.17) v3(120.31,93.46) v3(120.31,92.78) v3(120.33,89.12) v3(120.55,82.64) v3(120.59,91.15) v3(120.59,81.55) v3(120.97,116.3) v3(120.97,115.28) v3(120.97,114.07) v3(120.97,113.06) v3(120.94,93.46) v3(120.94,92.78) v3(121.02,89.25) v3(121.02,87.78) v3(121.02,86.28) v3(121.13,84.9) v3(121.21,81.18) v3(121.48,114.71) v3(121.44,85.6) v3(121.56,95.69) v3(121.67,97.05) v3(121.72,81.64) v3(121.99,116.3) v3(121.99,115.28) v3(121.99,114.07) v3(121.99,113.06) v3(121.94,93.63) v3(121.97,92.21) v3(122.94,114.07) v3(122.94,113.06) v3(123.13,116.3) v3(123.13,115.28) v3(126.18,111.09) v3(127.19,114.2) v3(127.19,113.18) v3(127.19,112.1) v3(127.19,111.09)
+VCCIO2PCH: length 32.1
  TOP w0.127: CC45.1 v2(128.23,108.34)
  TOP w0.508: 125.34,107.28 125.34,106.33 127.38,104.28 127.38,101.79 v3(125.74,100.14)
  IN2 w0.508: v3(125.74,100.14) 127.26,101.66 127.26,104.24 126.6,104.9 122.4,104.9 121.54,104.04 118.65,104.04 117.22,102.61 117.22,98.58 116.88,98.24 v3(116.55,98.24)
  BOTTOM w0.254: v3(116.55,98.24) 116.65,98.24 CPU1.F17 ; v3(125.74,100.14) 125.33,100.14 CPU1.D5
+VCCIO_OUT: length 108.5
  TOP w0.508: RC49.2 90.36,107.83 RC47.1 89.28,102.94 v3(89.66,102.56) ; v3(137.4,132.42) v2(136.96,131.98) 136.24,131.26 PR500.2 136.38,130.88 PR504.2 ; v3(121.93,111.1) RC34.2
  IN2 w0.508: v3(89.66,102.56) 89.66,103.09 90.64,104.07 109.98,104.07 113.45,107.53 115.69,107.53 116.77,108.61 119.45,108.61 v3(121.93,111.1) 122.98,111.1 125.17,108.91 128.7,108.91 131.89,112.1 131.89,115.28 134.18,117.57 136.21,117.57 136.52,117.88 142.81,117.88 146.56,121.63 146.56,128.74 142.62,132.68 140.22,132.68 139.37,131.83 138,131.83 v3(137.4,132.42)
  IN6 w0.508: v3(89.66,102.56) 92.63,99.6 v3(94.24,99.6)
  BOTTOM w0.254: v3(94.24,99.6) 94.56,99.92 CPU1.D51
  BOTTOM w0.508: RC51.1 CC32.1 88.97,102.88 RC11.1 89.06,102.56 v3(89.66,102.56) ; v3(137.4,132.42) 137.36,132.38 137.36,132.38 PR503.2
+VDD_TOUCH: length 6.4
  TOP w0.127: v2(101.75,128.84) 101.16,128.25 CV19.1
  TOP w0.254: 96.59,130.65 96.99,130.65 JEDP1.17 99.38,128.25 CV19.1
  vias: v3(94.06,130.28) v3(94.5,130.75)
+VDDCT_L: length 4.2
  BOTTOM w0.508: TL1.7 v3(329.45,80.54) ; TL1.10 v3(326.45,80.54) ; TL1.1 v3(335.45,80.58) ; TL1.4 v3(332.45,80.52)
  vias: v1(333.94,80.89)
AGND: length 36.4
  TOP w0.127: CA6.2 15.69,8.55 16.43,7.81 16.94,7.81 17.07,7.69 v2(17.39,7.69) ; 27.89,10.97 27.98,11.06 v2(27.98,11.58)
  TOP w0.203: v3(26.02,5.81) 26.08,5.87 UA6.7 ; UA1.30 17.33,11.24 v3(16.64,10.55) ; v3(15.15,13.76) 15.2,13.8 UA1.25 ; v3(26.65,5.81) 26.65,6.16 26.48,6.32 UA6.8 ; UA1.39 20.93,10.76 21,10.69 v3(21,10.7) ; v3(24.83,6.16) 25.14,6.16 25.28,6.31 UA6.5
  TOP w0.254: v3(12.14,18.67) 12,18.53 JIO.30
  TOP w0.406: QA7.4 3,9.12 v3(3.43,9.55) ; v3(5.3,7.22) 4.69,7.82 QA7.1
  TOP w0.508: RA122.1 v3(6.64,7.24)
  BOTTOM w0.381: QA2.3 v3(12.3,14.09)
  BOTTOM w0.457: QA13.2 24.75,6.16 v3(24.83,6.16)
  BOTTOM w0.508: CA15.1 21.88,12.92 CA71.1 23.01,14.05 24.18,14.05 v3(24.44,13.79) ; CA113.2 10.95,18.18 v3(10.49,17.72) ; v3(1.77,15.22) 1.65,15.33 RA54.1 ; v3(19.15,6.73) 18.85,7.04 CA8.1 ; CA75.2 28.39,10.49 v3(27.55,10.49) ; CA16.1 24.88,9.91 v3(24.42,9.91) ; 13.73,18.32 13.37,18.67 v3(12.14,18.67) 11.84,18.37 11.84,17.39 12.08,17.15 QA3.3 ; v3(26.65,5.81) 26.65,6.25 27.17,6.77 27.42,6.77 QA11.2 29.11,8.46 RA106.2 ; QA12.2 19.83,11.99 21,10.82 v3(21,10.7) 21.47,11.17 CA73.2 ; v3(15.15,13.76) 15.46,13.76 RA57.2 15.93,12.88 CA74.2 ; v3(20.61,6.05) 20.25,6.42 CA17.2
  vias: v2(19.84,6.12) v3(1.97,10.67) v3(3.88,9.11) v3(14.81,9.9) v3(15.39,9.9) v3(27.93,9.88)
DVDD_HDAIO: length 6.3
  TOP w0.127: RA51.2 21.97,22.21 21.97,23.59 v1(22.21,23.83)
  TOP w0.203: CA14.2 21.27,20.64 20.87,20.64 20.07,19.84 20.07,19.38 20.13,19.32 UA1.6
  TOP w0.508: RA51.2 21.5,20.87 CA14.2
GND: length 4737.7
  TOP w0.127: v2(321.76,64.29) v3(321.76,64.99) ; v3(319.09,43.52) v2(319.09,42.89)
  TOP w0.203: v3(153.35,29.4) 153.34,29.38 PU200.14 ; v3(148.66,30.09) 148.96,29.78 PU200.1 ; v3(153.38,60.31) 153.33,60.26 UV11.11 ; PU200.3 148.4,28.98 v3(148.35,29.04) ; UV4.15 106.74,139.5 v3(106.67,139.42) ; UL1.27 317.85,37.16 v3(317.39,37.62) ; U17.11 56.73,13.62 v3(56.8,13.68) ; v3(278.94,28.75) 279.2,28.49 UE5.24 ; UE5.11 284.4,28.32 v3(284.86,28.78) ; UE5.94 287.6,13.06 v3(287.4,13.25) ; v3(276.29,23.65) 276.29,24.35 275.59,25.05 UE5.35 ; U18.11 219.9,12.6 220.15,12.35 v3(220.15,11.84) ; v3(113.49,139.21) 113.38,139.1 UV4.35 ; v3(291.24,19.65) 291.04,19.85 UE5.113
  TOP w0.254: v3(194.76,117.92) 194.72,117.88 UV8.N14 ; UV15.H14 v3(219.51,79.52) UV15.H13 ; UV15.R4 v3(225.11,72.32) UV15.T5 ; v3(164.85,16.96) 164.66,16.96 164.43,16.73 UN1.3 ; v3(224.31,77.12) UV15.R11 ; UV15.N14 223.52,80.34 v3(223.52,80.35) ; UV6.H13 166.49,120.4 165.93,120.4 UV7.H1 ; v3(226.71,71.52) UV15.U3 ; UV6.A12 v3(167.01,114.28) ; v3(216.57,98.47) 216.57,98.44 216.71,98.31 UV12.E14 ; UV12.R4 v3(225.11,90.36) UV12.T5 ; UV6.T5 172.59,126.68 v3(172.47,126.79) ; UV12.M5 v3(221.91,91.16) UV12.L5 ; UV8.M10 v3(190.65,119.08) UV8.L10 ; UV6.H14 UV7.H1 ; UV7.H1 v3(165.41,119.88) ; UV6.H1 v3(175.81,119.88) UV6.H2 ; v3(226.71,89.56) UV12.U3 ; v3(194.73,114.93) 194.6,114.93 194.34,114.68 UV8.U14 ; UV6.T10 v3(168.61,126.28) UV6.R11 ; UV8.C1 v3(183.45,126.28) ; v3(225.11,71.52) UV15.R3 ; UV6.U3 v3(175.01,127.88) ; UV6.K1 v3(175.81,122.28) UV6.K2 ; UV8.N1 183.41,117.88 v3(183.35,117.82) ; v3(151.41,17.22) 151.24,17.05 UE4.23 ; v3(165.47,114.09) 165.47,114.33 UV7.A1 UV6.A14 ; v3(183.33,114.07) 183.85,114.59 UV8.U1 ; UV15.M5 v3(221.91,73.12) UV15.L5 ; UV15.C14 215.15,79.96 215.15,80.44 v3(215.35,80.64) ; UV12.C1 v3(214.71,87.16) ; UV12.R11 v3(224.31,95.16) ; UV6.R1 v3(176.61,126.28) ; UV15.C12 v3(214.71,77.92) UV15.C11 ; RPH2.5 233.82,43.35 v3(234.06,43.59) 233.8,43.85 RPH2.6 ; UV15.U14 226.05,80.18 v3(226.05,80.44) ; UV8.F10 190.76,123.48 v3(190.5,123.22) ; v3(223.09,69.01) 223.11,69.03 UV15.N1 ; UV8.R3 v3(185.85,115.88) UV8.R4 ; UV8.E14 194.67,124.28 194.72,124.23 v3(194.83,124.23) ; UV6.G5 v3(172.61,119.08) UV6.F5 ; v3(12.14,25.16) 12.01,25.03 JIO.17 ; UV8.E1 183.77,124.35 v3(183.33,124.35) ; UV6.R14 UV7.R1 v3(165.41,126.28) ; UN1.13 158.66,16.73 v3(158.6,16.66) ; v3(194.65,127.88) 194.25,127.48 UV8.A14 ; RPH1.5 206.63,40.67 v3(206.48,40.52) 206.83,40.17 RPH1.6 ; v3(165.41,123.83) 165.41,123.88 UV7.N1 UV6.N14 ; UV8.H1 183.93,121.88 v3(184.24,121.57) 184.56,121.88 UV8.H2 ; UV6.U1 176.21,127.48 v3(176.62,127.88) ; UV6.D10 v3(168.61,116.68) ; UV6.R12 v3(167.81,126.28) ; v3(176.63,124.55) 176.36,124.28 UV6.N1 ; UV12.H2 v3(218.71,87.96) UV12.H1 ; UV12.R12 v3(225.11,95.96) 225.71,95.96 226.11,96.36 UV12.U12 ; v3(226.31,87.04) UV12.U1 ; UV15.K2 220.61,70.22 220.61,69.62 UV15.K1 220.71,69.03 v3(220.63,68.94) ; v3(214.71,72.32) UV15.C4 214.89,71.7 214.89,71.34 UV15.C3 ; UV12.K14 v3(221.11,97.56) UV12.K13 ; v3(224.71,87.04) UV12.R1 ; UV12.M10 v3(221.91,94.36) UV12.L10 ; v3(224.71,69.01) UV15.R1 ; UV12.G10 217.87,94.32 v3(217.87,94.38) 217.87,94.39 UV12.F10 ; UV6.E3 v3(175.01,118.28) ; UV15.L10 v3(221.91,76.32) UV15.M10 ; UV15.A12 v3(213.11,78.72) ; v3(212.86,89.05) 212.9,89.05 212.96,89.11 213.46,89.11 UV12.A3 ; v3(187.64,115.47) 187.64,115.48 UV8.T5 ; v3(100.21,135.41) 100.21,135.2 JEDP1.6 ; UV15.K13 v3(221.11,79.52) UV15.K14 ; UV12.C11 v3(214.71,95.96) UV12.C12 ; UV8.N12 v3(192.25,117.48) ; v3(215.08,98.54) 215.08,97.98 UV12.C14 ; UV6.B5 v3(173.41,115.08) ; RV149.2 211.56,70.97 212.27,70.26 212.64,70.26 v3(213.11,70.72) UV15.A3 ; v3(223.17,87.06) 223.11,87.12 UV12.N1 ; UE4.18 148.74,17.28 v3(148.91,17.45) ; v3(220.63,86.98) 220.63,87.13 220.71,87.21 UV12.K1 UV12.K2 ; UE3.23 219.18,113.8 v3(218.96,113.58) ; UV8.C11 v3(192.25,126.28) UV8.C12 ; UE4.7 148.74,21.79 v3(148.68,21.86) ; UV8.H14 v3(193.85,121.48) UV8.H13 ; v3(101.54,136.72) 101.54,135.99 JEDP1.3 ; UV8.C3 v3(185.85,126.28) ; UV6.K13 v3(166.21,122.28) UV6.K14 ; v3(214.71,94.36) UV12.B10 ; UV8.E3 v3(185.85,124.68) ; v3(215.77,120.95) 216.68,120.04 UE3.7 ; UV15.H1 v3(218.71,69.92) UV15.H2 ; UV15.C1 v3(215.11,69.01) ; JPWR1.20 v3(182.65,146.89) ; UV8.M5 v3(187.45,119.08) UV8.L5 ; UV8.E12 v3(192.25,124.68) ; v3(190.36,124.92) 190.52,125.08 UV8.D10 ; v3(214.71,76.32) UV15.B10 ; v3(223.51,77.92) UV15.N12 ; UV15.B5 v3(213.91,73.12) ; UV15.E12 v3(216.31,77.92) ; v3(224.83,98.47) 224.71,98.35 UV12.R14 ; UV6.N12 167.81,123.88 v3(167.81,123.83) ; UV12.E1 v3(216.71,87.04) ; v3(176.61,114.23) 176.61,114.28 UV6.A1 ; UV8.N3 v3(185.85,117.48) ; v3(223.51,71.52) UV15.N3 ; UV15.U12 226.11,78.32 225.71,77.92 v3(225.11,77.92) UV15.R12 ; UV8.F5 v3(187.45,123.08) UV8.G5 ; UV12.G5 v3(217.91,91.16) UV12.F5 ; UV8.A1 v3(183.45,127.88) ; UV6.E1 v3(175.81,117.48) ; PU401.4 204.8,21.97 204.71,22.06 204.5,22.06 203.99,21.55 PR406.2 ; v3(213.11,79.52) UV15.A14 ; UV6.E12 v3(167.01,117.48) ; UV8.U3 v3(185.85,115.08) ; RPH1.7 206.33,39.67 v3(206.08,39.41) 206.32,39.17 RPH1.8 ; UV6.U12 v3(167.81,127.88) ; JIO.11 11.32,28.02 12.26,28.02 v3(12.38,28.15) ; UV8.C14 v3(194.65,126.28) ; v3(183.33,120.19) 183.42,120.28 UV8.K1 UV8.K2 ; v3(174.21,115.88) UV6.C3 ; v3(174.21,115.88) UV6.C4 ; v3(174.21,115.88) 174.21,115.23 174.4,115.05 174.4,114.89 UV6.A3 ; v3(216.31,94.36) UV12.D10 ; v3(224.8,80.5) 224.8,80.34 224.71,80.25 UV15.R14 ; UV8.G10 191,122.73 v3(190.19,122.73) ; v3(225.11,77.12) UV15.T10 ; JEDP1.15 97.63,131.42 v3(97.63,132.82) 98.36,132.82 JEDP1.12 ; UV6.F10 v3(169.41,119.08) UV6.G10 ; UV8.A3 v3(185.85,127.88) ; v3(93.23,124.11) 93.09,124.25 93.09,124.64 JEDP1.31 ; UV15.F10 v3(217.91,76.32) UV15.G10 ; v3(216.6,80.5) 216.71,80.4 UV15.E14 ; UV6.M5 v3(172.46,123.48) ; v3(225.11,89.56) UV12.R3 ; UV15.F5 v3(217.91,73.12) UV15.G5 ; UV12.C4 v3(214.71,90.36) UV12.B5 ; v3(165.3,116.28) UV6.C14 ; v3(223.51,89.56) UV12.N3 ; UV6.M10 v3(169.41,123.08) UV6.L10 ; v3(190.51,127.05) 190.88,126.68 UV8.B10 ; UV12.H14 v3(219.51,97.56) UV12.H13 ; UV8.R14 194.64,116.28 v3(194.73,116.19) ; v3(225.94,98.39) 225.94,98.33 UV12.U14 ; UV6.R3 v3(174.21,126.28) UV6.R4 ; v3(184.06,146.88) 184.15,146.97 JPWR1.23 ; UE3.18 216.68,115.41 v3(217.54,116.27) ; UV15.E3 v3(216.31,70.72) ; UV12.C3 v3(214.71,89.56) ; v3(226.31,69.01) UV15.U1 ; v3(194.74,120.34) 194.72,120.34 194.66,120.28 UV8.K14 UV8.K13 ; UV6.P10 v3(169.41,124.68) ; UV6.C12 v3(167.81,115.88) ; UV15.E1 v3(216.71,69.01) ; UV8.R11 v3(191.45,115.88) UV8.T10 ; UV15.A1 v3(213.11,69.12) ; UV12.A12 v3(213.11,96.76) ; UV8.R12 v3(192.25,115.88) 192.25,115.28 192.65,114.88 UV8.U12 ; UV8.A12 v3(192.25,127.88) ; JIO.8 v3(12.4,29.53) ; UV12.N12 v3(223.51,95.96) ; UV6.L5 v3(172.41,122.68) ; UV12.N14 223.11,98 v3(223.47,98.37) ; UV15.P10 v3(224.31,76.32) ; UV12.E3 v3(216.31,88.76) ; v3(216.31,76.32) UV15.D10 ; PU601.6 v3(191.84,29.18) ; v3(98.91,134.1) 99.2,134.1 JEDP1.9 ; UV8.C4 v3(186.65,126.28) UV8.B5 ; UV12.T10 v3(225.91,95.16) ; v3(165.3,117.88) UV6.E14 ; UV6.C11 v3(168.61,115.88) UV6.B10 ; UV12.A1 v3(213.11,87.16) ; UV6.C1 v3(176.61,116.68) ; v3(224.31,94.36) UV12.P10 ; v3(213.1,98.36) 213.51,97.96 UV12.A14 ; UV6.N3 v3(174.21,124.68) ; UV6.U14 v3(165.41,127.88) ; UV8.R1 v3(183.33,116.28) ; UV8.P10 v3(190.65,116.68) ; UV12.E12 v3(216.31,95.96)
  TOP w0.305: UN2.13 264.21,8.74 v3(263.97,8.98) 264.23,9.24 UN2.12 ; UN2.10 264.12,10.24 v3(263.86,10.5) ; Q33.4 123.69,9.8 123.97,10.09 v3(123.97,10.37) ; UN2.5 268.13,10.74 268.38,10.98 v3(268.38,11.18)
  TOP w0.356: CV105.2 191.9,80.42 v3(191.9,79.58) ; v3(123.97,10.37) 123.97,10.71 124.09,10.84 124.7,10.84 124.99,11.12 Q33.1 ; Q32.4 131.69,13.79 132.07,14.18 v3(132.07,14.33) ; CE36.2 285.69,29.61 v3(284.86,28.78) ; v3(114.11,10.39) 113.59,9.87 Q39.4
  TOP w0.381: UU5.3 v3(13.78,38.24) ; v3(218.32,43.09) 218.4,43.01 218.4,42.36 CH64.2 ; v3(295.33,21.08) 295.33,21.45 295.14,21.64 DE2.1 ; RE82.1 294.77,14.85 294.13,14.85 294,14.99 UE7.3 ; v3(84.36,63.06) 84.68,63.39 UC1.3 ; CH56.2 217.43,34.39 217.74,34.69 217.74,34.83 217.89,34.98 v3(217.89,35) ; PQ710.4 63.66,48.51 62.36,49.81 PQ710.1 61.61,49.81 v3(61.34,50.08)
  TOP w0.406: Q36.1 126.26,15.42 126.9,16.07 v3(127.29,16.07) ; v3(128.73,14.29) 128.32,13.88 Q34.4 ; Q37.4 116.95,9.77 116.85,9.87 v3(116.85,10.35) ; Q38.1 122.89,15.81 122.64,16.07 v3(122.38,16.07) ; v3(136.21,16.07) 136.21,15.88 136.35,15.74 Q30.1 ; v3(119.99,10.34) 119.99,10.04 120.32,9.71 Q35.4 ; v3(134.69,12.85) 134.69,13.12 Q30.4 ; v3(137.04,10.35) 137.15,10.24 Q31.4 ; Q28.1 139.72,15.82 139.46,16.07 v3(139.45,16.07) ; UH3.3 220.32,20.52 v3(220.42,20.42) ; UH2.3 214.01,21.7 213.53,21.21 v3(212.94,21.21) ; Q35.1 121.62,11.18 121.76,11.04 v3(121.76,10.37) ; Q31.1 138.45,12.07 138.21,12.31 138.21,12.76 138.18,12.79 v3(138.18,12.79) 138.42,13.03 Q28.4 ; v3(124.61,14.19) 124.61,13.88 124.96,13.54 Q36.4 ; v3(114.72,10.39) 114.72,10.73 114.89,10.9 Q39.1 ; v3(132.65,16.09) 132.99,15.76 Q32.1 ; Q34.1 129.62,15.73 129.23,16.12 v3(129.23,16.07) ; Q29.4 141.53,10.05 141.99,10.5 v3(142.35,10.5) 142.83,10.98 Q29.1 ; Q38.4 v3(121.59,14.17)
  TOP w0.432: QM2.1 294.22,26.56 v3(294.05,26.38) ; v3(291.54,28.77) 291.55,28.76 QM2.4
  TOP w0.457: CH34.2 215.19,37.94 v3(215.19,37.61) ; CV169.2 165.66,132.16 165.29,132.53 164.38,132.53 v3(164.15,132.3) ; v3(187.5,95.28) 187.17,95.6 PC1002.2 ; QV24.3 199.68,132.52 199.68,132.21 v3(199.3,131.83) ; RM62.1 163.5,129.15 162.59,128.23 CV229.2 ; v3(91.96,90.03) 91.43,90.03 RC41.1 RC43.1 ; RC37.2 91.57,87.91 v3(92.07,88.41) ; RH69.2 234.41,31.29 v3(234.49,31.29) ; v3(218.58,36.62) 218.58,37.28 CH35.2 ; CV223.2 174.15,131.61 v3(173.84,131.3) ; v3(167.9,131.24) 167.63,130.98 RV190.2 ; CA4.1 17.86,21 v3(17.38,21.48) ; CH21.2 221.54,35.99 CH27.2 ; v3(169.83,131.24) 170.33,130.74 CV302.2 ; v3(91.88,85.42) 91.7,85.24 RC36.1 ; v3(160.32,40.08) 160.59,39.82 UV20.3
  TOP w0.483: CH63.2 221.23,43.99 221.52,44.28 v3(221.86,44.28)
  TOP w0.508: JIO.43 12.03,12.63 v3(12.13,12.73) ; v3(218.58,36.62) 218.98,36.23 CH57.2 ; v3(173.5,95.28) 173.3,95.48 CV208.2 173.39,95.95 PC934.2 ; RC35.2 118.56,108.69 QC1.3 v3(118.79,109.91) ; v3(168.38,70.35) 168.42,70.39 RV38.1 ; v3(320.23,40.29) 320.23,39.92 CL7.2 ; v3(208.32,20.14) 208.32,19.89 208.66,19.55 PC405.2 ; PC978.2 v3(111.65,84.75) ; CE29.2 CE42.2 v3(286.5,8.71) ; CV103.2 v3(192.4,93.58) ; CV123.2 168.6,89.9 v3(168.6,89.58) 168.79,89.38 CV96.2 ; v3(190.63,31.9) 190.45,31.9 189.97,31.43 PC629.2 ; CV142.2 184.4,78.17 v3(184.5,78.28) ; RC42.1 RC37.2 ; RE37.2 RE27.2 154.84,20.17 154.84,21.41 v3(154.83,21.43) ; v3(313.84,27.54) CL12.2 CL11.2 ; CC30.2 89.55,65.57 v3(90.55,66.58) ; CV224.2 180.28,131.73 v3(180.28,132.2) ; CL25.2 324.17,36.08 v3(324.17,36.6) ; CV172.2 CV171.2 v3(176.72,132.32) ; CA14.1 22.47,20.93 22.47,22.39 22.85,22.77 CA30.2 24.63,22.77 v3(24.64,22.76) ; v3(175.6,102.38) 175.74,102.38 176.41,101.72 CV84.2 ; PC409.2 204.01,19.98 v3(204.61,20.58) ; v3(45.34,43.97) 44.64,43.27 PC710.2 ; RV118.2 172.11,130.97 v3(172.38,131.24) ; RE29.2 RE30.2 150.95,23.41 150.56,23.01 v3(150.56,22.75) ; CH69.2 225.03,40.38 v3(224.52,39.87) 224.5,39.85 224.5,39.5 CH68.2 ; CH42.2 221.99,34.45 v3(222.54,35) ; v3(213.12,38.51) 212.78,38.18 CH30.2 ; v3(228.43,84.86) CV252.2 CV182.2 ; CH49.2 223.52,34.66 v3(223.86,35) 223.86,35.28 224.26,35.67 CH28.2 ; PC112.2 21.34,36.54 v3(20.96,36.92) ; v3(228.84,35.51) 229.31,35.51 229.71,35.9 CH38.2 ; RN30.1 214.64,9.36 215.12,8.89 v3(215.12,7.65) ; v3(156.69,71.36) RV224.1 ; v3(182.15,20.37) 182.73,20.37 183,20.64 PR624.1 ; v3(155.12,80.67) 154.93,80.86 RV69.2 ; v3(184.5,84.28) 184.59,84.36 PC999.2 ; RN19.2 161.99,22.07 161.74,22.33 v3(160.96,22.33) ; v3(9.96,36.12) 9.95,36.13 JIO.41 ; v3(294.27,18.19) 294.2,18.26 CE50.2 ; v3(175.46,91.27) 175.5,91.31 CV380.2 ; v3(157.34,76.06) 157.33,76.05 RV216.1 ; RV202.2 CV305.2 v3(196.95,128.58) ; v3(157.34,77.57) 156.99,77.57 RV221.1 ; PR700.1 32.88,39.28 v3(33.28,38.89) ; PC997.2 v3(102.04,90.9) ; JIO.42 8.28,10.64 v3(8.28,11.65) ; CC28.2 91.76,61.58 91.52,61.34 91.39,61.34 ; RV228.1 v3(157.24,73.27) ; v3(217.19,39.98) 217.19,39.29 CH33.2 ; v3(14.84,35.12) CU28.2 CU29.2 ; CV408.2 160.58,40.34 v3(160.32,40.08) ; v3(193.02,10.9) 193.11,10.99 JTRONF.13 ; v3(172.91,52.61) 172.6,52.29 PC944.2 ; CA69.2 30.24,9.51 v3(30.44,9.31) ; PR103.1 20.59,26.96 20.83,27.21 v3(21.15,27.21) ; CV136.2 173.32,100.78 v3(173.2,100.78) ; v3(210.23,21.43) 210.81,22.01 CH6.2 ; v3(314.48,37.02) 313.48,37.02 CL23.2 ; v3(173.14,131.28) 173.14,131.88 CV225.2 ; v3(63.83,38.27) 63.92,38.36 PC8.2 PC9.2 ; C261.2 60.64,9.04 61.03,9.43 v3(61.03,9.74) ; CV143.2 185.27,73.64 v3(185.2,73.58) ; CH50.2 229.37,32 v3(229.07,32) ; RH161.2 211.27,25.67 210.91,25.31 v3(210.91,25.06) 210.75,24.89 CH11.2 ; v3(100.04,125.01) 100.04,125.63 RV14.2 ; v3(70.33,19.27) 70.07,19 70.07,18.06 70.33,17.8 PQ4.3 ; v3(329.88,78.02) CL33.2 CL35.2 ; CV242.2 202.52,127.5 v3(202.5,127.48) ; C10.2 C11.2 CD41.2 v3(144.03,20.17) ; RV134.2 CV308.2 191.64,130 v3(191.52,129.88) ; PC964.2 185.68,87.46 v3(185.5,87.28) ; v3(186.31,48.74) 186.55,48.5 PC621.2 ; Q40.3 308.83,38.88 v3(308.33,39.37) ; v3(131.64,96.17) 131.92,95.88 RC55.2 ; v3(147.58,26.13) 147.11,25.66 Q41.3 ; v3(89.66,93.25) 90.11,92.8 RC39.1 ; C270.2 C269.2 213.97,14.15 213.63,14.15 v3(213.62,14.14) ; v3(155.15,10.9) 155.15,10.91 155.2,10.95 155.2,12.18 155.56,12.55 CN8.2 ; v3(224.32,46.47) 224.8,46.95 RH39.1 ; v3(106.11,80.8) 105.86,80.55 CC33.2 ; CN35.2 CN38.2 v3(197.63,6.06) ; RV232.1 157.23,74.22 v3(157.25,74.2) ; CA5.2 18.25,23.8 18.82,23.8 v3(20.2,25.17) 19.59,25.78 PR105.1 ; v3(12.23,34.27) 11.89,33.93 JIO.44 ; v3(221.66,22.81) 221.66,22.71 222.42,21.95 CH7.2 ; v3(211.24,48.48) 211.62,48.86 CH23.2 ; v3(213.91,56.16) 213.65,55.91 CH70.2 ; RE66.1 274.45,8.51 274.73,8.23 v3(274.96,8.23) 275.07,8.23 275.4,8.56 CE28.2 ; CV247.2 v3(181.21,116.37) ; v3(47.69,43.11) 48.87,43.11 49.81,42.17 49.81,40.38 PC716.1 ; v3(333.42,19.59) 332.95,19.12 CR5.2 331.94,19.12 CR8.2 ; CV17.2 97.72,123.18 v3(98.35,123.18) ; QE14.3 155.81,132.98 v3(156.6,133.76) ; PR104.2 v3(21.21,31.03) ; CH47.2 215.77,46.43 216,46.19 v3(216.36,46.19) ; v3(139.96,45.37) 140.15,45.18 CD39.2 ; v3(241.44,39.09) 241.43,39.11 CE55.1 ; CV368.2 153.39,61.86 CV369.2 v3(154.95,61.86) ; CH58.2 217.65,40.77 v3(217.1,41.32) ; CN1.2 161.55,28.53 v3(160.92,28.53) ; CM28.1 155.48,22.18 v3(155.48,22.67) ; CL36.1 CL39.2 v3(332.87,78.07) ; RN22.2 159.32,22.3 v3(159.31,22.32) ; v3(36.83,37.32) PR715.2 ; RN31.1 234.63,8.43 v3(235.18,7.89) ; RH109.2 228.39,38.53 228.53,38.39 v3(229.15,38.39) 229.15,39.11 CH66.2 ; CH37.2 229.76,21.6 v3(230.6,21.6) 230.6,22.54 CH1.1 ; RE72.1 CE38.2 296.05,24.26 v3(296.34,23.97) ; CH45.2 222.39,42.53 v3(222.84,42.98) ; PR28.1 70.77,22.95 PQ8.3 70.77,21.71 71.02,21.47 v3(71.47,21.47) ; CN18.2 267.17,14.11 v3(266.91,14.38) ; v3(155.96,31.71) 155.26,31.02 PC207.1 ; PC500.1 141.19,129.76 PR521.2 141.6,130.15 v3(141.6,130.42) ; v3(229.08,40.01) 229.14,40.01 229.36,39.78 CH46.2 229.82,39.87 CH67.2 ; CH24.2 225.16,42.59 v3(224.73,43.02) ; RL4.1 v3(312.1,30.63) ; CH29.2 210.92,46.18 v3(211.17,46.43) ; CV167.2 164.72,130.61 v3(164.68,130.65) 164.63,130.7 RM75.1 ; CV206.2 189.17,88.95 v3(188.5,88.28) 189.04,87.74 CV365.2 ; CL19.2 CL18.2 v3(317.04,27.08) ; PC101.2 v3(18.35,28.88) ; v3(170.8,100.78) 171.23,100.34 PC909.2 ; v3(181.21,114.59) CV246.2 180.55,114.52 CV226.2 ; CC37.2 114.56,78.86 v3(114.54,78.84) ; RN35.1 166.64,8.33 v3(166.5,8.47) ; PC724.2 v3(61.34,50.08) ; v3(20.96,33.68) PR106.1 ; CD43.2 CD3.2 143.92,38.33 CD4.2 v3(144.54,39.21) ; v3(178.48,22.99) PC617.2 ; PC719.2 37.53,34.66 PR719.2 37.3,34.68 36.83,35.14 v3(36.83,35.4) ; v3(142.58,27.07) 142.38,26.88 C16.2 ; v3(283.96,31.52) 283.85,31.41 CE34.2 CE45.2 ; CV149.2 CV394.2 172.26,78.1 v3(172.5,78.34) ; v3(109.1,80.99) 108.27,80.16 CC34.2 ; v3(156.16,40.34) 156.58,39.92 RV241.1 ; PC991.2 106.1,96.28 v3(105.98,96.17) ; v3(190.15,11.84) 190.15,12.15 191.01,13.01 JTRONF.11 ; CV187.2 CV254.2 225.74,84.69 v3(225.89,84.85) ; v3(174.98,28.07) 174.07,28.07 173.79,27.79 RM31.2 PC614.2 174.73,27.41 PC618.2 ; v3(187.61,72.79) 187.71,72.89 CV92.2 ; v3(41.72,32.29) 41.53,32.29 41.3,32.51 PC720.1 41.29,32.91 PC718.1 ; JLOGO1.13 215.43,125.23 v3(215.58,125.38) ; v3(186.5,78.28) 186.19,77.97 CV209.2 ; CE58.2 259.98,23.68 v3(260.43,24.13) ; v3(168.9,35.71) 169.07,35.54 CM26.2 ; v3(89.17,120.35) 89.17,120.93 JEDP1.42 ; RC18.1 v3(88.78,96.8) ; PC1011.2 172.41,50.23 v3(172.91,50.23) ; CE25.2 154.27,17.01 v3(154.27,16.55) ; PC502.2 105.67,119.6 106.06,119.2 106.06,117.83 105.35,117.12 105.35,115.6 v3(104.52,114.77) ; PC214.2 150.01,25 PC213.2 v3(150.03,24.32) ; v3(295.68,15.09) RE82.1 ; CV138.2 190.13,97.71 v3(190.2,97.78) ; v3(73.22,20.75) 73.4,20.58 RD14.2 ; CV245.2 177.66,132.15 v3(177.85,132.34) ; v3(22.29,33.68) PR107.2 ; v3(99.39,16.14) 99.88,15.65 C14.2 99.94,14.81 C15.2 ; CV228.2 v3(178.62,114.59) ; PC408.2 205.68,16.84 205.36,16.52 v3(205.17,16.52) ; CV106.2 188.16,95.77 v3(188.58,96.2) ; v3(324.79,29.85) 324.5,29.55 CL6.2 ; YL1.4 v3(322.52,26.09) ; v3(72.81,28.82) 72.36,29.27 PD2.1 ; v3(103.24,78.91) 103.44,79.11 CC42.2 ; RV196.2 159.12,132.86 v3(160.03,133.76) 160.1,133.83 RM82.1 ; v3(270.79,23.13) 270.79,23.14 CE37.2 ; CE27.2 156.94,138.97 156.4,138.43 v3(156.05,138.43) ; v3(169.4,86.38) 169.45,86.33 CV126.2 ; PC993.2 103.68,98.03 v3(103.82,98.17) ; v3(190.58,144.29) 189.65,143.36 JPWR1.36 ; CD42.2 119.32,36.21 120.15,36.21 v3(120.29,36.35) ; PR649.1 v3(180.03,32.12) ; PC13.1 294.15,12.83 v3(294.58,12.4) 295.07,12.89 PR26.1 ; RV215.1 v3(156.66,70.41) ; CV135.2 189.17,78.56 CV204.2 188.8,78.57 v3(188.5,78.28) 187.98,77.76 CV215.2 ; Q2413.1 82.22,12.9 82.56,13.25 83.11,13.25 83.52,13.66 Q2413.4 83.86,14.65 83.86,16.02 v3(84.05,16.21) ; CV237.2 179.47,131.9 v3(179.05,132.32) 178.55,131.83 CV244.2 ; v3(323.97,21) 323.67,20.7 CR7.2 ; v3(156.75,67.76) 156.49,68.01 RV226.1 155.89,67.62 155.42,67.15 RV49.2 ; JTRONF.12 191.81,12.32 191.31,11.82 190.88,11.82 v3(190.87,11.83) ; CN6.2 v3(160.66,23.66) ; CL8.1 v3(321.71,29.8) ; v3(107.57,109.06) 106.97,109.06 PC926.2 ; JLOGO1.14 v3(225.2,127.22) ; v3(154.46,136.89) 154.46,136.39 RM69.1 ; PC994.2 101.34,98.16 v3(101.4,98.22) ; CV291.2 216.83,64.36 v3(216.35,64.36) 215.84,64.87 CV180.2 ; v3(182.4,98.68) 182.96,99.23 CV144.2 ; PQ2.3 282.8,31.57 v3(281.83,31.57) 281.82,31.58 281.82,32.64 PR9.1 ; v3(177.73,144.4) 177.23,144.4 176.65,143.82 JPWR1.33 ; v3(164.81,134.48) 165.08,134.75 RM23.1 ; CE48.2 v3(294.07,23.98) ; Q2412.1 79.81,12.94 80.08,13.21 80.55,13.21 81.11,13.77 Q2412.4 81.11,15.85 v3(80.75,16.21) ; v3(223.98,119.72) 223.92,119.79 RE42.2 RE44.2 ; PQ610.3 180.65,18.79 180.95,19.09 v3(180.95,20.37) 180.95,20.82 PC613.2 ; CR13.2 v3(301.68,30.36) ; CH32.2 219.24,38.72 v3(219.24,38.25) 219.24,37.96 219.48,37.72 CH19.2 ; CL5.2 324.36,30.44 v3(324.8,30.89) 324.36,31.33 RL3.2 ; PC627.2 185.55,28.51 v3(185.76,28.73) ; CV288.2 214.62,64.88 v3(215.14,64.36) ; CR3.1 v3(328.3,24.87) ; CC38.2 113.54,78.72 v3(113.57,78.69) ; PC937.2 104.74,109.12 v3(104.08,109.12) ; v3(179.6,100.78) 179.36,100.78 178.82,100.23 CV91.2 ; RN23.2 165.18,11.5 v3(165.18,10.9) ; RH54.1 233.31,46.71 v3(233.36,46.76) ; PC1006.2 183.53,83.31 v3(183.5,83.28) ; CV367.2 183.01,77.76 v3(182.5,78.28) ; v3(167.6,86.38) 167.6,85.91 CV117.2 ; QV2.3 82.34,112.44 v3(82.68,112.78) ; JLOGO1.12 215.1,122.69 v3(215.52,122.26) 215.9,122.64 JLOGO1.11 ; PR406.2 203.68,21 v3(203.62,20.93) ; v3(170.45,22.42) CM15.2 170.45,23.98 CM12.2 ; R3.2 v3(91.44,107.09) ; CE32.1 279.53,30.52 v3(279.53,31.51) 279.53,32.06 279.31,32.28 PD1.1 ; v3(178.98,46.89) 179.34,46.53 PC615.2 ; v3(213.17,35.4) 212.83,35.4 212.52,35.09 CH31.2 ; CL16.2 324.3,33.75 v3(324.74,34.19) 324.3,34.63 CL17.2 ; v3(178.95,125.73) CV173.2 CV248.2 ; Q2411.1 89.08,12.75 89.51,13.18 89.99,13.18 v3(90.36,13.55) 90.38,13.57 Q2411.4 ; JTRONF.9 189.41,14.84 188.96,15.28 v3(187.77,15.28) ; v3(177.36,22.99) 176.78,23.57 PR602.2 PC616.2 175.74,22.62 PR618.2 ; JPWR1.31 v3(169.03,144.21) ; CV170.2 161.23,123.48 v3(160.61,122.86) ; v3(182.76,11.83) 182.45,12.13 JTRONF.14 ; v3(222.54,39.87) 222.54,40.4 CH39.2 ; v3(158.75,10.85) RN20.2 RN18.2 ; PC721.2 v3(47.94,36.35) ; v3(178.95,120.42) 178.95,119.85 179.28,119.52 RV116.2 RV132.2 ; v3(164.04,130.01) 164.04,129.82 RM62.1 ; RM73.2 152.55,138.01 v3(152.12,138.44) 151.63,137.95 RM78.1 ; v3(183.81,17.5) 183.16,18.15 PR631.2 PC626.2 ; v3(155.13,130.99) 155.09,131.03 SW2.6 ; CV250.2 180.58,121.57 181.61,121.57 v3(181.74,121.69) ; PC960.2 179.08,77.69 v3(178.5,78.28) ; RV153.2 155.36,101.42 v3(155.36,100.8) 155.45,100.71 RV57.1 ; CC31.2 84.32,63.02 v3(84.36,63.06) ; v3(179.45,95.38) 179.44,95.39 PC928.2 ; CR2.2 v3(330.87,16.55) ; JEDP1.43 85.77,121.22 v3(85.77,120.13) ; CC36.2 118.62,79.08 v3(118.69,79.02) ; C27.2 179.9,16.1 179.34,16.1 179.21,16.23 v3(179.21,16.24) ; CH48.2 226.57,33.8 v3(226.57,33.32) ; CV287.2 CV184.2 222,64.66 v3(222.13,64.54) ; CV122.2 171.07,90.85 v3(171.5,91.28) ; PC977.2 v3(109.93,84.75) ; CV181.2 223.95,84.41 224.11,84.56 v3(224.11,84.85) ; JLOGO1.7 219.1,122.47 v3(219.23,122.33) ; v3(211.08,83.4) 210.63,82.95 RV115.2 ; v3(160.58,120.63) 160.77,120.44 RV120.2 ; v3(33.19,14.95) 33.63,14.51 CA33.2 34.15,14.52 CA29.2 ; RV223.1 v3(156.67,69.22) ; PH500.2 v3(122.8,122.52) ; CL27.2 v3(321.5,87.51) ; v3(184.36,144.44) 184.15,144.23 JPWR1.34 ; v3(330.46,31.21) 330.96,31.71 CL42.2 ; CL34.1 CL38.1 v3(335.03,78.03) ; CC46.2 v3(126.81,110.16) CC45.2 ; JEDP1.44 102.61,139.95 101.96,140.6 101.96,141.37 102.3,141.71 v3(102.59,141.71) ; v3(291.29,10.4) 290.91,10.4 CE43.2 ; 43.18,7.85 43.17,7.86 JSPK.5 ; CU26.2 v3(15.1,40.6) ; CV240.2 CV241.2 CV214.2 183.97,131.71 v3(183.97,132.2) ; v3(172.34,98.33) 171.97,97.95 PC961.2 ; PC406.2 206,27.76 v3(206.63,28.4) ; PC709.2 38.78,41.33 38.48,41.62 v3(38.04,41.62) 37.72,41.3 PC707.1 ; 91.39,61.34 v3(91.45,61.28) ; 91.39,61.34 90.74,61.99 RC30.2 ; CL4.2 CL3.2 v3(312.12,31.84) ; CC35.2 121.03,78.82 v3(121.12,78.73) ; UE9.2 250.76,43.52 250.33,43.09 250.33,42.5 v3(250.33,42.49) ; CM13.2 174.56,17.91 v3(174.96,17.52) 174.96,17.03 CM14.2 ; CL20.2 CL21.2 312.51,33.61 312.02,33.11 CL22.2 310.57,33.11 v3(310.49,33.19) ; RE31.2 v3(223.84,117.02) ; v3(153.55,78.6) 153.56,78.62 RV68.1 ; v3(215.28,45.05) 215.77,45.54 CH22.2 ; v3(290.07,31.46) 290.07,31.27 289.57,30.77 RE83.2 ; v3(234.77,44.36) 234.89,44.25 CE56.2 ; v3(230.42,98.57) 230.04,98.19 CV259.2 ; CA31.2 34.18,10.87 CA32.2 34.55,10.86 v3(34.94,11.25) ; v3(213.63,11.51) 213.83,11.71 213.83,12.74 C268.2 ; CV375.2 81.68,119.7 80.84,118.86 CV14.2 80.84,115.76 v3(80.88,115.72) ; PC939.2 96.99,108.93 v3(96.52,108.93) ; RV151.2 213.55,64.86 v3(213.08,64.39) ; v3(104.42,135.52) 104.42,135.8 JEDP1.41 ; RE81.2 292.25,12.41 v3(292.24,12.4) ; CH18.2 CH36.2 243.68,36.54 v3(243.82,36.68) ; CV255.2 213.24,84.41 213.91,85.08 v3(213.98,85.08) ; v3(176.5,90.28) 176.52,90.3 PC931.2 ; UL2.2 v3(328.23,33.68) ; v3(221.22,41.5) 221.2,41.48 CH61.2 ; CE31.1 CE41.2 v3(287.53,31.52) ; RH135.1 RH67.1 206.87,34.19 206.38,34.19 v3(206.19,34) ; CE24.2 CM20.2 223.92,116.08 v3(223.94,116.11) ; PC212.2 155.45,25.11 v3(155.89,24.67) ; v3(199.39,126.01) 199.02,126.38 RV136.2 ; v3(318.16,27.21) 318.65,27.69 YL1.2 ; CN24.2 CN26.2 223.74,6.95 v3(224.45,7.66) ; CR6.2 321.65,21.22 v3(321.38,20.94) ; v3(321.76,68.61) 322.21,69.06 QL3.3 ; CV227.2 v3(178.62,116.37) ; LE2.1 v3(278.16,6.35) ; v3(71.53,14.98) PC12.2 ; v3(143.22,27.12) 143.22,26.25 142.75,25.78 C13.2 C12.2 141.45,25.5 141.04,25.08 RD16.1 ; v3(100.59,109.12) 99.93,109.12 PC938.2 ; JPWR1.32 v3(191.78,144.24) ; v3(171.5,85.28) 171.45,85.33 RV533.1 ; CH43.2 224.53,38.25 v3(224.52,38.25) 224.52,38 224.05,37.53 CH65.2 ; v3(324.68,32.79) CL24.2 ; CV110.2 190.68,75.25 v3(190.57,75.36) ; v3(190.69,15.28) 190.21,14.8 JTRONF.10 ; PR730.1 66.35,49.67 v3(66.98,49.67) ; RV198.2 v3(193.42,130.05) ; RH57.1 225.47,47.86 v3(225.21,48.12) 224.8,48.52 CH40.2 ; CE44.2 276.1,30.67 v3(276.54,31.12) 276.99,30.67 RE75.2 ; v3(214.84,85.05) 214.84,84.36 CV315.2 CV186.2 ; CL37.2 CL32.1 v3(326.01,78.32) ; v3(115.25,110.33) RC52.1 RC38.1 RC40.1 v3(113.48,110.33) ; v3(192.34,89.56) 191.6,90.31 CV203.2 ; PC903.2 v3(111.33,93.04) ; v3(171.5,89.28) 171.5,89.39 170.91,89.98 CV80.2 ; v3(160.03,132.37) 160.57,132.91 CV154.2 ; PC992.2 108.45,96.56 v3(108.84,96.17) ; CH55.2 219.96,35.12 CH44.2 220.11,35 v3(220.61,35) ; PC622.2 v3(181.09,32.12) ; CL9.1 318.95,29.29 319.41,29.75 v3(319.67,29.75) ; CV118.2 168.74,92.12 v3(168.6,91.98) ; RV36.2 100.87,127.58 CV19.2 101.66,127.61 v3(101.86,127.41) ; v3(101.06,90.28) PC998.2 ; CH54.2 219.27,30.13 v3(219.44,30.31) ; v3(332.79,15.89) 332.79,16.41 CR1.2 ; v3(178.02,11.43) 178.02,12 RN34.1 ; v3(294.71,21.06) 294.71,20.6 294.98,20.32 CE40.1 CE51.2 ; CL28.2 v3(325.38,75.52) ; PC711.1 40.57,41.86 v3(40.57,41.49) ; CL31.2 CL29.2 323.85,73.42 v3(323.38,72.95) ; CV156.2 CV201.2 v3(178.95,127.57) ; v3(175.5,87.28) 175.47,87.25 PC1007.2 ; CH20.2 221.24,36.64 v3(221.22,36.62) 221.27,36.62 221.56,36.33 CH27.2 ; CD24.2 76.27,15.71 v3(75.76,15.2) ; v3(184.69,132.2) 185.17,131.71 CV243.2 CV249.2 ; RD13.1 CD25.2 73.87,24.91 v3(74.17,25.21) ; v3(220.92,64.04) 220.1,64.86 CV311.2 RV204.2 ; PC996.2 v3(103.82,91.02) ; CV290.2 216.81,83.89 v3(216.59,84.11) ; CE23.2 v3(225,119.61) ; CL13.2 v3(312.96,27.54) ; v3(20.96,37.68) PR116.2 ; v3(45.16,17.19) 45.16,17.97 44.73,18.4 JSPK.6 ; RN16.1 RN21.2 162.37,11.39 162.3,11.32 v3(162.3,10.91) ; v3(306.9,39.78) 307.29,39.38 R176.2 ; CH2.1 v3(233.06,25.2) ; CH101.2 CH100.2 v3(335.45,35.18) ; v3(284.89,8) 284.42,8.47 CE46.2 ; v3(172.42,144.43) 171.95,144.43 171.15,143.63 JPWR1.35 ; CN7.2 v3(157.55,20.13) ; RV171.2 218.28,83.11 v3(218.28,82.22) ; CV168.2 161.14,124.36 v3(160.53,124.97) ; RV66.2 v3(156.94,72.32) ; CN3.2 161.01,25.49 v3(160.63,25.11) 161.15,24.59 CN4.2 ; CR4.2 RR2.1 v3(332.74,14.57) ; PD3.1 72.37,25.34 v3(72.82,25.8) ; CE52.2 v3(295.99,12.37) ; PC995.2 v3(105.72,91.15) ; v3(155.48,65.23) 155.44,65.27 RV51.2 ; CH72.2 228.65,48.77 v3(228.74,48.68) ; v3(101.23,87.08) PC902.2 ; CN22.2 CN20.2 247.78,6.06 v3(248.03,6.31) ; v3(92.74,96.49) 92.42,96.8 CC29.2 ; v3(46.8,40.98) 46.8,40.48 47.14,40.14 PR711.2 ; CH25.2 221.22,40.45 v3(221.22,39.87) ; CE30.2 v3(294.05,26.38) ; CH41.2 221.88,37.76 v3(221.88,38.25) ; v3(175.1,7.66) 174.39,6.95 CN41.2 CN40.2 ; PC900.2 v3(106.83,94.94) ; CH71.2 217.22,46.45 v3(217.81,46.45) 217.81,47.54 CH59.2 ; v3(300.62,24.28) CR12.2 ; CV178.2 229.19,94.59 v3(228.86,94.26) ; RH4.2 231.73,30.09 232.49,29.33 CH51.2 232.49,28.84 232.79,28.54 CH52.2 v3(232.79,27.33) ; CV147.2 v3(180.5,78.18) ; PC976.2 v3(108.22,84.75) ; CV427.2 CV428.2 v3(106.2,143.41) ; v3(160.67,127.61) 159.63,127.61 159.21,128.03 159.21,128.12 QV23.3
  GND1 w0.203: 142.93,143.54 JDP1.13 ; JDP1.13 143.97,143.08 ; JDP1.13 142.83,143.08 ; H20.1 82.15,102.71 ; H20.1 84.5,100.36 ; H20.1 80.43,98.63 ; H20.1 83.88,98.63 ; H20.1 79.8,100.36 ; H20.1 82.15,98.01 ; H20.1 83.88,102.08 ; H20.1 80.43,102.08 ; H16.1 205.05,120.01 ; H16.1 200.97,121.74 ; H16.1 205.67,121.74 ; H16.1 203.32,124.09 ; H16.1 203.32,119.39 ; H16.1 205.05,123.46 ; H16.1 201.59,120.01 ; H16.1 201.59,123.46 ; H24.1 201.36,28.29 ; H24.1 201.36,25.27 ; H24.1 198.34,28.29 ; H24.1 199.85,28.82 ; H24.1 197.81,26.78 ; H24.1 199.85,24.73 ; H24.1 198.34,25.27 ; H24.1 201.9,26.78 ; 130.26,138.38 JHDMI1.20 ; JHDMI1.20 130.26,139.68 ; JHDMI1.20 131.25,138.38 ; JHDMI1.20 132.24,140.97 ; JHDMI1.20 132.24,139.68 ; JHDMI1.20 132.24,138.38 ; JCDRA.48 196.72,149.35 ; JCDRA.48 194.78,149.35 ; JCDRA.48 196.72,147.78 ; JCDRA.48 194.78,147.78 ; JCDRA.48 194.78,146.2 ; JCDRA.48 195.75,149.35 ; JCDRA.48 196.72,146.2 ; JCDRA.48 195.75,146.2 ; JCR.23 327.28,39.4 ; JCR.23 324.33,39.4 ; JCR.23 324.33,40.88 ; JCR.23 325.8,40.88 ; JCR.23 327.28,40.14 ; JCR.23 324.33,40.14 ; JCR.23 325.8,39.4 ; JCR.23 327.28,40.88 ; 325.32,2.11 H13.1 ; H13.1 325.32,4.84 ; H13.1 324.85,3.48 ; H13.1 326.69,1.64 ; H13.1 328.53,3.48 ; H13.1 328.05,4.84 ; H13.1 328.05,2.11 ; H13.1 326.69,5.32 ; 124.01,139.89 JHDMI1.11 ; JHDMI1.11 124.99,139.89 ; JHDMI1.11 124.99,140.86 ; JHDMI1.11 124.01,140.86 ; JHDMI1.11 124.5,139.78 ; 199.01,136.73 H2.1 ; H2.1 203.99,138.93 ; H2.1 203.99,141.12 ; H2.1 199.01,138.93 ; H2.1 201.5,141.12 ; H2.1 203.99,136.73 ; H2.1 199.01,141.12 ; H2.1 201.5,136.73 ; JUSB2.11 332.59,57.26 ; JUSB2.11 332.59,58.1 ; JUSB2.11 329.01,57.26 ; JUSB2.11 330.8,58.94 ; JUSB2.11 329.01,58.94 ; JUSB2.11 330.8,57.26 ; JUSB2.11 332.59,58.94 ; JUSB2.11 329.01,58.1 ; 336.45,59.56 JUSB1.13 ; JUSB1.13 338.04,60.4 ; JUSB1.13 334.86,61.24 ; JUSB1.13 338.04,61.24 ; JUSB1.13 334.86,60.4 ; JUSB1.13 338.04,59.56 ; JUSB1.13 336.45,61.24 ; JUSB1.13 334.86,59.56 ; 80.43,74.08 H21.1 ; H21.1 83.88,74.08 ; H21.1 79.8,72.36 ; H21.1 84.5,72.36 ; H21.1 83.88,70.63 ; H21.1 82.15,70.01 ; H21.1 80.43,70.63 ; H21.1 82.15,74.71 ; H5.1 87.46,56.84 ; H5.1 86.1,56.36 ; H5.1 84.73,56.84 ; H5.1 84.25,58.21 ; H5.1 87.46,59.57 ; H5.1 86.1,60.05 ; H5.1 87.94,58.21 ; H5.1 84.73,59.57 ; 119.4,139.18 JHDMI1.2 ; JHDMI1.2 119.51,139.66 ; JHDMI1.2 120.49,138.69 ; JHDMI1.2 119.51,138.69 ; JHDMI1.2 120,139.77 ; JHDMI1.2 120.49,139.66 ; JHDMI1.2 120,138.58 ; JCDRA.49 164.22,147.78 ; JCDRA.49 164.22,146.2 ; JCDRA.49 163.25,146.2 ; JCDRA.49 162.28,147.78 ; JCDRA.49 162.28,146.2 ; JCDRA.49 164.22,149.35 ; JCDRA.49 162.28,149.35 ; JCDRA.49 163.25,149.35 ; JUSB1.11 332.59,76.4 ; JUSB1.11 330.8,75.56 ; JUSB1.11 329.01,77.24 ; JUSB1.11 330.8,77.24 ; JUSB1.11 332.59,75.56 ; JUSB1.11 329.01,76.4 ; JUSB1.11 332.59,77.24 ; JUSB1.11 329.01,75.56 ; 146.53,8.64 H8.1 ; H8.1 149.74,7.28 ; H8.1 146.53,5.91 ; H8.1 147.9,5.43 ; H8.1 149.27,8.64 ; H8.1 147.9,9.12 ; H8.1 149.27,5.91 ; H8.1 146.06,7.28 ; JUSB1.12 338.04,77.24 ; JUSB1.12 334.86,76.4 ; JUSB1.12 334.86,77.24 ; JUSB1.12 338.04,75.56 ; JUSB1.12 336.45,75.56 ; JUSB1.12 334.86,75.56 ; JUSB1.12 338.04,76.4 ; JUSB1.12 336.45,77.24 ; 65.8,6.93 H9.1 ; H9.1 67.64,8.78 ; H9.1 67.17,7.41 ; H9.1 63.96,8.78 ; H9.1 64.43,7.41 ; H9.1 67.17,10.14 ; H9.1 65.8,10.62 ; H9.1 64.43,10.14 ; 115.76,140.97 JHDMI1.23 ; JHDMI1.23 117.74,139.68 ; JHDMI1.23 117.74,138.38 ; JHDMI1.23 115.76,139.68 ; JHDMI1.23 115.76,138.38 ; JHDMI1.23 116.75,138.38 ; 195.75,141.6 JCDRA.47 ; JCDRA.47 196.72,143.18 ; JCDRA.47 196.72,141.6 ; JCDRA.47 194.78,141.6 ; JCDRA.47 194.78,143.18 ; JCDRA.47 194.78,144.75 ; JCDRA.47 195.75,144.75 ; JCDRA.47 196.72,144.75 ; H15.1 331.54,9.21 ; H15.1 333.73,7.01 ; H15.1 329.92,8.63 ; H15.1 329.34,7.01 ; H15.1 333.15,5.4 ; H15.1 331.54,4.81 ; H15.1 329.92,5.4 ; H15.1 333.15,8.63 ; JUSB1.10 332.59,61.24 ; JUSB1.10 329.01,60.4 ; JUSB1.10 332.59,59.56 ; JUSB1.10 329.01,61.24 ; JUSB1.10 329.01,59.56 ; JUSB1.10 330.8,59.56 ; JUSB1.10 332.59,60.4 ; JUSB1.10 330.8,61.24 ; JHDMI1.8 123,139.77 ; JHDMI1.8 123.49,138.69 ; JHDMI1.8 123,138.58 ; JHDMI1.8 122.51,139.66 ; JHDMI1.8 123.49,139.66 ; JHDMI1.8 122.51,138.69 ; JUSB2.10 330.8,42.94 ; JUSB2.10 330.8,41.26 ; JUSB2.10 332.59,42.94 ; JUSB2.10 329.01,42.94 ; JUSB2.10 329.01,42.1 ; JUSB2.10 329.01,41.26 ; JUSB2.10 332.59,42.1 ; JUSB2.10 332.59,41.26 ; 136.11,144.28 JDP1.23 ; JDP1.23 137.69,144.28 ; JDP1.23 136.9,142.98 ; JDP1.23 136.9,145.57 ; JDP1.23 137.69,142.98 ; JDP1.23 136.11,145.57 ; JDP1.23 136.11,142.98 ; 326.06,54.26 JUSB2.4 ; JUSB2.4 326.06,52.95 ; JUSB2.4 326.72,54.44 ; JUSB2.4 325.88,53.6 ; JUSB2.4 326.72,52.76 ; JUSB2.4 327.38,52.95 ; 200.13,146.29 H11.1 ; H11.1 202.87,143.56 ; H11.1 201.5,146.77 ; H11.1 201.5,143.08 ; H11.1 200.13,143.56 ; H11.1 202.87,146.29 ; H11.1 199.66,144.93 ; H11.1 203.34,144.93 ; JHDMI1.21 133.99,148.08 ; JHDMI1.21 133.99,149.37 ; JHDMI1.21 133,146.78 ; JHDMI1.21 133,149.37 ; JHDMI1.21 133.99,146.78 ; JUSB2.12 338.04,57.26 ; JUSB2.12 336.45,57.26 ; JUSB2.12 336.45,58.94 ; JUSB2.12 338.04,58.1 ; JUSB2.12 338.04,58.94 ; JUSB2.12 334.86,58.94 ; JUSB2.12 334.86,58.1 ; JUSB2.12 334.86,57.26 ; 147.31,142.07 JDP1.21 ; JDP1.21 148.89,142.07 ; JDP1.21 148.1,142.07 ; JDP1.21 148.89,139.48 ; JDP1.21 147.31,139.48 ; JDP1.21 148.1,139.48 ; JDP1.21 148.89,140.78 ; JDP1.21 147.31,140.78 ; 146.55,66.58 H12.1 ; H12.1 147.92,63.37 ; H12.1 149.76,65.22 ; H12.1 147.92,67.06 ; H12.1 149.29,63.85 ; H12.1 149.29,66.58 ; H12.1 146.08,65.22 ; H12.1 146.55,63.85 ; JDP1.24 137.69,139.48 ; JDP1.24 136.9,142.07 ; JDP1.24 136.11,140.78 ; JDP1.24 136.11,139.48 ; JDP1.24 137.69,140.78 ; JDP1.24 136.9,139.48 ; JDP1.24 136.11,142.07 ; JDP1.24 137.69,142.07 ; JDP1.19 145.77,143.08 ; JDP1.19 145.67,143.54 ; JDP1.19 144.73,142.61 ; JDP1.19 144.63,143.08 ; JUSB2.13 338.04,42.94 ; JUSB2.13 338.04,41.26 ; JUSB2.13 334.86,41.26 ; JUSB2.13 336.45,41.26 ; JUSB2.13 338.04,42.1 ; JUSB2.13 334.86,42.94 ; JUSB2.13 334.86,42.1 ; JUSB2.13 336.45,42.94 ; 328.22,49.26 JUSB2.7 ; JUSB2.7 327.38,50.1 ; JUSB2.7 327.56,50.76 ; JUSB2.7 327.56,49.45 ; JUSB2.7 328.22,50.94 ; 163.25,141.6 JCDRA.50 ; JCDRA.50 163.25,144.75 ; JCDRA.50 162.28,144.75 ; JCDRA.50 164.22,141.6 ; JCDRA.50 162.28,143.18 ; JCDRA.50 164.22,144.75 ; JCDRA.50 164.22,143.18 ; JCDRA.50 162.28,141.6 ; JLAN.14 337.17,92.02 ; JLAN.14 337.17,91.09 ; JLAN.14 337.17,91.55 ; JHDMI1.5 121.99,140.86 ; JHDMI1.5 121.01,140.86 ; JHDMI1.5 121.01,139.89 ; JHDMI1.5 121.99,139.89 ; JHDMI1.5 121.5,139.78 ; 114.01,149.37 JHDMI1.22 ; JHDMI1.22 115,149.37 ; JHDMI1.22 115,146.78 ; JHDMI1.22 114.01,146.78 ; JHDMI1.22 114.01,148.08 ; 254.98,7.41 H14.1 ; H14.1 257.72,10.14 ; H14.1 258.19,8.78 ; H14.1 254.98,10.14 ; H14.1 256.35,6.93 ; H14.1 257.72,7.41 ; H14.1 256.35,10.62 ; H14.1 254.51,8.78 ; JDP1.22 148.89,145.57 ; JDP1.22 148.1,145.57 ; JDP1.22 148.1,142.98 ; JDP1.22 147.31,145.57 ; JDP1.22 147.31,144.28 ; JDP1.22 147.31,142.98 ; JDP1.22 148.89,144.28 ; JDP1.22 148.89,142.98 ; 151.97,121.74 H17.1 ; H17.1 156.67,121.74 ; H17.1 152.6,120.01 ; H17.1 156.05,120.01 ; H17.1 156.05,123.46 ; H17.1 152.6,123.46 ; H17.1 154.32,124.09 ; H17.1 154.32,119.39 ; H10.1 104.34,146.78 ; H10.1 103.87,145.41 ; H10.1 101.13,145.41 ; H10.1 103.87,148.14 ; H10.1 101.13,148.14 ; H10.1 102.5,144.93 ; H10.1 100.66,146.78 ; H10.1 102.5,148.62 ; 138.2,70.38 H19.1 ; H19.1 142.9,70.38 ; H19.1 140.55,68.03 ; H19.1 138.82,72.1 ; H19.1 140.55,72.73 ; H19.1 142.28,72.1 ; H19.1 142.28,68.65 ; H19.1 138.82,68.65 ; 236.65,58.49 H6.1 ; H6.1 239.86,57.12 ; H6.1 239.86,59.85 ; H6.1 238.5,60.33 ; H6.1 237.13,57.12 ; H6.1 237.13,59.85 ; H6.1 240.34,58.49 ; H6.1 238.5,56.64 ; H18.1 142.9,102.38 ; H18.1 140.55,104.73 ; H18.1 140.55,100.03 ; H18.1 142.28,104.1 ; H18.1 138.2,102.38 ; H18.1 138.82,104.1 ; H18.1 138.82,100.65 ; H18.1 142.28,100.65 ; 202.1,58.01 H22.1 ; H22.1 205.55,61.46 ; H22.1 202.1,61.46 ; H22.1 205.55,58.01 ; H22.1 206.17,59.74 ; H22.1 203.82,57.39 ; H22.1 201.47,59.74 ; H22.1 203.82,62.09 ; 324.33,11.58 JCR.24 ; JCR.24 325.8,11.58 ; JCR.24 327.28,10.1 ; JCR.24 327.28,10.84 ; JCR.24 324.33,10.1 ; JCR.24 325.8,10.1 ; JCR.24 327.28,11.58 ; JCR.24 324.33,10.84 ; 139.23,143.08 JDP1.1 ; JDP1.1 139.33,143.54 ; JDP1.1 140.37,143.08 ; JDP1.1 140.27,142.61 ; JDP1.7 142.07,143.54 ; JDP1.7 141.03,143.08 ; JDP1.7 141.13,142.61 ; JDP1.7 142.17,143.08 ; 326.06,71.25 JUSB1.4 ; JUSB1.4 326.06,72.56 ; JUSB1.4 325.88,71.9 ; JUSB1.4 327.38,71.25 ; JUSB1.4 326.72,72.74 ; JUSB1.4 326.72,71.06 ; H4.1 5.34,38.78 ; H4.1 3.5,40.62 ; H4.1 4.87,40.14 ; H4.1 3.5,36.93 ; H4.1 4.87,37.41 ; H4.1 2.13,37.41 ; H4.1 2.13,40.14 ; H4.1 1.66,38.78 ; 127.01,140.86 JHDMI1.17 ; JHDMI1.17 127.01,139.89 ; JHDMI1.17 127.5,139.78 ; JHDMI1.17 127.99,140.86 ; JHDMI1.17 127.99,139.89 ; JUSB1.7 328.22,69.24 ; JUSB1.7 327.38,68.4 ; JUSB1.7 327.56,69.06 ; JUSB1.7 328.22,67.56 ; JUSB1.7 327.56,67.75
  IN1 w0.508: v3(18.49,13.81) 18.42,13.81 17.31,12.7 14.49,12.7 13.93,12.14 12.49,12.14 12.13,12.5 v3(12.13,12.73) 10.56,11.15 8.66,11.15 8.28,11.53 v3(8.28,11.65)
  VCC w0.203: 122.51,138.69 JHDMI1.8 ; JHDMI1.8 123,139.77 ; JHDMI1.8 122.51,139.66 ; JHDMI1.8 123.49,139.66 ; JHDMI1.8 123,138.58 ; JHDMI1.8 123.49,138.69 ; JUSB1.13 336.45,61.24 ; JUSB1.13 338.04,59.56 ; JUSB1.13 336.45,59.56 ; JUSB1.13 338.04,60.4 ; JUSB1.13 334.86,60.4 ; JUSB1.13 338.04,61.24 ; JUSB1.13 334.86,61.24 ; JUSB1.13 334.86,59.56 ; JHDMI1.2 120.49,138.69 ; JHDMI1.2 120,138.58 ; JHDMI1.2 119.4,139.18 ; JHDMI1.2 120.49,139.66 ; JHDMI1.2 120,139.77 ; JHDMI1.2 119.51,139.66 ; JHDMI1.2 119.51,138.69 ; 114.01,149.37 JHDMI1.22 ; JHDMI1.22 115,146.78 ; JHDMI1.22 114.01,146.78 ; JHDMI1.22 114.01,148.08 ; JHDMI1.22 115,149.37 ; H13.1 328.53,3.48 ; H13.1 326.69,1.64 ; H13.1 326.69,5.32 ; H13.1 325.32,4.84 ; H13.1 328.05,2.11 ; H13.1 325.32,2.11 ; H13.1 324.85,3.48 ; H13.1 328.05,4.84 ; 330.8,59.56 JUSB1.10 ; JUSB1.10 332.59,59.56 ; JUSB1.10 332.59,60.4 ; JUSB1.10 329.01,60.4 ; JUSB1.10 329.01,59.56 ; JUSB1.10 330.8,61.24 ; JUSB1.10 329.01,61.24 ; JUSB1.10 332.59,61.24 ; 162.28,147.78 JCDRA.49 ; JCDRA.49 164.22,146.2 ; JCDRA.49 164.22,147.78 ; JCDRA.49 163.25,146.2 ; JCDRA.49 164.22,149.35 ; JCDRA.49 162.28,146.2 ; JCDRA.49 163.25,149.35 ; JCDRA.49 162.28,149.35 ; JUSB1.4 326.72,72.74 ; JUSB1.4 326.06,72.56 ; JUSB1.4 326.06,71.25 ; JUSB1.4 326.72,71.06 ; JUSB1.4 327.38,71.25 ; JUSB1.4 325.88,71.9 ; 147.31,142.98 JDP1.22 ; JDP1.22 147.31,145.57 ; JDP1.22 148.89,142.98 ; JDP1.22 148.1,145.57 ; JDP1.22 147.31,144.28 ; JDP1.22 148.1,142.98 ; JDP1.22 148.89,145.57 ; JDP1.22 148.89,144.28 ; 330.8,75.56 JUSB1.11 ; JUSB1.11 332.59,77.24 ; JUSB1.11 332.59,75.56 ; JUSB1.11 329.01,76.4 ; JUSB1.11 329.01,77.24 ; JUSB1.11 329.01,75.56 ; JUSB1.11 332.59,76.4 ; JUSB1.11 330.8,77.24 ; JDP1.7 142.07,143.54 ; JDP1.7 141.03,143.08 ; JDP1.7 141.13,142.61 ; JDP1.7 142.17,143.08 ; JUSB2.13 336.45,42.94 ; JUSB2.13 338.04,42.94 ; JUSB2.13 334.86,41.26 ; JUSB2.13 336.45,41.26 ; JUSB2.13 338.04,41.26 ; JUSB2.13 334.86,42.1 ; JUSB2.13 338.04,42.1 ; JUSB2.13 334.86,42.94 ; 324.33,10.84 JCR.24 ; JCR.24 327.28,10.1 ; JCR.24 327.28,11.58 ; JCR.24 325.8,11.58 ; JCR.24 327.28,10.84 ; JCR.24 324.33,10.1 ; JCR.24 325.8,10.1 ; JCR.24 324.33,11.58 ; 142.83,143.08 JDP1.13 ; JDP1.13 143.97,143.08 ; JDP1.13 142.93,143.54 ; JUSB2.11 330.8,58.94 ; JUSB2.11 329.01,57.26 ; JUSB2.11 332.59,58.94 ; JUSB2.11 330.8,57.26 ; JUSB2.11 332.59,57.26 ; JUSB2.11 329.01,58.1 ; JUSB2.11 329.01,58.94 ; JUSB2.11 332.59,58.1 ; 136.11,144.28 JDP1.23 ; JDP1.23 136.9,145.57 ; JDP1.23 137.69,144.28 ; JDP1.23 137.69,142.98 ; JDP1.23 136.11,142.98 ; JDP1.23 136.9,142.98 ; JDP1.23 136.11,145.57 ; JUSB2.10 330.8,42.94 ; JUSB2.10 332.59,42.94 ; JUSB2.10 332.59,42.1 ; JUSB2.10 329.01,42.94 ; JUSB2.10 330.8,41.26 ; JUSB2.10 329.01,42.1 ; JUSB2.10 332.59,41.26 ; JUSB2.10 329.01,41.26 ; H5.1 87.46,56.84 ; H5.1 84.25,58.21 ; H5.1 86.1,60.05 ; H5.1 86.1,56.36 ; H5.1 84.73,56.84 ; H5.1 87.94,58.21 ; H5.1 87.46,59.57 ; H5.1 84.73,59.57 ; 162.28,143.18 JCDRA.50 ; JCDRA.50 162.28,141.6 ; JCDRA.50 162.28,144.75 ; JCDRA.50 163.25,141.6 ; JCDRA.50 164.22,141.6 ; JCDRA.50 164.22,143.18 ; JCDRA.50 164.22,144.75 ; JCDRA.50 163.25,144.75 ; JCDRA.47 195.75,144.75 ; JCDRA.47 194.78,144.75 ; JCDRA.47 194.78,143.18 ; JCDRA.47 196.72,144.75 ; JCDRA.47 194.78,141.6 ; JCDRA.47 196.72,143.18 ; JCDRA.47 195.75,141.6 ; JCDRA.47 196.72,141.6 ; 334.86,57.26 JUSB2.12 ; JUSB2.12 334.86,58.94 ; JUSB2.12 338.04,58.1 ; JUSB2.12 336.45,57.26 ; JUSB2.12 338.04,57.26 ; JUSB2.12 334.86,58.1 ; JUSB2.12 336.45,58.94 ; JUSB2.12 338.04,58.94 ; JDP1.24 137.69,140.78 ; JDP1.24 136.9,139.48 ; JDP1.24 136.11,140.78 ; JDP1.24 137.69,142.07 ; JDP1.24 136.11,139.48 ; JDP1.24 137.69,139.48 ; JDP1.24 136.9,142.07 ; JDP1.24 136.11,142.07 ; 200.13,143.56 H11.1 ; H11.1 201.5,146.77 ; H11.1 201.5,143.08 ; H11.1 200.13,146.29 ; H11.1 203.34,144.93 ; H11.1 202.87,146.29 ; H11.1 199.66,144.93 ; H11.1 202.87,143.56 ; JUSB1.12 338.04,75.56 ; JUSB1.12 336.45,75.56 ; JUSB1.12 334.86,76.4 ; JUSB1.12 338.04,76.4 ; JUSB1.12 334.86,77.24 ; JUSB1.12 336.45,77.24 ; JUSB1.12 338.04,77.24 ; JUSB1.12 334.86,75.56 ; JCDRA.48 196.72,149.35 ; JCDRA.48 195.75,149.35 ; JCDRA.48 194.78,147.78 ; JCDRA.48 194.78,146.2 ; JCDRA.48 196.72,147.78 ; JCDRA.48 195.75,146.2 ; JCDRA.48 196.72,146.2 ; JCDRA.48 194.78,149.35 ; JDP1.21 148.89,140.78 ; JDP1.21 148.89,142.07 ; JDP1.21 148.1,142.07 ; JDP1.21 148.1,139.48 ; JDP1.21 148.89,139.48 ; JDP1.21 147.31,142.07 ; JDP1.21 147.31,139.48 ; JDP1.21 147.31,140.78 ; JHDMI1.17 127.99,140.86 ; JHDMI1.17 127.01,140.86 ; JHDMI1.17 127.01,139.89 ; JHDMI1.17 127.99,139.89 ; JHDMI1.17 127.5,139.78 ; 327.56,69.06 JUSB1.7 ; JUSB1.7 327.38,68.4 ; JUSB1.7 327.56,67.75 ; JUSB1.7 328.22,67.56 ; JUSB1.7 328.22,69.24 ; 115.76,138.38 JHDMI1.23 ; JHDMI1.23 117.74,138.38 ; JHDMI1.23 115.76,140.97 ; JHDMI1.23 117.74,139.68 ; JHDMI1.23 115.76,139.68 ; JHDMI1.23 116.75,138.38 ; 124.01,139.89 JHDMI1.11 ; JHDMI1.11 124.01,140.86 ; JHDMI1.11 124.99,139.89 ; JHDMI1.11 124.99,140.86 ; JHDMI1.11 124.5,139.78 ; JHDMI1.21 133.99,148.08 ; JHDMI1.21 133.99,146.78 ; JHDMI1.21 133.99,149.37 ; JHDMI1.21 133,146.78 ; JHDMI1.21 133,149.37 ; 121.5,139.78 JHDMI1.5 ; JHDMI1.5 121.99,139.89 ; JHDMI1.5 121.01,140.86 ; JHDMI1.5 121.01,139.89 ; JHDMI1.5 121.99,140.86 ; JDP1.19 145.67,143.54 ; JDP1.19 144.73,142.61 ; JDP1.19 145.77,143.08 ; JDP1.19 144.63,143.08 ; H10.1 103.87,145.41 ; H10.1 102.5,148.62 ; H10.1 101.13,145.41 ; H10.1 104.34,146.78 ; H10.1 100.66,146.78 ; H10.1 101.13,148.14 ; H10.1 102.5,144.93 ; H10.1 103.87,148.14 ; JHDMI1.20 132.24,140.97 ; JHDMI1.20 132.24,138.38 ; JHDMI1.20 130.26,138.38 ; JHDMI1.20 132.24,139.68 ; JHDMI1.20 131.25,138.38 ; JHDMI1.20 130.26,139.68 ; 327.56,49.45 JUSB2.7 ; JUSB2.7 328.22,49.26 ; JUSB2.7 328.22,50.94 ; JUSB2.7 327.56,50.76 ; JUSB2.7 327.38,50.1 ; H15.1 331.54,9.21 ; H15.1 329.92,8.63 ; H15.1 333.15,8.63 ; H15.1 333.73,7.01 ; H15.1 331.54,4.81 ; H15.1 329.92,5.4 ; H15.1 333.15,5.4 ; H15.1 329.34,7.01 ; 326.06,54.26 JUSB2.4 ; JUSB2.4 326.72,54.44 ; JUSB2.4 326.72,52.76 ; JUSB2.4 326.06,52.95 ; JUSB2.4 327.38,52.95 ; JUSB2.4 325.88,53.6 ; JLAN.14 337.17,92.02 ; JLAN.14 337.17,91.09 ; JLAN.14 337.17,91.55 ; 325.8,39.4 JCR.23 ; JCR.23 327.28,40.88 ; JCR.23 327.28,40.14 ; JCR.23 327.28,39.4 ; JCR.23 324.33,39.4 ; JCR.23 324.33,40.14 ; JCR.23 325.8,40.88 ; JCR.23 324.33,40.88 ; 139.33,143.54 JDP1.1 ; JDP1.1 139.23,143.08 ; JDP1.1 140.37,143.08 ; JDP1.1 140.27,142.61
  IN4 w0.508: v3(323.38,72.95) 323.85,73.42 323.85,76.21 322.71,77.36 322.71,85.96 321.5,87.16 v3(321.5,87.51)
  GND2 w0.203: 160.09,58.01 H23.1 ; H23.1 164.17,59.74 ; H23.1 163.55,61.46 ; H23.1 161.82,57.39 ; H23.1 163.55,58.01 ; H23.1 161.82,62.09 ; H23.1 159.47,59.74 ; H23.1 160.09,61.46 ; 201.59,120.01 H16.1 ; H16.1 205.05,123.46 ; H16.1 205.67,121.74 ; H16.1 200.97,121.74 ; H16.1 203.32,119.39 ; H16.1 205.05,120.01 ; H16.1 201.59,123.46 ; H16.1 203.32,124.09 ; 127.01,139.89 JHDMI1.17 ; JHDMI1.17 127.5,139.78 ; JHDMI1.17 127.99,139.89 ; JHDMI1.17 127.99,140.86 ; JHDMI1.17 127.01,140.86 ; 139.33,143.54 JDP1.1 ; JDP1.1 140.27,142.61 ; JDP1.1 139.23,143.08 ; JDP1.1 140.37,143.08 ; 327.38,50.1 JUSB2.7 ; JUSB2.7 328.22,50.94 ; JUSB2.7 327.56,50.76 ; JUSB2.7 328.22,49.26 ; JUSB2.7 327.56,49.45 ; JUSB1.12 336.45,77.24 ; JUSB1.12 338.04,76.4 ; JUSB1.12 334.86,75.56 ; JUSB1.12 338.04,75.56 ; JUSB1.12 334.86,77.24 ; JUSB1.12 338.04,77.24 ; JUSB1.12 334.86,76.4 ; JUSB1.12 336.45,75.56 ; 329.92,8.63 H15.1 ; H15.1 333.15,5.4 ; H15.1 333.15,8.63 ; H15.1 329.92,5.4 ; H15.1 333.73,7.01 ; H15.1 329.34,7.01 ; H15.1 331.54,4.81 ; H15.1 331.54,9.21 ; 101.13,148.14 H10.1 ; H10.1 103.87,148.14 ; H10.1 101.13,145.41 ; H10.1 103.87,145.41 ; H10.1 102.5,148.62 ; H10.1 104.34,146.78 ; H10.1 102.5,144.93 ; H10.1 100.66,146.78 ; 146.53,8.64 H8.1 ; H8.1 146.06,7.28 ; H8.1 147.9,5.43 ; H8.1 149.27,8.64 ; H8.1 149.27,5.91 ; H8.1 146.53,5.91 ; H8.1 147.9,9.12 ; H8.1 149.74,7.28 ; 151.97,121.74 H17.1 ; H17.1 154.32,124.09 ; H17.1 152.6,123.46 ; H17.1 152.6,120.01 ; H17.1 156.67,121.74 ; H17.1 156.05,120.01 ; H17.1 154.32,119.39 ; H17.1 156.05,123.46 ; 119.51,139.66 JHDMI1.2 ; JHDMI1.2 120,139.77 ; JHDMI1.2 120.49,138.69 ; JHDMI1.2 119.51,138.69 ; JHDMI1.2 120,138.58 ; JHDMI1.2 119.4,139.18 ; JHDMI1.2 120.49,139.66 ; 330.8,59.56 JUSB1.10 ; JUSB1.10 329.01,59.56 ; JUSB1.10 332.59,60.4 ; JUSB1.10 330.8,61.24 ; JUSB1.10 332.59,61.24 ; JUSB1.10 332.59,59.56 ; JUSB1.10 329.01,61.24 ; JUSB1.10 329.01,60.4 ; 194.78,147.78 JCDRA.48 ; JCDRA.48 195.75,149.35 ; JCDRA.48 196.72,147.78 ; JCDRA.48 194.78,149.35 ; JCDRA.48 195.75,146.2 ; JCDRA.48 196.72,149.35 ; JCDRA.48 194.78,146.2 ; JCDRA.48 196.72,146.2 ; 198.34,25.27 H24.1 ; H24.1 201.9,26.78 ; H24.1 197.81,26.78 ; H24.1 199.85,28.82 ; H24.1 198.34,28.29 ; H24.1 199.85,24.73 ; H24.1 201.36,25.27 ; H24.1 201.36,28.29 ; 122.51,138.69 JHDMI1.8 ; JHDMI1.8 123,138.58 ; JHDMI1.8 122.51,139.66 ; JHDMI1.8 123.49,139.66 ; JHDMI1.8 123,139.77 ; JHDMI1.8 123.49,138.69 ; JDP1.7 142.17,143.08 ; JDP1.7 141.13,142.61 ; JDP1.7 141.03,143.08 ; JDP1.7 142.07,143.54 ; JDP1.24 137.69,139.48 ; JDP1.24 137.69,140.78 ; JDP1.24 136.11,140.78 ; JDP1.24 136.9,139.48 ; JDP1.24 136.9,142.07 ; JDP1.24 136.11,142.07 ; JDP1.24 136.11,139.48 ; JDP1.24 137.69,142.07 ; JCDRA.49 164.22,147.78 ; JCDRA.49 163.25,146.2 ; JCDRA.49 164.22,149.35 ; JCDRA.49 162.28,147.78 ; JCDRA.49 162.28,149.35 ; JCDRA.49 164.22,146.2 ; JCDRA.49 163.25,149.35 ; JCDRA.49 162.28,146.2 ; JUSB2.12 338.04,58.94 ; JUSB2.12 334.86,58.1 ; JUSB2.12 338.04,57.26 ; JUSB2.12 334.86,58.94 ; JUSB2.12 334.86,57.26 ; JUSB2.12 336.45,57.26 ; JUSB2.12 336.45,58.94 ; JUSB2.12 338.04,58.1 ; 142.93,143.54 JDP1.13 ; JDP1.13 143.97,143.08 ; JDP1.13 142.83,143.08 ; 84.73,59.57 H5.1 ; H5.1 87.94,58.21 ; H5.1 86.1,56.36 ; H5.1 84.25,58.21 ; H5.1 87.46,56.84 ; H5.1 84.73,56.84 ; H5.1 86.1,60.05 ; H5.1 87.46,59.57 ; H20.1 83.88,102.08 ; H20.1 83.88,98.63 ; H20.1 82.15,98.01 ; H20.1 80.43,102.08 ; H20.1 82.15,102.71 ; H20.1 79.8,100.36 ; H20.1 80.43,98.63 ; H20.1 84.5,100.36 ; 199.01,141.12 H2.1 ; H2.1 199.01,138.93 ; H2.1 201.5,136.73 ; H2.1 203.99,136.73 ; H2.1 201.5,141.12 ; H2.1 203.99,141.12 ; H2.1 199.01,136.73 ; H2.1 203.99,138.93 ; 121.5,139.78 JHDMI1.5 ; JHDMI1.5 121.01,140.86 ; JHDMI1.5 121.99,140.86 ; JHDMI1.5 121.01,139.89 ; JHDMI1.5 121.99,139.89 ; 324.85,3.48 H13.1 ; H13.1 326.69,5.32 ; H13.1 328.05,2.11 ; H13.1 328.05,4.84 ; H13.1 326.69,1.64 ; H13.1 325.32,4.84 ; H13.1 325.32,2.11 ; H13.1 328.53,3.48 ; H18.1 142.9,102.38 ; H18.1 140.55,104.73 ; H18.1 140.55,100.03 ; H18.1 138.2,102.38 ; H18.1 138.82,100.65 ; H18.1 142.28,104.1 ; H18.1 138.82,104.1 ; H18.1 142.28,100.65 ; JHDMI1.11 124.99,139.89 ; JHDMI1.11 124.01,139.89 ; JHDMI1.11 124.01,140.86 ; JHDMI1.11 124.5,139.78 ; JHDMI1.11 124.99,140.86 ; JDP1.21 148.89,139.48 ; JDP1.21 148.1,142.07 ; JDP1.21 148.89,142.07 ; JDP1.21 147.31,140.78 ; JDP1.21 147.31,139.48 ; JDP1.21 148.89,140.78 ; JDP1.21 147.31,142.07 ; JDP1.21 148.1,139.48 ; 238.5,56.64 H6.1 ; H6.1 240.34,58.49 ; H6.1 237.13,57.12 ; H6.1 236.65,58.49 ; H6.1 237.13,59.85 ; H6.1 239.86,59.85 ; H6.1 239.86,57.12 ; H6.1 238.5,60.33 ; 325.88,53.6 JUSB2.4 ; JUSB2.4 327.38,52.95 ; JUSB2.4 326.06,52.95 ; JUSB2.4 326.72,54.44 ; JUSB2.4 326.72,52.76 ; JUSB2.4 326.06,54.26 ; JUSB1.11 330.8,77.24 ; JUSB1.11 329.01,76.4 ; JUSB1.11 332.59,77.24 ; JUSB1.11 332.59,76.4 ; JUSB1.11 332.59,75.56 ; JUSB1.11 330.8,75.56 ; JUSB1.11 329.01,77.24 ; JUSB1.11 329.01,75.56 ; H14.1 256.35,10.62 ; H14.1 258.19,8.78 ; H14.1 254.51,8.78 ; H14.1 254.98,10.14 ; H14.1 254.98,7.41 ; H14.1 257.72,10.14 ; H14.1 256.35,6.93 ; H14.1 257.72,7.41 ; JCR.23 325.8,40.88 ; JCR.23 325.8,39.4 ; JCR.23 327.28,39.4 ; JCR.23 324.33,40.14 ; JCR.23 327.28,40.14 ; JCR.23 327.28,40.88 ; JCR.23 324.33,39.4 ; JCR.23 324.33,40.88 ; 136.11,142.98 JDP1.23 ; JDP1.23 136.11,145.57 ; JDP1.23 137.69,142.98 ; JDP1.23 136.11,144.28 ; JDP1.23 136.9,145.57 ; JDP1.23 136.9,142.98 ; JDP1.23 137.69,144.28 ; JHDMI1.20 132.24,138.38 ; JHDMI1.20 130.26,139.68 ; JHDMI1.20 132.24,140.97 ; JHDMI1.20 132.24,139.68 ; JHDMI1.20 131.25,138.38 ; JHDMI1.20 130.26,138.38 ; JUSB2.11 330.8,58.94 ; JUSB2.11 329.01,58.1 ; JUSB2.11 332.59,58.94 ; JUSB2.11 329.01,57.26 ; JUSB2.11 329.01,58.94 ; JUSB2.11 330.8,57.26 ; JUSB2.11 332.59,58.1 ; JUSB2.11 332.59,57.26 ; 199.66,144.93 H11.1 ; H11.1 201.5,143.08 ; H11.1 202.87,146.29 ; H11.1 200.13,146.29 ; H11.1 202.87,143.56 ; H11.1 203.34,144.93 ; H11.1 201.5,146.77 ; H11.1 200.13,143.56 ; JDP1.22 148.89,142.98 ; JDP1.22 148.89,145.57 ; JDP1.22 147.31,142.98 ; JDP1.22 148.1,145.57 ; JDP1.22 148.1,142.98 ; JDP1.22 147.31,144.28 ; JDP1.22 147.31,145.57 ; JDP1.22 148.89,144.28 ; 194.78,143.18 JCDRA.47 ; JCDRA.47 196.72,143.18 ; JCDRA.47 195.75,141.6 ; JCDRA.47 194.78,141.6 ; JCDRA.47 195.75,144.75 ; JCDRA.47 196.72,144.75 ; JCDRA.47 194.78,144.75 ; JCDRA.47 196.72,141.6 ; H4.1 4.87,40.14 ; H4.1 3.5,40.62 ; H4.1 2.13,37.41 ; H4.1 2.13,40.14 ; H4.1 5.34,38.78 ; H4.1 4.87,37.41 ; H4.1 1.66,38.78 ; H4.1 3.5,36.93 ; JCDRA.50 164.22,144.75 ; JCDRA.50 162.28,144.75 ; JCDRA.50 162.28,143.18 ; JCDRA.50 163.25,141.6 ; JCDRA.50 164.22,141.6 ; JCDRA.50 162.28,141.6 ; JCDRA.50 164.22,143.18 ; JCDRA.50 163.25,144.75 ; 325.88,71.9 JUSB1.4 ; JUSB1.4 327.38,71.25 ; JUSB1.4 326.06,71.25 ; JUSB1.4 326.06,72.56 ; JUSB1.4 326.72,72.74 ; JUSB1.4 326.72,71.06 ; H21.1 83.88,74.08 ; H21.1 80.43,70.63 ; H21.1 82.15,70.01 ; H21.1 80.43,74.08 ; H21.1 79.8,72.36 ; H21.1 82.15,74.71 ; H21.1 83.88,70.63 ; H21.1 84.5,72.36 ; H22.1 206.17,59.74 ; H22.1 203.82,62.09 ; H22.1 203.82,57.39 ; H22.1 205.55,61.46 ; H22.1 205.55,58.01 ; H22.1 202.1,61.46 ; H22.1 202.1,58.01 ; H22.1 201.47,59.74 ; 140.55,68.03 H19.1 ; H19.1 142.9,70.38 ; H19.1 140.55,72.73 ; H19.1 142.28,68.65 ; H19.1 142.28,72.1 ; H19.1 138.82,68.65 ; H19.1 138.2,70.38 ; H19.1 138.82,72.1 ; 115.76,138.38 JHDMI1.23 ; JHDMI1.23 115.76,140.97 ; JHDMI1.23 117.74,138.38 ; JHDMI1.23 117.74,139.68 ; JHDMI1.23 115.76,139.68 ; JHDMI1.23 116.75,138.38 ; 146.55,63.85 H12.1 ; H12.1 147.92,67.06 ; H12.1 147.92,63.37 ; H12.1 149.29,63.85 ; H12.1 149.29,66.58 ; H12.1 146.08,65.22 ; H12.1 146.55,66.58 ; H12.1 149.76,65.22 ; 114.01,148.08 JHDMI1.22 ; JHDMI1.22 115,149.37 ; JHDMI1.22 114.01,146.78 ; JHDMI1.22 114.01,149.37 ; JHDMI1.22 115,146.78 ; JUSB2.10 330.8,42.94 ; JUSB2.10 332.59,41.26 ; JUSB2.10 329.01,41.26 ; JUSB2.10 329.01,42.94 ; JUSB2.10 330.8,41.26 ; JUSB2.10 329.01,42.1 ; JUSB2.10 332.59,42.1 ; JUSB2.10 332.59,42.94 ; 327.56,67.75 JUSB1.7 ; JUSB1.7 327.38,68.4 ; JUSB1.7 328.22,69.24 ; JUSB1.7 328.22,67.56 ; JUSB1.7 327.56,69.06 ; 324.33,10.84 JCR.24 ; JCR.24 325.8,10.1 ; JCR.24 324.33,10.1 ; JCR.24 327.28,10.84 ; JCR.24 327.28,10.1 ; JCR.24 324.33,11.58 ; JCR.24 327.28,11.58 ; JCR.24 325.8,11.58 ; 334.86,42.94 JUSB2.13 ; JUSB2.13 336.45,42.94 ; JUSB2.13 334.86,41.26 ; JUSB2.13 334.86,42.1 ; JUSB2.13 338.04,41.26 ; JUSB2.13 338.04,42.1 ; JUSB2.13 338.04,42.94 ; JUSB2.13 336.45,41.26 ; 64.43,10.14 H9.1 ; H9.1 64.43,7.41 ; H9.1 63.96,8.78 ; H9.1 65.8,10.62 ; H9.1 67.64,8.78 ; H9.1 65.8,6.93 ; H9.1 67.17,10.14 ; H9.1 67.17,7.41 ; JDP1.19 145.77,143.08 ; JDP1.19 144.63,143.08 ; JDP1.19 145.67,143.54 ; JDP1.19 144.73,142.61 ; 336.45,59.56 JUSB1.13 ; JUSB1.13 338.04,59.56 ; JUSB1.13 338.04,60.4 ; JUSB1.13 334.86,60.4 ; JUSB1.13 334.86,61.24 ; JUSB1.13 334.86,59.56 ; JUSB1.13 338.04,61.24 ; JUSB1.13 336.45,61.24 ; JHDMI1.21 133.99,146.78 ; JHDMI1.21 133.99,148.08 ; JHDMI1.21 133,149.37 ; JHDMI1.21 133.99,149.37 ; JHDMI1.21 133,146.78 ; JLAN.14 337.17,91.09 ; JLAN.14 337.17,92.02 ; JLAN.14 337.17,91.55
  GND3 w0.203: H18.1 142.28,104.1 ; H18.1 138.82,100.65 ; H18.1 142.28,100.65 ; H18.1 140.55,104.73 ; H18.1 140.55,100.03 ; H18.1 138.82,104.1 ; H18.1 142.9,102.38 ; H18.1 138.2,102.38 ; 144.73,142.61 JDP1.19 ; JDP1.19 145.77,143.08 ; JDP1.19 144.63,143.08 ; JDP1.19 145.67,143.54 ; JHDMI1.8 123.49,139.66 ; JHDMI1.8 122.51,139.66 ; JHDMI1.8 123.49,138.69 ; JHDMI1.8 123,138.58 ; JHDMI1.8 122.51,138.69 ; JHDMI1.8 123,139.77 ; JUSB2.12 338.04,58.1 ; JUSB2.12 336.45,58.94 ; JUSB2.12 338.04,57.26 ; JUSB2.12 338.04,58.94 ; JUSB2.12 334.86,58.94 ; JUSB2.12 336.45,57.26 ; JUSB2.12 334.86,57.26 ; JUSB2.12 334.86,58.1 ; 327.56,69.06 JUSB1.7 ; JUSB1.7 327.38,68.4 ; JUSB1.7 328.22,67.56 ; JUSB1.7 327.56,67.75 ; JUSB1.7 328.22,69.24 ; 326.72,71.06 JUSB1.4 ; JUSB1.4 325.88,71.9 ; JUSB1.4 326.06,71.25 ; JUSB1.4 326.72,72.74 ; JUSB1.4 326.06,72.56 ; JUSB1.4 327.38,71.25 ; 324.85,3.48 H13.1 ; H13.1 328.53,3.48 ; H13.1 328.05,2.11 ; H13.1 325.32,4.84 ; H13.1 328.05,4.84 ; H13.1 326.69,5.32 ; H13.1 326.69,1.64 ; H13.1 325.32,2.11 ; H10.1 104.34,146.78 ; H10.1 101.13,148.14 ; H10.1 101.13,145.41 ; H10.1 100.66,146.78 ; H10.1 102.5,148.62 ; H10.1 103.87,145.41 ; H10.1 102.5,144.93 ; H10.1 103.87,148.14 ; 199.01,136.73 H2.1 ; H2.1 203.99,138.93 ; H2.1 199.01,141.12 ; H2.1 199.01,138.93 ; H2.1 201.5,141.12 ; H2.1 201.5,136.73 ; H2.1 203.99,141.12 ; H2.1 203.99,136.73 ; JUSB1.12 338.04,76.4 ; JUSB1.12 338.04,75.56 ; JUSB1.12 334.86,76.4 ; JUSB1.12 334.86,75.56 ; JUSB1.12 336.45,75.56 ; JUSB1.12 336.45,77.24 ; JUSB1.12 338.04,77.24 ; JUSB1.12 334.86,77.24 ; 80.43,102.08 H20.1 ; H20.1 83.88,98.63 ; H20.1 82.15,102.71 ; H20.1 80.43,98.63 ; H20.1 79.8,100.36 ; H20.1 82.15,98.01 ; H20.1 84.5,100.36 ; H20.1 83.88,102.08 ; 138.82,68.65 H19.1 ; H19.1 142.9,70.38 ; H19.1 140.55,68.03 ; H19.1 138.2,70.38 ; H19.1 140.55,72.73 ; H19.1 142.28,68.65 ; H19.1 142.28,72.1 ; H19.1 138.82,72.1 ; H14.1 256.35,10.62 ; H14.1 256.35,6.93 ; H14.1 254.98,10.14 ; H14.1 257.72,10.14 ; H14.1 254.51,8.78 ; H14.1 257.72,7.41 ; H14.1 254.98,7.41 ; H14.1 258.19,8.78 ; 334.86,42.94 JUSB2.13 ; JUSB2.13 336.45,41.26 ; JUSB2.13 334.86,42.1 ; JUSB2.13 338.04,41.26 ; JUSB2.13 338.04,42.1 ; JUSB2.13 336.45,42.94 ; JUSB2.13 334.86,41.26 ; JUSB2.13 338.04,42.94 ; 334.86,60.4 JUSB1.13 ; JUSB1.13 338.04,61.24 ; JUSB1.13 338.04,60.4 ; JUSB1.13 336.45,59.56 ; JUSB1.13 334.86,61.24 ; JUSB1.13 338.04,59.56 ; JUSB1.13 336.45,61.24 ; JUSB1.13 334.86,59.56 ; H15.1 333.15,5.4 ; H15.1 329.34,7.01 ; H15.1 333.73,7.01 ; H15.1 331.54,4.81 ; H15.1 329.92,5.4 ; H15.1 331.54,9.21 ; H15.1 333.15,8.63 ; H15.1 329.92,8.63 ; 141.03,143.08 JDP1.7 ; JDP1.7 141.13,142.61 ; JDP1.7 142.17,143.08 ; JDP1.7 142.07,143.54 ; 136.11,142.98 JDP1.23 ; JDP1.23 137.69,142.98 ; JDP1.23 137.69,144.28 ; JDP1.23 136.11,144.28 ; JDP1.23 136.9,145.57 ; JDP1.23 136.9,142.98 ; JDP1.23 136.11,145.57 ; 130.26,138.38 JHDMI1.20 ; JHDMI1.20 132.24,139.68 ; JHDMI1.20 132.24,138.38 ; JHDMI1.20 131.25,138.38 ; JHDMI1.20 130.26,139.68 ; JHDMI1.20 132.24,140.97 ; 115.76,138.38 JHDMI1.23 ; JHDMI1.23 117.74,139.68 ; JHDMI1.23 116.75,138.38 ; JHDMI1.23 115.76,139.68 ; JHDMI1.23 115.76,140.97 ; JHDMI1.23 117.74,138.38 ; 195.75,141.6 JCDRA.47 ; JCDRA.47 194.78,141.6 ; JCDRA.47 194.78,144.75 ; JCDRA.47 196.72,143.18 ; JCDRA.47 196.72,144.75 ; JCDRA.47 194.78,143.18 ; JCDRA.47 196.72,141.6 ; JCDRA.47 195.75,144.75 ; JUSB2.10 332.59,42.1 ; JUSB2.10 330.8,42.94 ; JUSB2.10 329.01,41.26 ; JUSB2.10 329.01,42.1 ; JUSB2.10 332.59,41.26 ; JUSB2.10 330.8,41.26 ; JUSB2.10 329.01,42.94 ; JUSB2.10 332.59,42.94 ; JHDMI1.21 133,149.37 ; JHDMI1.21 133.99,146.78 ; JHDMI1.21 133,146.78 ; JHDMI1.21 133.99,148.08 ; JHDMI1.21 133.99,149.37 ; H5.1 87.94,58.21 ; H5.1 86.1,60.05 ; H5.1 87.46,59.57 ; H5.1 84.25,58.21 ; H5.1 84.73,59.57 ; H5.1 87.46,56.84 ; H5.1 84.73,56.84 ; H5.1 86.1,56.36 ; JUSB1.11 332.59,75.56 ; JUSB1.11 329.01,76.4 ; JUSB1.11 329.01,77.24 ; JUSB1.11 329.01,75.56 ; JUSB1.11 330.8,77.24 ; JUSB1.11 330.8,75.56 ; JUSB1.11 332.59,76.4 ; JUSB1.11 332.59,77.24 ; 327.38,50.1 JUSB2.7 ; JUSB2.7 328.22,50.94 ; JUSB2.7 327.56,50.76 ; JUSB2.7 327.56,49.45 ; JUSB2.7 328.22,49.26 ; 238.5,56.64 H6.1 ; H6.1 238.5,60.33 ; H6.1 236.65,58.49 ; H6.1 237.13,59.85 ; H6.1 240.34,58.49 ; H6.1 239.86,59.85 ; H6.1 237.13,57.12 ; H6.1 239.86,57.12 ; 325.88,53.6 JUSB2.4 ; JUSB2.4 326.72,52.76 ; JUSB2.4 326.72,54.44 ; JUSB2.4 326.06,54.26 ; JUSB2.4 327.38,52.95 ; JUSB2.4 326.06,52.95 ; JCDRA.50 163.25,144.75 ; JCDRA.50 164.22,143.18 ; JCDRA.50 164.22,141.6 ; JCDRA.50 163.25,141.6 ; JCDRA.50 162.28,143.18 ; JCDRA.50 164.22,144.75 ; JCDRA.50 162.28,141.6 ; JCDRA.50 162.28,144.75 ; 151.97,121.74 H17.1 ; H17.1 156.05,120.01 ; H17.1 154.32,124.09 ; H17.1 156.05,123.46 ; H17.1 154.32,119.39 ; H17.1 152.6,120.01 ; H17.1 156.67,121.74 ; H17.1 152.6,123.46 ; JLAN.14 337.17,92.02 ; JLAN.14 337.17,91.09 ; JLAN.14 337.17,91.55 ; JUSB1.10 332.59,59.56 ; JUSB1.10 330.8,59.56 ; JUSB1.10 329.01,60.4 ; JUSB1.10 330.8,61.24 ; JUSB1.10 332.59,60.4 ; JUSB1.10 329.01,61.24 ; JUSB1.10 332.59,61.24 ; JUSB1.10 329.01,59.56 ; H24.1 201.36,25.27 ; H24.1 197.81,26.78 ; H24.1 199.85,28.82 ; H24.1 201.36,28.29 ; H24.1 199.85,24.73 ; H24.1 198.34,28.29 ; H24.1 198.34,25.27 ; H24.1 201.9,26.78 ; 146.55,66.58 H12.1 ; H12.1 147.92,67.06 ; H12.1 149.29,66.58 ; H12.1 147.92,63.37 ; H12.1 146.55,63.85 ; H12.1 149.76,65.22 ; H12.1 149.29,63.85 ; H12.1 146.08,65.22 ; 324.33,11.58 JCR.24 ; JCR.24 327.28,10.1 ; JCR.24 327.28,10.84 ; JCR.24 324.33,10.1 ; JCR.24 325.8,10.1 ; JCR.24 327.28,11.58 ; JCR.24 324.33,10.84 ; JCR.24 325.8,11.58 ; 194.78,146.2 JCDRA.48 ; JCDRA.48 196.72,146.2 ; JCDRA.48 196.72,149.35 ; JCDRA.48 195.75,146.2 ; JCDRA.48 194.78,147.78 ; JCDRA.48 194.78,149.35 ; JCDRA.48 195.75,149.35 ; JCDRA.48 196.72,147.78 ; 121.01,140.86 JHDMI1.5 ; JHDMI1.5 121.01,139.89 ; JHDMI1.5 121.99,140.86 ; JHDMI1.5 121.5,139.78 ; JHDMI1.5 121.99,139.89 ; 163.25,146.2 JCDRA.49 ; JCDRA.49 162.28,149.35 ; JCDRA.49 162.28,146.2 ; JCDRA.49 164.22,149.35 ; JCDRA.49 164.22,146.2 ; JCDRA.49 164.22,147.78 ; JCDRA.49 162.28,147.78 ; JCDRA.49 163.25,149.35 ; H4.1 5.34,38.78 ; H4.1 2.13,40.14 ; H4.1 2.13,37.41 ; H4.1 4.87,40.14 ; H4.1 3.5,40.62 ; H4.1 1.66,38.78 ; H4.1 4.87,37.41 ; H4.1 3.5,36.93 ; JDP1.21 148.89,142.07 ; JDP1.21 148.89,139.48 ; JDP1.21 148.1,139.48 ; JDP1.21 148.89,140.78 ; JDP1.21 147.31,140.78 ; JDP1.21 147.31,139.48 ; JDP1.21 147.31,142.07 ; JDP1.21 148.1,142.07 ; 147.31,142.98 JDP1.22 ; JDP1.22 148.1,142.98 ; JDP1.22 147.31,145.57 ; JDP1.22 148.89,142.98 ; JDP1.22 148.89,144.28 ; JDP1.22 148.89,145.57 ; JDP1.22 148.1,145.57 ; JDP1.22 147.31,144.28 ; JCR.23 327.28,40.14 ; JCR.23 327.28,39.4 ; JCR.23 324.33,40.14 ; JCR.23 325.8,40.88 ; JCR.23 324.33,39.4 ; JCR.23 325.8,39.4 ; JCR.23 327.28,40.88 ; JCR.23 324.33,40.88 ; 127.01,140.86 JHDMI1.17 ; JHDMI1.17 127.99,140.86 ; JHDMI1.17 127.99,139.89 ; JHDMI1.17 127.5,139.78 ; JHDMI1.17 127.01,139.89 ; JHDMI1.2 120.49,138.69 ; JHDMI1.2 120,139.77 ; JHDMI1.2 119.4,139.18 ; JHDMI1.2 119.51,138.69 ; JHDMI1.2 120.49,139.66 ; JHDMI1.2 119.51,139.66 ; JHDMI1.2 120,138.58 ; 199.66,144.93 H11.1 ; H11.1 202.87,143.56 ; H11.1 200.13,143.56 ; H11.1 200.13,146.29 ; H11.1 202.87,146.29 ; H11.1 201.5,143.08 ; H11.1 203.34,144.93 ; H11.1 201.5,146.77 ; H16.1 205.67,121.74 ; H16.1 201.59,120.01 ; H16.1 201.59,123.46 ; H16.1 205.05,123.46 ; H16.1 203.32,124.09 ; H16.1 203.32,119.39 ; H16.1 200.97,121.74 ; H16.1 205.05,120.01 ; 114.01,149.37 JHDMI1.22 ; JHDMI1.22 115,146.78 ; JHDMI1.22 114.01,148.08 ; JHDMI1.22 114.01,146.78 ; JHDMI1.22 115,149.37 ; H23.1 161.82,62.09 ; H23.1 160.09,61.46 ; H23.1 159.47,59.74 ; H23.1 160.09,58.01 ; H23.1 164.17,59.74 ; H23.1 161.82,57.39 ; H23.1 163.55,61.46 ; H23.1 163.55,58.01 ; H22.1 205.55,61.46 ; H22.1 202.1,58.01 ; H22.1 206.17,59.74 ; H22.1 203.82,62.09 ; H22.1 205.55,58.01 ; H22.1 202.1,61.46 ; H22.1 203.82,57.39 ; H22.1 201.47,59.74 ; 139.33,143.54 JDP1.1 ; JDP1.1 140.27,142.61 ; JDP1.1 140.37,143.08 ; JDP1.1 139.23,143.08 ; 80.43,74.08 H21.1 ; H21.1 80.43,70.63 ; H21.1 83.88,74.08 ; H21.1 83.88,70.63 ; H21.1 79.8,72.36 ; H21.1 82.15,70.01 ; H21.1 84.5,72.36 ; H21.1 82.15,74.71 ; JUSB2.11 332.59,57.26 ; JUSB2.11 332.59,58.1 ; JUSB2.11 330.8,58.94 ; JUSB2.11 330.8,57.26 ; JUSB2.11 332.59,58.94 ; JUSB2.11 329.01,58.1 ; JUSB2.11 329.01,58.94 ; JUSB2.11 329.01,57.26 ; 124.5,139.78 JHDMI1.11 ; JHDMI1.11 124.01,139.89 ; JHDMI1.11 124.01,140.86 ; JHDMI1.11 124.99,139.89 ; JHDMI1.11 124.99,140.86 ; 63.96,8.78 H9.1 ; H9.1 67.17,10.14 ; H9.1 67.64,8.78 ; H9.1 64.43,7.41 ; H9.1 65.8,6.93 ; H9.1 65.8,10.62 ; H9.1 67.17,7.41 ; H9.1 64.43,10.14 ; H8.1 149.74,7.28 ; H8.1 147.9,5.43 ; H8.1 149.27,8.64 ; H8.1 146.53,8.64 ; H8.1 146.06,7.28 ; H8.1 149.27,5.91 ; H8.1 147.9,9.12 ; H8.1 146.53,5.91 ; JDP1.24 137.69,139.48 ; JDP1.24 136.9,139.48 ; JDP1.24 137.69,140.78 ; JDP1.24 136.11,142.07 ; JDP1.24 136.11,140.78 ; JDP1.24 136.9,142.07 ; JDP1.24 136.11,139.48 ; JDP1.24 137.69,142.07 ; 142.93,143.54 JDP1.13 ; JDP1.13 142.83,143.08 ; JDP1.13 143.97,143.08
  BOTTOM w0.089: UV15.G5 v3(217.91,73.12)
  BOTTOM w0.127: UH1.BD31 212.23,41.23 212.6,40.86 ; v2(212.55,63.46) 212.55,63.86 v3(213.08,64.39) ; v3(38.04,41.62) 38.39,41.26 v2(38.85,41.26) ; v2(12.18,35.02) 12.18,35.23 v3(11.7,35.71) ; v2(231.12,16.65) 230.53,16.65 v3(230.21,16.97) ; v3(321.76,68.61) v2(321.06,68.61) ; v3(147.77,73.97) 147.02,73.22 v2(146.83,73.22) ; v2(213.17,56.16) 213.9,56.16 v3(213.91,56.16) ; v2(159.88,119.23) 160.52,119.23
  BOTTOM w0.152: UV1.N46 UV1.N45 ; v3(184.4,104.78) 184.53,104.65 184.53,104.43 184.8,104.15 UV1.W46 UV1.W45 ; v3(182,104.78) 182.4,104.38 UV1.AB46 UV1.AB45 ; UV1.K5 UV1.K4 192,69.18 v3(192.4,68.78) ; UV1.AP46 UV1.AP45
  BOTTOM w0.203: CPU1.BF43 100.45,71.04 v3(101.21,71.04) ; CPU1.BD5 125.3,72.94 125.3,73.53 CPU1.BC5 ; CPU1.BA50 CPU1.AY50 ; JCDRA.38 185.5,144.1 v3(185.84,144.44) 186.31,144.44 186.7,144.05 JCDRA.41 ; CPU1.BA22 114.37,74.67 114.81,74.67 114.85,74.63 115.02,74.63 115.36,74.28 CPU1.BB20 ; CPU1.E16 117.75,99.27 117.39,99.63 117.04,99.27 CPU1.E17 ; CPU1.E19 116.13,99.27 v3(115.77,99.63) 116.11,99.97 CPU1.D19 ; v3(172.42,144.43) 172.3,144.3 172.3,143.18 JCDRA.5 ; v3(184.36,144.44) 184.3,144.38 JCDRA.35 ; JCDRA.44 187.9,142.26 187.9,142.26 v3(188.17,141.99) ; v3(182.77,140.58) 183.1,140.91 JCDRA.32 183.1,144.06 182.76,144.4 v3(182.5,144.4) 182.18,144.4 181.9,144.12 JCDRA.29 181.9,142.13 v3(181.55,141.78) ; CPU1.B15 118.64,101.41 118.64,101.89 118.6,101.92 CPU1.A15 ; CPU1.T48 v3(96.52,91.8) 96.71,91.99 CPU1.R48 96.52,92.6 96.52,93.05 CPU1.P48 ; v3(173.41,141.92) 173.5,142.02 JCDRA.8 173.5,143.18 173.5,144.26 173.32,144.44 v3(173.13,144.44) ; v3(175.2,140.64) 175.9,141.34 JCDRA.14 175.9,143.18 175.9,144.21 175.67,144.44 v3(175.12,144.44) 174.91,144.44 174.7,144.22 174.7,143.18 JCDRA.11 v3(174.7,141.9) ; v3(179.53,144.44) 179.5,144.41 JCDRA.23 179.5,142.23 179.19,141.92 v3(178.55,141.92) 178.3,142.17 JCDRA.20 178.3,144.14 178.04,144.4 v3(177.73,144.4) 177.4,144.4 177.1,144.1 177.1,143.18 JCDRA.17
  BOTTOM w0.206: v3(117.75,36.65) 118.16,36.65 118.85,37.34 JDIMM1.127
  BOTTOM w0.229: CPU1.G11 121.19,97.95 v3(121.47,98.24)
  BOTTOM w0.254: CPU1.H51 94.47,96.85 v3(94.11,96.49) CPU1.J51 ; v3(190.19,122.73) 191,122.73 UV8.G10 ; CPU1.F52 93.86,98.5 v3(93.49,98.12) 93.78,97.82 CPU1.G52 ; UV8.R11 v3(191.45,115.88) UV8.T10 ; CPU1.B33 106.47,101.37 v3(106.12,101.02) 106.47,100.67 CPU1.C33 ; v3(115.77,99.63) 115.41,99.27 CPU1.E20 ; CPU1.AE7 124.05,85.6 v3(124.19,85.74) ; UV6.B5 v3(173.41,115.08) ; CPU1.BC12 CPU1.BB12 ; CPU1.BB12 120.47,74.43 120.98,74.43 CPU1.BB11 CPU1.BB10 ; CPU1.BB12 120.13,74.47 119.69,74.47 CPU1.BB14 ; v3(216.71,69.01) UV15.E1 ; CPU1.J49 96.01,96.27 v3(96.01,96.61) 96.01,96.91 96.28,97.17 CPU1.H49 ; UV6.R1 v3(176.61,126.28) ; UV15.T10 v3(225.11,77.12) ; CPU1.AU13 119.82,77.78 v3(120.17,77.43) 119.82,77.08 CPU1.AV13 ; v3(113.61,78.09) 113.64,78.09 114.03,78.48 CPU1.AT22 ; UV15.N1 223.11,69.03 v3(223.09,69.01) ; CPU1.BC10 121.8,73.73 121.8,74.14 CPU1.BB10 ; UV12.R12 v3(225.11,95.96) 225.71,95.96 226.11,96.36 UV12.U12 ; CPU1.H54 92.37,96.86 v3(92.74,96.49) 92.38,96.13 CPU1.J54 ; UV7.D10 v3(172.61,116.68) ; v3(107.95,78.21) 107.97,78.21 108.39,77.78 CPU1.AU30 ; v3(101.4,102.48) 101.79,102.09 CPU1.A40 ; CPU1.AB5 CPU1.AC5 125.42,86.82 125.77,86.48 v3(125.77,86.49) ; UV6.M5 v3(172.46,123.48) ; v3(183.33,124.35) 183.77,124.35 UV8.E1 ; CPU1.AW18 116.88,76.42 116.95,76.49 116.95,77.01 CPU1.AV18 116.95,77.15 116.95,77.72 CPU1.AU18 116.81,77.78 v3(116.39,78.2) 116.68,78.48 CPU1.AT18 ; 122.58,97.8 CPU1.G9 ; 122.58,97.8 CPU1.G8 ; 122.58,97.8 v3(123.08,98.29) ; v3(220.63,68.94) 220.71,69.03 UV15.K1 220.65,69.58 220.65,70.27 UV15.K2 ; CPU1.C19 116.2,100.67 v3(116.58,101.05) ; UV15.L10 v3(221.91,76.32) UV15.M10 ; CM33.2 150.16,133.37 UM8.25 ; v3(165.3,117.88) UV7.E1 ; v3(92.07,88.41) 92.37,88.11 CPU1.AB54 ; UV15.R12 v3(225.11,77.92) 225.91,77.92 UV15.U12 ; CPU1.BC30 109,73.58 v3(109.32,73.9) 109.7,74.28 CPU1.BB28 ; v3(96.52,94.3) 96.52,93.88 CPU1.N48 ; v3(96.52,94.3) 96.52,94.55 96.71,94.73 CPU1.L48 ; v3(96.52,94.3) CPU1.M48 ; UV8.E14 194.67,124.28 194.72,124.23 v3(194.83,124.23) ; v3(124.9,78.71) 124.77,78.71 124.55,78.48 CPU1.AT6 ; CPU1.BC41 101.69,73.58 v3(102.03,73.25) ; CPU1.BA18 117.1,74.76 117.34,74.76 117.48,74.62 v3(117.48,74.61) 117.81,74.28 CPU1.BB16 CPU1.BB15 ; UV12.P10 v3(224.31,94.36) ; CPU1.AW37 103.86,76.38 v3(104.21,76.04) ; v3(93.48,100.23) 93.48,100.22 93.46,100.22 93.07,100.61 CPU1.C53 ; CPU1.AV33 106.46,77.08 v3(106.11,77.43) 106.46,77.78 CPU1.AU33 ; CPU1.A44 99.43,102.09 v3(99.03,102.48) ; v3(96.52,87.6) CPU1.AB48 ; CPU1.AT16 117.94,78.48 v3(118.3,78.12) ; UV6.U3 v3(175.01,127.88) ; v3(96.63,78.84) 96.27,78.48 CPU1.AT49 96.14,78.48 95.89,78.74 v3(95.76,78.74) ; v3(96.63,78.84) 96.99,79.2 CPU1.AR48 ; v3(96.63,78.84) 96.79,78.84 CPU1.AT47 97.29,78.48 97.51,78.71 v3(97.65,78.71) 97.86,78.71 CPU1.AT46 98.2,78.6 98.86,78.6 98.98,78.48 CPU1.AT45 99.45,78.91 v3(99.48,78.94) 99.54,78.91 CPU1.AT43 ; 123.56,74.28 CPU1.BB7 CPU1.BB6 ; 123.56,74.28 CPU1.BB9 ; 123.56,74.28 122.86,74.98 CPU1.BA9 ; v3(91.83,97.69) 92.25,97.69 CPU1.G54 ; CPU1.AL48 97.02,82 96.8,82.23 96.8,82.61 CPU1.AK48 96.52,82.89 v3(96.52,83.4) ; UV6.K1 v3(175.81,122.28) UV6.K2 ; UV8.A14 194.25,127.48 v3(194.65,127.88) ; CPU1.AV5 125.42,77.02 v3(125.77,76.67) ; CPU1.C8 123.44,100.63 123.44,100.01 CPU1.D8 123.43,99.92 123.43,99.32 CPU1.E8 123.45,99.27 v3(123.08,98.91) ; UV8.H2 184.56,121.88 v3(184.24,121.57) 183.93,121.88 UV8.H1 ; CPU1.U50 95.17,91.27 v3(94.79,91.65) ; UV8.K2 UV8.K1 183.42,120.28 v3(183.33,120.19) ; UV8.L10 v3(190.65,119.08) UV8.M10 ; CPU1.B4 125.97,101.37 v3(125.67,101.07) 125.67,101.04 126.04,100.67 CPU1.C4 ; CPU1.E37 104.11,99.27 v3(103.76,99.62) 104.11,99.97 CPU1.D37 ; v3(96.66,76.87) 96.65,76.87 96.65,76.86 96.81,76.7 96.84,76.7 97.14,76.39 CPU1.AW47 ; CPU1.U52 93.77,91.28 v3(93.39,91.66) ; CPU1.AA48 96.52,88.49 v3(96.52,89) ; CPU1.U54 v3(91.95,90.83) ; CPU1.BF5 125.36,71.47 125.36,71.16 v3(125.08,70.88) 125.05,70.88 124.5,71.44 124.5,71.47 CPU1.BF6 CPU1.BF7 ; UV8.B5 v3(186.65,126.28) UV8.C4 ; CPU1.AV1 128.12,76.97 127.63,76.97 CPU1.AV2 127.5,77.08 127.11,77.46 ; v3(187.64,115.47) 187.64,115.48 UV8.T5 ; v3(112.56,78.12) 112.22,77.78 CPU1.AU25 CPU1.AV25 ; v3(91.83,98.51) CPU1.F54 ; v3(176.61,114.23) 176.61,114.28 UV6.A1 ; v3(122.04,78.81) 122.43,79.2 CPU1.AR9 ; CPU1.AM51 94.47,81.44 v3(94.82,81.09) 95.17,80.74 CPU1.AN50 ; CPU1.F44 99.38,98.57 v3(99.03,98.22) 99.38,97.87 CPU1.G44 ; CPU1.AU22 114.15,77.78 114.5,77.44 v3(114.54,77.44) 114.19,77.08 CPU1.AV22 ; CPU1.C26 111.22,100.67 v3(110.87,101.02) 111.22,101.37 CPU1.B26 ; CPU1.AW5 125.42,76.32 v3(125.77,76.67) ; CPU1.AW50 95.57,77.02 v3(95.57,77.11) 95.47,77.11 95.17,77.41 CPU1.AV50 ; UV12.R14 224.71,98.19 224.83,98.31 v3(224.83,98.47) ; UV12.K14 v3(221.11,97.56) UV12.K13 ; CPU1.BA37 104.06,74.64 CPU1.BB37 104.76,73.58 CPU1.BC36 104.77,73.48 104.77,72.99 CPU1.BD36 104.78,72.79 104.78,72.28 CPU1.BE36 104.8,72.11 104.8,71.56 CPU1.BF36 ; CPU1.BA37 103.56,74.98 103.21,75.33 v3(103.21,75.35) 103.55,75.68 CPU1.AY37 ; CPU1.BA37 103.25,74.51 CPU1.BB38 CPU1.BC38 103.25,73.57 102.84,73.16 102.84,71.89 CPU1.BF38 103.25,71.31 102.95,71.02 102.04,71.02 v3(101.97,71.09) ; CPU1.BB15 118.81,74.41 119.38,74.41 CPU1.BB14 ; CPU1.BB15 118.6,74.19 118.6,73.68 CPU1.BC15 118.65,73.54 118.65,72.93 CPU1.BD15 CPU1.BE15 CPU1.BF15 119.12,71.06 119.8,71.06 119.85,71.11 v3(119.86,71.11) 120.23,71.48 CPU1.BF12 ; UV6.C3 v3(174.21,115.88) ; v3(174.21,115.88) UV6.C4 ; v3(174.21,115.88) 174.21,115.15 174.61,114.75 UV6.A3 ; CPU1.B40 101.74,101.37 v3(101.4,101.02) 101.75,100.67 CPU1.C40 ; UV8.U3 v3(185.85,115.08) ; v3(129.29,93.76) 128.87,93.34 128.23,93.34 CPU1.P1 CPU1.P2 127.42,93.33 127.41,93.32 127.12,93.32 127.09,93.3 126.86,93.3 CPU1.P3 126.69,93.33 126.68,93.32 126.13,93.32 CPU1.P4 CPU1.P5 125.4,93.31 124.75,93.31 CPU1.P6 124.46,93.59 124.46,93.74 v3(124.31,93.89) ; v3(8.09,28.68) 7.98,28.68 UA4.4 ; v3(167.81,115.88) UV6.C12 ; CPU1.B30 108.83,101.37 v3(108.48,101.02) 108.83,100.67 CPU1.C30 ; UV8.C3 v3(185.85,126.28) ; v3(127.17,85.55) 126.82,85.9 CPU1.AE3 ; CPU1.AT42 100.78,78.48 v3(100.43,78.13) ; CPU1.AT42 100.9,78.7 v3(100.62,78.97) ; CPU1.AT42 101.16,78.74 101.58,78.74 CPU1.AT40 ; CPU1.G33 106.53,97.81 v3(106.12,98.22) 106.47,98.57 CPU1.F33 ; CPU1.AU42 100.78,77.78 v3(100.43,77.43) 100.78,77.08 CPU1.AV42 ; CPU1.BB46 98.38,74.28 98.39,74.28 98.76,74.28 98.76,74.28 CPU1.BB44 99.19,74.26 99.56,73.88 v3(99.56,73.89) ; UV15.R4 v3(225.11,72.32) UV15.T5 ; UV12.C4 v3(214.71,90.36) UV12.B5 ; CPU1.E44 99.38,99.27 v3(99.03,99.62) 99.38,99.97 CPU1.D44 ; CPU1.BF18 116.25,70.72 v3(116.52,70.46) ; CPU1.G8 123.28,97.46 CPU1.H7 124.09,97.11 v3(124.27,96.93) 124.27,96.69 CPU1.J7 ; CPU1.G8 CPU1.G7 125.05,97.8 v3(125.07,97.82) ; CPU1.D49 96.21,99.97 v3(95.85,99.61) 96.19,99.27 CPU1.E49 ; UH1.BE41 211.62,45.99 v3(211.17,46.43) ; v3(96.52,86.2) 96.52,85.69 CPU1.AE48 96.52,85.32 v3(96.52,84.8) ; v3(96.52,86.2) 96.52,86.72 CPU1.AC48 ; v3(96.52,86.2) CPU1.AD48 ; UA4.20 3.73,23.73 v3(3.58,23.73) 3.58,24.28 UA4.21 ; v3(94.14,82.76) 94.47,83.09 CPU1.AJ51 ; CPU1.B15 118.7,101.27 118.7,100.77 CPU1.C15 118.58,100.67 v3(118.21,100.3) ; v3(91.42,81.09) 91.42,81.37 91.59,81.54 92.32,81.54 CPU1.AM54 ; UV15.M5 v3(221.91,73.12) UV15.L5 ; CPU1.AM5 125.42,81.08 v3(125.77,80.73) ; CPU1.C22 113.82,100.67 v3(114.14,100.35) 113.76,99.97 CPU1.D22 ; v3(96.52,84.8) CPU1.AG48 ; v3(96.52,84.8) 96.61,84.71 96.61,84.19 CPU1.AH48 96.52,83.92 v3(96.52,83.4) ; v3(118.23,99.66) 118.6,99.28 CPU1.E15 ; v3(118.23,99.66) 117.84,99.27 CPU1.E16 ; v3(118.23,99.66) 118.54,99.97 CPU1.D15 ; UV8.R4 v3(185.85,115.88) UV8.R3 ; v3(125.77,76.67) 126.12,77.02 CPU1.AV4 ; UV12.G5 v3(217.91,91.16) UV12.F5 ; v3(226.71,89.56) UV12.U3 ; CPU1.F30 108.83,98.57 v3(108.48,98.22) 108.87,97.84 CPU1.G30 ; UV12.H14 v3(219.51,97.56) UV12.H13 ; v3(91.96,94.11) 92.35,94.5 CPU1.M54 ; v3(120.18,76.73) 119.83,76.38 CPU1.AW13 CPU1.AY13 119.9,75.48 119.9,75.19 CPU1.BA13 119.51,74.79 CPU1.BB14 ; UV12.R4 v3(225.11,90.36) UV12.T5 ; v3(127.81,75.03) 127.81,74.92 128.22,74.5 CPU1.BB1 ; v3(91.78,76.15) 91.79,76.16 91.82,76.16 92.28,76.62 CPU1.AW54 ; CPU1.BB10 121.94,74.32 122.52,74.9 CPU1.BA9 ; UV6.H2 v3(175.81,119.88) UV6.H1 ; 127.11,77.46 127.11,77.37 CPU1.AV3 ; 127.11,77.46 v3(127.11,77.49) ; CPU1.E22 113.79,99.27 v3(114.14,99.63) 114.5,99.27 CPU1.E21 ; UV8.E12 v3(192.25,124.68) ; v3(167.01,114.28) UV6.A12 ; v3(96.52,89) 96.52,89.52 CPU1.W48 96.52,89.89 v3(96.52,90.4) ; v3(96.52,89) CPU1.Y48 ; v3(167.81,126.28) UV6.R12 ; CPU1.AW42 100.9,76.39 100.6,76.69 v3(100.38,76.69) 100.07,76.38 CPU1.AW43 ; CPU1.E25 112.14,99.27 v3(112.52,99.65) 112.9,99.27 CPU1.E24 ; CPU1.F40 101.74,98.57 v3(101.4,98.22) 101.81,97.8 CPU1.G40 ; v3(215.35,80.64) 215.11,80.4 UV15.C14 ; v3(165.41,123.83) 165.41,123.88 UV7.N1 ; v3(124.31,93.89) 123.95,93.89 CPU1.M7 123.86,94.44 123.86,94.88 CPU1.L7 123.98,95.06 123.63,95.41 CPU1.K7 124,95.74 v3(124.4,95.34) 124.4,95.45 CPU1.K6 124.84,95.66 125.31,95.66 CPU1.K5 125.45,95.77 v3(125.86,96.17) 125.86,96.17 126.12,95.9 CPU1.K4 CPU1.K3 126.93,95.67 127.42,95.67 CPU1.K2 CPU1.K1 ; v3(124.31,93.89) 123.95,93.53 CPU1.N7 124.19,93.27 124.19,92.8 ; v3(95.52,81.93) 95.52,81.96 CPU1.AK49 95.87,82.42 v3(95.57,82.72) 95.57,82.82 CPU1.AJ49 95.87,83.18 v3(95.52,83.53) ; v3(95.52,81.93) 95.17,81.58 CPU1.AM50 95.17,81.44 v3(95.52,81.09) 95.87,80.74 CPU1.AN49 ; v3(95.52,81.93) 95.17,82.28 CPU1.AK50 ; v3(225.21,48.12) 224.79,47.7 UH1.P45 ; v3(214.71,87.16) UV12.C1 ; CPU1.G13 119.52,97.67 119.52,97.86 119.16,98.22 118.78,98.22 118.62,98.06 v3(118.38,98.06) 118.19,97.87 CPU1.G16 ; CPU1.F37 103.82,98.24 v3(103.82,98.17) 104.13,97.85 CPU1.G37 ; UV8.C1 v3(183.45,126.28) ; UV15.U14 226.05,80.18 v3(226.05,80.44) ; CPU1.BC46 98.46,73.5 98.46,72.97 CPU1.BD46 98.36,72.88 v3(97.95,72.48) 98.07,72.48 CPU1.BE46 98.43,72.12 98.43,71.55 CPU1.BF46 ; CPU1.AE5 125.77,85.67 v3(125.77,85.55) 126.12,85.9 CPU1.AE4 ; UV15.A14 v3(213.11,79.52) ; v3(216.71,87.04) UV12.E1 ; v3(127.82,75.86) 128.22,75.46 CPU1.BA1 ; CPU1.B8 123.67,101.56 123.67,101.98 CPU1.A8 123.58,102.1 123.95,102.47 124,102.47 v3(124.03,102.5) ; v3(97.16,74) 97.28,74 CPU1.BB47 ; UV15.B10 v3(214.71,76.32) ; UV12.B10 v3(214.71,94.36) ; v3(106.09,76.15) 106.54,75.7 CPU1.AY33 CPU1.BA33 106.5,74.95 CPU1.BB33 ; CPU1.AG5 125.42,84.34 v3(125.77,83.99) 126.12,83.64 CPU1.AH4 ; UV8.M5 v3(187.45,119.08) UV8.L5 ; CPU1.AC50 95.17,87.13 v3(94.82,86.78) 95.17,86.43 CPU1.AD50 ; UV8.N12 v3(192.25,117.48) ; CPU1.AL4 126.12,81.9 v3(125.77,81.55) 125.42,81.9 CPU1.AL5 ; v3(124.24,84.5) 124.14,84.5 123.84,84.2 CPU1.AG7 ; 222.15,14.33 v3(222.23,14.41) ; 222.15,14.33 JSSD2.3 ; 222.15,14.33 221.65,13.83 JSSD2.5 ; CPU1.AA7 v3(124.19,88.5) ; v3(124.19,88.5) 124.19,88.03 CPU1.AB7 124.19,87.57 v3(124.19,87) ; v3(124.19,88.5) 124.19,89.02 CPU1.Y7 123.95,89.46 123.63,89.78 CPU1.W7 123.95,90.28 CPU1.V7 123.95,90.83 123.63,91.16 CPU1.U7 124.19,91.35 ; CPU1.B19 116.2,101.37 v3(116.58,101.75) 116.26,102.07 CPU1.A19 ; UA4.24 2.53,25.35 2.29,25.35 2.16,25.48 v3(2.16,25.68) ; UV6.T10 v3(168.61,126.28) UV6.R11 ; CPU1.U5 125.41,90.89 v3(125.03,90.51) 124.72,90.83 CPU1.U6 124.64,90.89 124.19,91.35 ; v3(224.71,69.01) UV15.R1 ; UH1.Y8 222.53,32.39 222.66,32.39 v3(222.89,32.62) 223.07,32.8 UH1.U10 ; CPU1.A33 106.51,102.09 v3(106.12,102.48) ; UV8.U12 192.65,114.88 192.25,115.28 v3(192.25,115.88) UV8.R12 ; v3(165.41,126.28) UV7.R1 ; CPU1.BC22 113.83,73.58 v3(114.17,73.24) 114.19,73.24 114.53,73.58 CPU1.BC21 ; UV12.C12 v3(214.71,95.96) UV12.C11 ; CPU1.AG53 93.07,84.77 v3(93.41,85.11) 93.41,85.09 93.76,84.75 CPU1.AG52 ; CPU1.A37 104.15,102.09 v3(103.76,102.48) ; v3(94.11,76.99) 94.11,76.98 CPU1.AW51 ; v3(213.91,73.12) UV15.B5 ; UV12.N1 223.11,87.12 v3(223.17,87.06) ; CPU1.AG54 91.88,85.23 v3(91.88,85.42) ; v3(223.52,80.35) 223.52,80.34 UV15.N14 ; UV7.K1 v3(166.21,122.28) UV6.K13 ; CPU1.A11 CPU1.B11 121,101.33 121,100.71 CPU1.C11 121.1,100.67 v3(121.45,101.02) ; CPU1.D26 111.22,99.97 110.87,99.62 v3(110.87,98.96) ; UV15.H14 v3(219.51,79.52) UV15.H13 ; v3(183.33,114.07) 183.85,114.59 UV8.U1 ; UV15.R14 224.71,80.25 224.8,80.34 v3(224.8,80.5) ; CPU1.AM52 93.77,81.59 v3(93.42,81.94) 93.07,81.59 CPU1.AM53 ; CPU1.B44 99.38,101.37 v3(99.03,101.02) 99.38,100.67 CPU1.C44 ; UV15.C11 v3(214.71,77.92) UV15.C12 ; UV6.N3 v3(174.21,124.68) 173.55,124.68 173.15,125.08 UV7.P10 ; CPU1.AT25 112.03,78.48 v3(111.7,78.15) 111.36,78.48 CPU1.AT26 ; UV6.C1 v3(176.61,116.68) ; v3(124.19,85.74) 124.19,85.9 123.95,86.13 CPU1.AD7 123.95,86.71 124.19,86.94 v3(124.19,87) ; v3(124.19,85.74) 124.19,85.13 CPU1.AF7 123.63,84.58 CPU1.AG7 ; v3(124.19,85.74) 124.32,85.6 124.33,85.6 CPU1.AF6 124.72,85.15 v3(125.07,84.8) ; UE8.18 178.18,138.54 v3(178.16,138.52) ; UV8.D10 190.52,125.08 v3(190.36,124.92) ; v3(94.79,90.84) 95.17,90.46 CPU1.V50 ; CPU1.D30 108.83,99.97 v3(108.48,99.62) 108.83,99.27 CPU1.E30 ; UV8.N14 194.72,117.88 v3(194.76,117.92) ; v3(94.79,93.28) 95.17,92.9 CPU1.P50 ; v3(190.51,127.05) 190.88,126.68 UV8.B10 ; v3(94.82,85.97) 95.17,85.62 CPU1.AE50 ; v3(214.71,72.32) UV15.C4 214.89,71.7 214.89,71.34 UV15.C3 ; v3(223.51,71.52) UV15.N3 ; CPU1.F3 126.54,98.49 v3(126.54,98.62) 126.3,98.37 126.28,98.37 CPU1.F4 ; v3(212.86,89.05) 212.9,89.05 212.96,89.11 213.46,89.11 UV12.A3 ; CPU1.BD10 121.8,72.74 121.8,72.33 CPU1.BE10 121.78,72.02 121.78,71.65 CPU1.BF10 v3(122.3,71.1) ; v3(96.52,90.4) CPU1.V48 ; v3(96.52,90.4) 96.52,90.92 CPU1.U48 ; CPU1.W52 93.77,89.65 v3(93.39,90.03) ; v3(217.91,73.12) UV15.F5 ; UV15.F10 v3(217.91,76.32) UV15.G10 ; CPU1.BF33 106.11,71.87 106.11,73.19 CPU1.BC33 106.43,73.65 106.43,74.22 CPU1.BB33 ; CPU1.AY50 95.64,75.81 v3(95.72,75.89) 96.2,76.37 CPU1.AW49 ; v3(183.35,117.82) 183.41,117.88 UV8.N1 ; CPU1.AH2 127.6,83.65 128.15,83.65 CPU1.AH1 128.22,83.52 v3(128.57,83.17) ; UV8.R1 v3(183.33,116.28) ; v3(142.35,10.5) 142.61,10.76 142.61,12.35 142.94,12.67 U2407.6 ; v3(94.82,80.28) 94.47,79.93 CPU1.AP51 ; v3(91.82,82.64) 91.89,82.7 91.89,83.02 92.1,83.23 92.26,83.23 CPU1.AJ54 ; UV12.M5 v3(221.91,91.16) UV12.L5 ; CPU1.C37 104.11,100.67 v3(103.76,101.02) 104.11,101.37 CPU1.B37 ; UV6.H13 166.51,120.38 165.91,120.38 ; v3(101.31,78.07) 101.72,78.48 CPU1.AT40 ; v3(223.51,89.56) UV12.N3 ; CPU1.AT52 93.77,78.28 v3(93.41,78.63) 93.07,78.29 CPU1.AT53 ; CPU1.BA42 100.78,74.98 v3(100.43,75.33) 100.78,75.68 CPU1.AY42 ; UV12.L10 v3(221.91,94.36) UV12.M10 ; CPU1.BB43 100.04,74.28 v3(100.4,73.92) 100.06,73.58 CPU1.BC43 ; CPU1.AP50 95.17,79.93 v3(95.52,80.28) 95.87,79.93 CPU1.AP49 ; v3(224.31,77.12) UV15.R11 ; CPU1.A26 111.28,102.07 110.89,102.46 v3(110.87,102.48) ; CPU1.A22 113.79,102 113.79,101.44 CPU1.B22 113.63,101.37 v3(113.29,101.03) ; v3(220.63,86.98) 220.63,87.13 220.71,87.21 UV12.K1 UV12.K2 ; UV8.H13 v3(193.85,121.48) UV8.H14 ; CPU1.AR22 113.79,78.91 v3(113.57,78.69) ; CPU1.B51 94.61,101.37 v3(94.24,100.99) 93.89,100.64 CPU1.C52 ; v3(183.45,127.88) 183.45,127.88 UV8.A1 ; CPU1.U2 127.52,90.92 v3(127.88,91.28) 128.22,90.93 CPU1.U1 ; CPU1.H53 93.07,96.96 v3(93.41,97.3) CPU1.H52 ; UV6.U1 176.21,127.48 v3(176.62,127.88) ; UV12.N12 223.51,95.96 v3(223.51,95.96) ; CPU1.AR5 125.42,79.46 v3(125.77,79.11) 125.42,78.76 CPU1.AT5 ; v3(223.47,98.37) 223.47,98.35 223.11,97.99 UV12.N14 ; v3(124.19,82.8) 124.19,82.33 CPU1.AL7 124.19,81.87 v3(124.19,81.3) CPU1.AM7 ; v3(124.19,82.8) CPU1.AK7 ; v3(124.19,82.8) 124.19,83.27 CPU1.AH7 123.63,83.83 CPU1.AG7 ; CPU1.AY9 122.52,75.55 122.59,75.48 122.59,75.11 122.52,75.04 CPU1.BA9 ; v3(92.73,77.9) 92.38,78.25 CPU1.AT54 92.06,78.25 v3(91.84,78.02) ; v3(216.57,98.47) 216.57,98.44 216.71,98.31 UV12.E14 ; 124.19,91.35 124.19,91.87 CPU1.R7 124.19,92.33 124.19,92.8 ; UV6.G5 v3(172.61,119.08) UV6.F5 ; v3(113.52,76) 113.84,75.68 CPU1.AY22 114.34,75.4 v3(114.55,75.4) 114.14,74.98 CPU1.BA22 113.9,74.82 113.59,74.82 113.06,74.28 CPU1.BB23 CPU1.BB25 112.26,74.36 112.26,74.9 CPU1.BA25 CPU1.AY25 112.53,76.04 v3(112.74,76.04) ; v3(125.1,83.97) 125.42,83.65 CPU1.AH5 ; CPU1.BA29 109.37,75 109.37,75.67 CPU1.AY29 109.01,76.03 v3(108.82,76.03) ; CPU1.M52 v3(93.42,94.85) ; CPU1.AE2 CPU1.AE1 128.64,86.02 v3(129.1,85.56) ; v3(96.57,80.71) 96.67,80.6 CPU1.AN48 ; UV12.A1 v3(213.11,87.16) ; v3(213.1,98.36) 213.51,97.96 UV12.A14 ; CPU1.E26 111.39,99.27 v3(111.7,98.96) 111.31,98.57 CPU1.F26 ; v3(225.11,89.56) UV12.R3 ; CPU1.AT39 102.81,78.48 v3(103.24,78.91) 103.34,78.91 103.72,78.53 CPU1.AT37 103.6,78.48 v3(103.25,78.13) 103.25,78.13 103.59,77.78 CPU1.AU37 ; CPU1.AT39 CPU1.AT40 ; CPU1.AT39 102.25,79.02 v3(102.04,79.02) 101.84,78.81 CPU1.AT40 ; CPU1.AT4 126.12,78.65 v3(125.77,78.3) 125.42,77.95 CPU1.AU5 ; v3(224.31,95.16) UV12.R11 ; CPU1.BA4 126.12,75.4 v3(125.77,75.05) 125.42,75.4 CPU1.BA5 ; CPU1.BB39 102.36,74.28 v3(102.02,73.94) 101.67,74.28 CPU1.BB41 101.39,74.52 101.04,74.52 CPU1.BB42 ; v3(94.12,86.78) 94.47,86.43 CPU1.AD51 ; v3(190.5,123.22) 190.76,123.48 UV8.F10 ; UV6.B10 v3(168.61,115.88) UV6.C11 ; UV8.E3 v3(185.85,124.68) ; UV6.N1 176.36,124.28 v3(176.63,124.55) ; UV6.G10 v3(169.41,119.08) UV6.F10 ; v3(91.07,79.58) 92.08,79.58 CPU1.AP54 ; v3(214.71,89.56) UV12.C3 ; CPU1.AJ48 v3(96.52,83.4) ; CPU1.P54 92,93.25 v3(91.95,93.25) ; CPU1.BA51 CPU1.BA52 93.67,74.9 93.17,74.9 CPU1.BA53 93.05,75.02 93.04,75.02 v3(92.71,75.34) ; v3(93.42,88.41) 93.77,88.06 CPU1.AB52 93.39,87.62 v3(93.39,87.6) ; UV12.H2 v3(218.71,87.96) UV12.H1 ; UV15.H1 v3(218.71,69.92) UV15.H2 ; UV6.T5 172.59,126.68 v3(172.47,126.79) ; v3(111.7,70.74) 111.38,71.06 CPU1.BF26 110.95,71.91 110.95,73.16 CPU1.BC26 ; UV12.D10 v3(216.31,94.36) ; CPU1.AT1 128.84,79.32 v3(128.84,79.65) 128.84,79.71 CPU1.AN1 ; CPU1.E40 101.75,99.27 v3(101.4,99.62) 101.74,99.97 CPU1.D40 ; CPU1.AT12 120.48,78.48 v3(120.16,78.81) 120.55,79.2 CPU1.AR12 ; CPU1.AT50 95.17,78.19 v3(94.82,77.84) 94.47,78.19 CPU1.AT51 ; v3(194.74,120.34) 194.72,120.34 194.66,120.28 UV8.K14 UV8.K13 ; CPU1.AR7 123.95,78.7 v3(123.94,78.68) ; CPU1.AR7 123.95,79.58 CPU1.AP7 123.63,80.28 CPU1.AN7 ; CPU1.AR7 CPU1.AR8 CPU1.AR9 ; UV8.R14 194.64,116.28 v3(194.73,116.19) ; UV8.C12 v3(192.25,126.28) UV8.C11 ; 116.34,72.88 CPU1.BD18 ; 116.34,72.88 v3(116.68,73.22) 116.31,73.58 CPU1.BC18 116.19,73.65 116.19,74.22 CPU1.BB18 116.36,74.28 116.55,74.48 116.87,74.48 CPU1.BB17 ; 116.34,72.88 116.35,72.88 v3(116.69,72.55) ; v3(93.37,93.31) 93.77,92.91 CPU1.P52 ; UV8.A12 v3(192.25,127.88) ; CPU1.AT15 118.69,78.56 v3(118.69,79.02) ; CPU1.AB53 93.07,88.06 v3(92.72,88.41) ; CPU1.BB6 124.57,74.28 v3(124.85,74) 125.25,73.61 CPU1.BC5 ; CPU1.BB6 123.9,73.75 123.74,73.75 CPU1.BC7 123.57,73.57 v3(123.24,73.23) ; UV8.F5 v3(187.45,123.08) UV8.G5 ; CPU1.F49 96.26,98.57 v3(95.89,98.2) 96.22,97.87 CPU1.G49 ; CPU1.AA5 125.42,88.51 125.8,88.89 v3(125.77,88.89) 125.8,88.86 125.8,88.84 126.12,88.51 CPU1.AA4 CPU1.AA3 ; v3(124.19,87) CPU1.AC7 ; v3(216.31,70.72) UV15.E3 ; v3(216.31,95.96) UV12.E12 ; v3(125.77,84.8) 125.42,85.15 CPU1.AF5 ; v3(95.51,89.18) 95.51,89.29 CPU1.W50 ; CPU1.BC52 93.58,73.58 v3(93.58,73.26) 93.2,72.88 CPU1.BD53 ; UM4.6 221.69,114.28 221.82,114.15 221.82,113.16 221.43,112.77 v3(221.35,112.77) ; CPU1.BE41 101.69,72.18 v3(102.03,71.84) 101.67,71.48 CPU1.BF41 ; v3(121.12,78.73) 121.33,78.73 CPU1.AT10 ; CPU1.AW46 98.35,76.11 98.75,76.11 CPU1.AW45 99.19,76.38 v3(99.53,76.73) ; 124.84,74 125.12,74.28 CPU1.BB5 ; CPU1.AR20 114.82,78.84 v3(114.54,78.84) 114.89,78.48 CPU1.AT20 ; CPU1.W54 92.37,89.63 v3(91.96,90.03) ; UV8.A3 v3(185.85,127.88) ; v3(216.6,80.5) 216.71,80.4 UV15.E14 ; CPU1.AT9 122.55,78.52 CPU1.AR9 ; UV15.K14 v3(221.11,79.52) UV15.K13 ; v3(94.12,88.41) 94.47,88.06 CPU1.AB51 ; v3(108.53,102.5) 108.53,102.43 108.88,102.08 CPU1.A30 ; v3(94.82,82.73) 95.17,83.08 CPU1.AJ50 ; v3(216.31,88.76) UV12.E3 ; v3(224.71,87.04) UV12.R1 ; CPU1.AN2 127.52,80.3 127.18,79.95 v3(127.15,79.95) 127.14,79.95 126.82,80.27 CPU1.AN3 ; CPU1.BB33 106.57,74.36 107.24,74.36 CPU1.BB32 ; CPU1.BC50 95.1,73.4 v3(94.5,73.4) 94.5,73.03 CPU1.BD51 ; CPU1.BB54 CPU1.BA54 92.37,74.95 92.04,75.27 v3(91.78,75.27) ; CPU1.AT29 CPU1.AU29 ; CPU1.AU29 109.43,77.78 109.65,77.56 v3(109.82,77.56) ; CPU1.AU29 109.19,77.78 v3(108.84,77.43) 109.19,77.08 CPU1.AV29 ; v3(130.01,81.41) 129.5,81.92 128.26,81.92 CPU1.AL1 ; v3(167.01,117.48) UV6.E12 ; UV7.U1 165.41,127.88 v3(165.41,127.88) ; CPU1.E52 93.93,99.15 94.58,99.15 CPU1.E51 CPU1.F51 94.62,98.52 v3(94.24,98.13) ; v3(180.68,141.02) 180.68,141.02 UE8.23 ; 124.19,92.8 CPU1.P7 ; CPU1.M50 v3(95.52,94.85) ; UV15.A3 v3(213.11,70.72) ; UV8.N3 v3(185.85,117.48) ; v3(216.31,77.92) UV15.E12 ; CPU1.BF50 95.13,71.1 v3(95.3,70.94) 95.83,71.47 CPU1.BF49 96.13,71.19 96.4,71.19 CPU1.BF48 ; UV8.U14 194.41,114.68 194.66,114.93 v3(194.73,114.93) ; CPU1.AW9 122.61,76.38 122.93,76.71 v3(122.93,76.72) 122.93,76.72 122.56,77.08 CPU1.AV9 ; 165.91,120.38 v3(165.41,119.88) ; 165.91,120.38 UV7.H1 ; UV6.E1 v3(175.81,117.48) ; UV12.U14 225.94,98.33 v3(225.94,98.39) ; CPU1.AN5 125.42,80.27 v3(125.77,79.92) 125.77,79.98 CPU1.AN4 ; CPU1.H44 99.38,97.17 v3(99.03,96.82) 99.38,96.47 CPU1.J44 ; v3(226.31,69.01) UV15.U1 ; CPU1.D11 120.93,99.97 v3(120.59,99.63) 120.88,99.34 120.97,99.34 CPU1.E11 ; v3(177.83,133.28) 177.83,133.91 178.18,134.27 UE8.7 ; v3(128.68,88.82) 128.59,88.82 CPU1.AA1 CPU1.AA2 ; v3(92.71,85.94) 92.37,86.29 CPU1.AD54 ; v3(215.11,69.01) UV15.C1 ; CPU1.E53 CPU1.E54 v3(91.81,99.21) ; JHDD1.11 161.95,26.52 160.7,26.52 v3(160.63,26.46) ; v3(165.47,114.09) 165.47,114.33 UV7.A1 ; UV15.A1 v3(213.11,69.12) ; CPU1.BF22 113.82,71.25 v3(113.55,70.98) ; UV6.L5 v3(172.41,122.68) ; CPU1.BB49 95.94,74.28 v3(96.26,73.96) 96.42,73.96 CPU1.BB48 ; CPU1.AB50 95.17,88.06 v3(94.82,88.41) ; CPU1.AH50 95.17,83.99 v3(94.82,84.34) ; v3(125.79,91.32) 125.79,91.23 CPU1.U4 126.27,90.75 126.68,90.75 CPU1.U3 ; v3(97.14,73.19) 97.14,73.22 97.09,73.22 96.75,73.56 CPU1.BC48 ; UV12.C14 215.08,97.98 v3(215.08,98.54) ; v3(226.31,87.04) UV12.U1 ; v3(223.51,77.92) 223.51,77.92 UV15.N12 ; UV6.R4 v3(174.21,126.28) UV6.R3 ; CPU1.AR50 95.17,79.14 v3(95.52,79.49) ; CPU1.C49 96.25,100.67 v3(95.91,101.01) 96.27,101.37 CPU1.B49 ; CPU1.BF30 108.94,70.8 109.19,70.55 v3(109.36,70.55) ; UV15.D10 v3(216.31,76.32) ; v3(167.81,123.83) 167.81,123.88 UV6.N12 ; UH1.B35 229.17,43.26 v3(229.11,43.21) ; CPU1.AR16 117.83,79.02 v3(117.29,79.02) 116.79,79.02 CPU1.AR18 ; CPU1.BD2 127.46,72.88 127.17,73.17 v3(127.17,73.31) 126.81,73.68 CPU1.BC3 ; UV12.G10 217.87,94.32 v3(217.87,94.38) 217.87,94.39 UV12.F10 ; v3(165.3,116.28) UV7.C1 ; CPU1.AR24 112.24,79 v3(111.83,79) 111.38,79 111.19,79.2 CPU1.AR26 ; v3(226.71,71.52) UV15.U3 ; CPU1.AG50 95.17,84.8 v3(94.82,85.15) 94.47,84.8 CPU1.AG51 ; UV6.E3 v3(175.01,118.28) ; CPU1.AH3 126.39,83.15 125.8,83.15 CPU1.AK5 125.42,82.71 v3(125.77,82.36) ; UV6.L10 v3(169.41,123.08) UV6.M10 ; UV8.P10 v3(190.65,116.68) ; CPU1.AT33 106.38,78.48 v3(106.1,78.21) 106,78.21 105.72,78.48 CPU1.AT35 ; UV8.C14 v3(194.65,126.28) ; v3(167.81,127.88) UV6.U12 ; CPU1.E33 106.47,99.27 v3(106.12,99.62) 106.47,99.97 CPU1.D33 ; CPU1.A49 96.27,102.11 v3(95.86,102.52) CPU1.A50 ; v3(213.11,96.76) UV12.A12 ; UV12.T10 v3(225.91,95.16) ; v3(225.11,71.52) UV15.R3 ; UV15.A12 v3(213.11,78.72) ; UV15.P10 v3(224.31,76.32)
  BOTTOM w0.279: v3(213.63,11.51) 213.63,11.66 213.15,12.14 JSSD2.31 ; CPU1.G26 111.24,97.8 v3(111.7,98.26) 111.94,98.02 CPU1.G25
  BOTTOM w0.305: PR558.1 138.08,118.52 138.2,118.39 ; UV1.AP2 172.4,68.77 v3(172.4,68.8) ; UV1.B22 v3(199,84.38) ; JSSD4.13 v3(168.15,10.89) ; v3(184.72,106.05) 184.9,105.87 184.9,105.28 UV1.W48 v3(184.4,104.78) ; v3(128.77,97.48) 128.24,97.48 CPU1.G1 128.22,97.51 CPU1.F2 ; JSSD2.25 214.65,11.75 v3(214.41,11.51) ; JSSD3.25 v3(188.65,11.84) ; v3(160.63,25.11) 161.05,25.53 JHDD1.13 ; JSSD4.49 159.15,11.25 v3(158.75,10.85) ; CPU1.AT8 123.12,78.15 v3(122.97,78.15) 122.85,78.15 CPU1.AT9 ; v3(162.3,10.91) 162.15,11.06 JSSD4.37 ; CPU1.AU9 122.56,77.78 v3(122.91,77.43) ; v3(233.48,11.5) 233.48,11.5 233.65,11.67 JSSD1.43 ; v3(166.35,10.87) 166.65,11.18 JSSD4.19 ; JWLAN1.18 172.91,31.78 v3(172.68,32.02) ; JSSD2.67 204.15,11.79 v3(204.22,11.72) ; v3(167.51,24.78) 167.25,25.03 JWLAN1.37 ; v3(240.67,11.52) 241.15,12 JSSD1.13 ; CPU1.AD9 v3(121.92,86.3) ; v3(154.46,10.9) 154.65,11.09 JSSD4.67 ; JWLAN1.49 165.5,22.03 v3(165.23,22.3) ; JSSD2.43 210.15,12.06 209.81,11.71 v3(209.81,11.51) 209.02,11.51 208.65,11.88 JSSD2.49 ; v3(168.9,35.71) 168.82,35.63 168.04,35.63 167.63,36.03 JWLAN1.1 ; UV1.AL15 172.44,78.34 v3(172.5,78.34) 172.5,78.28 UV1.AK14 ; v3(211.65,11.51) 211.65,11.77 211.65,11.77 JSSD2.37 ; v3(174.87,68.85) 175.2,68.52 UV1.AL2 ; JHDD1.4 160.96,30.03 160.77,30.22 v3(160.44,30.22) ; JSSD2.11 v3(220.15,11.84) ; JSSD1.31 236.65,12.12 237.25,11.52 v3(238.15,11.52) JSSD1.25 ; v3(122.02,90.65) CPU1.V9 ; UV1.P32 v3(188.58,96.2) ; v3(164.51,14.34) 164.31,14.15 163.88,14.15 163.65,13.92 JSSD4.31 ; CPU1.AK9 122.01,82.58 v3(122.01,82.16) ; JWLAN1.67 165.42,17.53 v3(164.85,16.96) ; v3(178.02,11.43) 178.15,11.57 JSSD3.67 ; JSSD4.5 172.15,11.08 v3(172.28,10.95) 172.65,11.32 JSSD4.3 ; JWLAN1.61 167.15,19.03 v3(167.43,19.31) ; v3(182,104.78) UV1.AB48 v3(182.4,105.68) ; JHDD1.19 161.16,22.53 v3(160.96,22.33) 161.26,22.03 JHDD1.20 ; UV1.AM14 170.77,77.55 v3(170.32,77.55) ; v3(192.4,71.18) UV1.K5 ; v3(231.9,11.46) 232.15,11.71 JSSD1.49 ; v3(170.92,11.08) 170.92,11.39 170.65,11.66 JSSD4.11 ; JSSD4.65 v3(155.15,10.9) 155.16,10.91 155.16,10.95 155.65,11.44 JSSD4.63 ; UV1.AP11 173.17,75.41 v3(173.17,75.23) 172.8,74.86 UV1.AP9 UV1.AP8 ; CPU1.D2 127.52,100 v3(127.87,100.35) ; JSSD1.3 v3(245.65,11.46) 245.3,11.46 245.15,11.61 JSSD1.5 ; 178.93,11.39 v3(178.93,11.43) ; 178.93,11.39 179.15,11.61 JSSD3.63 ; 178.93,11.39 178.86,11.39 178.65,11.6 JSSD3.65 ; JHDD1.17 160.79,23.53 v3(160.66,23.66) ; JWLAN1.43 167.35,23.53 v3(167.5,23.38) ; JSSD3.11 194.15,11.63 193.45,10.92 193.03,10.92 193.02,10.91 v3(193.02,10.9) ; v3(190.87,11.83) 191.38,11.83 191.65,12.1 JSSD3.13 ; JSSD4.25 165.15,10.93 v3(165.18,10.9) ; JDIMM2.63 97.25,23.77 97.25,23.54 v3(97.31,23.48) ; UV1.AP45 v3(172.4,102.38) ; CPU1.AG9 122.13,84.2 v3(121.78,84.55) ; JSSD4.43 160.65,12.16 160.39,11.9 v3(160.39,10.86) ; v3(183.91,11.83) 184.15,12.07 JSSD3.43 ; v3(182.8,102.38) UV1.AB45 ; JSSD3.19 v3(190.15,11.84) ; v3(167.45,26.42) 167.34,26.53 JWLAN1.31 ; JSSD3.49 182.65,11.93 v3(182.76,11.83) ; v3(122.01,89.25) CPU1.Y9 ; JSSD3.3 196.15,11.76 v3(195.91,11.52) 195.65,11.78 JSSD3.5 ; JWLAN1.25 165.5,28.03 v3(165.15,27.69) ; JSSD3.37 v3(185.65,15.28) ; v3(215.95,11.51) 216.15,11.71 JSSD2.19 ; JSSD1.11 243.65,12.22 v3(242.89,11.46) ; JSSD2.65 204.65,12.1 204.99,11.76 v3(204.99,11.72) 205.15,11.88 JSSD2.63 ; v3(190.2,97.78) UV1.N39 ; JWLAN1.7 v3(165.1,34.53) ; UV1.AL8 UV1.AL9 175.2,74.98 v3(174.8,75.38) UV1.AL11 ; JSSD2.13 217.65,12.12 217.86,11.91 v3(218.38,11.91) ; v3(162.65,31.99) 162.65,31.73 162.45,31.53 JHDD1.1 ; CPU1.G23 113.52,97.74 v3(113.14,98.11) ; v3(164.64,22.3) 164.64,21.43 165.54,20.53 JWLAN1.55 ; CPU1.F5 125.16,98.48 125.19,98.45 125.19,97.93 v3(125.07,97.82) ; JSSD1.63 228.65,12.11 229.05,11.71 v3(229.05,11.5) ; JHDD1.7 v3(160.92,28.53) ; CPU1.G20 115.09,97.8 v3(115.28,97.98) 115.46,97.8 CPU1.G19 116.18,97.48 CPU1.G18 ; v3(121.99,87.8) CPU1.AB9 ; v3(122.05,95) CPU1.L9 ; JSSD1.37 v3(235.15,14.19) ; JSSD3.31 v3(187.15,11.83) ; UV1.N45 v3(190,102.38) ; v3(228.39,11.5) 228.15,11.74 JSSD1.65 228.15,13.88 228.03,14 227.78,14 227.65,13.87 JSSD1.67 ; JSSD1.19 v3(239.65,11.52) ; v3(185.2,102.38) UV1.W45 ; v3(121.67,92.8) CPU1.P9
  BOTTOM w0.33: v3(125.98,34.56) 124.94,33.52 124.94,32.54 123.94,31.54 JDIMM1.144
  BOTTOM w0.35: UV1.Y32 v3(183.5,95.28) UV1.W31 v3(184.5,94.28) UV1.V30 UV1.U29 v3(186.5,92.28) UV1.T28 v3(187.5,91.28) UV1.R27 v3(188.5,90.28) UV1.P26 ; UV1.P28 v3(188.5,92.28) UV1.R29 187.5,93.28 UV1.T30 v3(186.5,94.28) UV1.U31 v3(185.5,95.28) UV1.V32 ; UV1.AL31 v3(172.5,94.28) UV1.AK30 v3(173.5,93.28) UV1.AJ29 v3(174.5,92.28) UV1.AH28 175.46,91.32 v3(175.46,91.27) 175.95,90.78 UV1.AG27 v3(176.5,90.28) UV1.AF26 UV1.AE25 178.5,88.28 UV1.AD24 v3(179.5,87.28) UV1.AC23 v3(180.5,86.28) UV1.AB22 181.5,85.28 UV1.AA21 UV1.Y20 v3(183.5,83.28) UV1.W19 v3(184.5,82.28) UV1.V18 UV1.U17 v3(186.5,80.28) UV1.T16 v3(187.5,79.28) UV1.R15 v3(188.5,78.28) UV1.P14 ; UV1.AF32 v3(177.5,95.28) UV1.AE31 v3(178.5,94.28) UV1.AD30 v3(179.5,93.28) UV1.AC29 v3(180.5,92.28) UV1.AB28 UV1.AA27 UV1.Y26 183.5,89.28 UV1.W25 UV1.V24 v3(185.5,87.28) UV1.U23 v3(186.5,86.28) UV1.T22 v3(187.5,85.28) UV1.R21 v3(188.5,84.28) UV1.P20 ; UV1.AH32 v3(175.5,95.28) UV1.AG31 v3(176.5,94.28) UV1.AF30 177.5,93.28 UV1.AE29 UV1.AD28 v3(179.5,91.28) UV1.AC27 v3(180.5,90.28) UV1.AB26 181.5,89.28 UV1.AA25 v3(182.5,88.28) UV1.Y24 v3(183.5,87.28) UV1.W23 184.5,86.28 UV1.V22 UV1.U21 v3(186.5,84.28) UV1.T20 187.5,83.28 UV1.R19 v3(188.5,82.28) UV1.P18 ; UV1.V14 v3(184.5,78.28) UV1.W15 v3(183.5,79.28) UV1.Y16 UV1.AA17 UV1.AB18 181,81.78 180.5,82.28 v3(180.5,82.28) UV1.AC19 v3(179.5,83.28) UV1.AD20 v3(178.5,84.28) UV1.AE21 v3(177.5,85.28) 177,85.78 ; UV1.AF14 v3(176.5,78.1) UV1.AG15 UV1.AH16 UV1.AJ17 v3(173.5,81.28) UV1.AK18 v3(172.5,82.28) UV1.AL19 v3(171.5,83.28) UV1.AM20 ; UV1.P22 v3(188.5,86.28) UV1.R23 ; UV1.AB32 v3(181.5,95.28) UV1.AA31 v3(182.5,94.28) UV1.Y30 v3(183.5,93.28) UV1.W29 v3(184.5,92.28) UV1.V28 UV1.U27 v3(186.5,90.28) UV1.T26 187.5,89.28 UV1.R25 ; UV1.AL15 v3(171.5,79.28) UV1.AM16 ; UV1.AJ27 v3(173.5,91.28) UV1.AK28 UV1.AL29 v3(171.5,93.28) UV1.AM30 ; UV1.AE19 UV1.AD18 v3(179.5,81.28) UV1.AC17 v3(180.5,80.28) UV1.AB16 UV1.AA15 v3(182.5,78.28) UV1.Y14 ; v3(176.5,84.28) UV1.AG21 v3(175.45,85.33) UV1.AH22 UV1.AJ23 v3(173.5,87.28) UV1.AK24 v3(172.5,88.28) UV1.AL25 v3(171.5,89.28) UV1.AM26 ; UV1.P30 v3(188.5,94.28) UV1.R31 v3(187.5,95.28) UV1.T32 ; UV1.P24 v3(188.5,88.28) ; UV1.AM28 v3(171.5,91.28) UV1.AL27 UV1.AK26 v3(173.5,89.28) UV1.AJ25 v3(174.5,88.28) UV1.AH24 v3(175.5,87.28) UV1.AG23 v3(176.5,86.28) 177,85.78 ; v3(175.46,89.26) 175.52,89.26 UV1.AG25 v3(176.5,88.28) UV1.AF24 v3(177.5,87.28) UV1.AE23 178.5,86.28 UV1.AD22 v3(179.5,85.28) UV1.AC21 v3(180.5,84.28) UV1.AB20 UV1.AA19 UV1.Y18 v3(183.5,81.28) UV1.W17 v3(184.5,80.28) UV1.V16 v3(185.5,79.28) UV1.U15 v3(186.5,78.28) UV1.T14 ; UV1.AD32 v3(179.45,95.38) UV1.AC31 UV1.AB30 UV1.AA29 UV1.Y28 v3(183.5,91.28) UV1.W27 v3(184.5,90.28) UV1.V26 UV1.U25 v3(186.5,88.28) ; 177,85.78 UV1.AF22 ; UV1.AH14 v3(174.5,78.28) UV1.AJ15 v3(173.5,79.28) UV1.AK16 UV1.AL17 v3(171.5,81.28) UV1.AM18 ; UV1.AB14 v3(180.5,78.18) UV1.AC15 v3(179.5,79.28) UV1.AD16 UV1.AE17 UV1.AF18 v3(176.5,82.28) UV1.AG19 v3(175.5,83.28) UV1.AH20 UV1.AJ21 v3(173.5,85.28) UV1.AK22 UV1.AL23 v3(171.5,87.28) UV1.AM24 ; UV1.AK32 v3(173.5,95.28) UV1.AJ31 v3(174.5,94.28) UV1.AH30 UV1.AG29 UV1.AF28 UV1.AE27 UV1.AD26 v3(179.5,89.28) UV1.AC25 v3(180.5,88.28) UV1.AB24 181.5,87.28 UV1.AA23 v3(182.5,86.28) UV1.Y22 v3(183.5,85.28) UV1.W21 v3(184.5,84.28) UV1.V20 v3(185.5,83.28) UV1.U19 v3(186.5,82.28) UV1.T18 187.5,81.28 UV1.R17 v3(188.5,80.28) UV1.P16 ; UV1.AD14 v3(178.5,78.28) UV1.AE15 v3(177.5,79.28) UV1.AF16 v3(176.5,80.28) UV1.AG17 v3(175.5,81.28) UV1.AH18 UV1.AJ19 v3(173.5,83.28) UV1.AK20 UV1.AL21 v3(171.5,85.28) UV1.AM22
  BOTTOM w0.356: 97.85,27.14 JDIMM2.65 ; 97.85,27.14 96.97,27.14 96.65,26.83 JDIMM2.61 ; 97.85,27.14 v3(97.86,27.14) ; v3(119.26,16.21) 119.26,16.37 119.15,16.47 JDIMM2.128 ; JDIMM1.43 91.24,39.85 90.88,40.22 89.26,40.22 89.24,40.24 89.22,40.24 ; JDIMM2.2 78.95,16.58 v3(79.31,16.22) ; JDIMM1.170 131.74,29.34 131.45,29.05 v3(131.32,29.05) 131.24,29.05 131.15,29.15 JDIMM1.168 ; v3(87.13,40.2) 87.62,39.71 87.64,39.71 JDIMM1.31 ; UV1.R25 v3(188.5,88.28) ; v3(95.13,32.8) 94.54,32.22 JDIMM1.54 ; JDIMM1.162 129.34,29.42 129.14,29.22 v3(128.94,29.22) 127.9,29.22 127.54,29.57 JDIMM1.156 ; JDIMM1.178 134.15,29.14 v3(134.13,29.12) 134.15,29.11 135.64,29.11 135.95,29.42 JDIMM1.184 ; v3(121.98,32.92) 122.14,32.83 JDIMM1.138 ; JDIMM2.179 134.45,27.31 134.06,27.7 v3(133.31,27.7) 132.96,27.7 132.65,27.39 JDIMM2.173 ; v3(84.05,16.21) 84.35,16.51 JDIMM2.20 ; JDIMM1.32 87.94,29.38 v3(88.18,29.14) 89.37,29.14 89.75,29.51 JDIMM1.38 ; JDIMM2.187 v3(136.85,27.62) 136.25,27.02 JDIMM2.185 ; v3(118.69,79.02) 119.25,79.02 CPU1.AR14 ; JDIMM1.25 85.84,40.12 86.52,40.8 v3(87.2,40.8) ; JDIMM2.172 132.35,16.63 132.35,16.39 v3(132.65,16.09) ; JDIMM2.161 129.05,27.7 v3(129,27.76) 130.13,27.76 130.85,27.04 JDIMM2.167 ; v3(94.74,16.22) 94.55,16.41 JDIMM2.54 ; v3(139.45,16.07) 139.45,16.55 139.55,16.65 JDIMM2.196 ; JDIMM1.60 96.34,32.07 v3(96.67,32.4) ; UV1.AE19 UV1.AF20 v3(176.5,84.28) ; JDIMM1.187 136.85,40.05 137.36,40.57 v3(137.43,40.57) 138.37,40.57 139.24,39.69 139.24,39.51 JDIMM1.195 ; JDIMM1.145 124.24,40 123.77,40.47 v3(123.03,40.47) 122.9,40.47 122.44,40.01 122.44,39.94 JDIMM1.139 ; v3(86.04,27.65) 86.04,27.08 85.85,26.88 JDIMM2.25 ; v3(89.61,16.18) 89.75,16.32 JDIMM2.38 ; v3(84.05,27.65) 84.05,27.04 JDIMM2.19 ; v3(138.31,16.07) 137.75,16.62 JDIMM2.190 ; JDIMM1.3 79.24,40.2 78.81,40.64 v3(78.81,40.64) ; v3(95.69,23.1) 94.85,23.94 JDIMM2.55 ; v3(92.24,33.07) 91.54,32.37 JDIMM1.44 ; v3(97.48,16.18) 97.68,16.18 98.15,16.65 JDIMM2.66 ; v3(143.39,141.44) 143.4,141.43 JDP1.14 ; JDIMM2.151 126.05,26.76 126.05,27.24 v3(126.46,27.65) 126.65,27.46 126.65,27.05 JDIMM2.153 ; v3(125.98,36.08) 126.64,36.75 JDIMM1.153 ; JDIMM1.19 84.04,40.02 v3(83.89,40.17) 83.84,40.22 82.55,40.22 82.24,39.92 JDIMM1.13 ; CT4.1 199.73,132.6 200.34,132.6 200.51,132.77 U2410.5 ; JDP1.8 141.6,141.09 v3(141.3,141.39) ; v3(175.46,89.26) 175.46,89.32 UV1.AH26 UV1.AJ27 ; JDIMM2.195 139.25,26.7 139.25,27.17 138.79,27.64 v3(138.53,27.64) 138.23,27.64 137.45,26.86 137.45,26.68 JDIMM2.189 ; v3(85.83,16.18) 85.83,16.34 86.15,16.67 JDIMM2.26 ; JDIMM1.133 120.64,37.69 120.84,37.49 120.84,36.9 v3(120.29,36.35) ; JDIMM2.156 127.55,16.33 v3(127.29,16.07) ; v3(131.34,40.59) 130.85,40.11 130.84,40.11 JDIMM1.167 ; v3(89.21,40.24) 89.22,40.24 ; 89.22,40.24 89.44,40.01 JDIMM1.37 ; v3(81.86,16.18) 82.12,16.18 82.55,16.61 JDIMM2.14 ; JDIMM2.43 91.25,23.7 v3(91.47,23.48) ; JDIMM2.44 91.55,16.34 v3(91.39,16.18) ; JDIMM2.145 124.25,26.85 124.25,27.18 123.71,27.71 v3(123.52,27.71) 123.07,27.71 122.45,27.1 122.45,26.97 JDIMM2.139 ; v3(84.2,29.11) 84.34,29.25 JDIMM1.20 ; JDIMM2.48 92.75,16.46 v3(92.47,16.18) 92.15,16.5 JDIMM2.46 ; JDIMM2.9 81.05,24.08 v3(80.45,23.48) ; JDIMM1.161 129.04,40.11 130.12,41.18 v3(131.34,41.18) ; JDIMM1.150 125.74,29.43 125.74,29.24 125.96,29.02 v3(126.46,29.02) 127.25,28.23 127.25,27.2 JDIMM2.155 ; JDIMM1.72 99.94,29.55 99.56,29.17 v3(99.12,29.17) 98.43,29.17 98.15,29.46 JDIMM1.66 ; v3(102.03,73.25) 101.67,72.88 CPU1.BD41 ; JDIMM2.37 89.45,26.71 89.45,27.09 88.84,27.7 v3(88.18,27.7) 87.65,27.16 87.65,26.97 JDIMM2.31 ; JDIMM1.172 132.34,32.97 v3(132.3,33.08) ; v3(92.39,27.64) 92.65,27.64 93.05,27.24 93.05,26.87 JDIMM2.49 ; JDIMM1.11 81.64,39.85 81.64,40.11 81.45,40.31 v3(81.09,40.31) 81.05,40.27 JDIMM1.9 ; JDIMM2.13 82.25,27.25 82.25,27.48 v3(82.16,27.57) 81.65,27.07 81.65,27 JDIMM2.11 ; JDIMM1.190 137.74,31.66 138.2,32.12 v3(138.2,33.14) ; JDIMM2.3 79.25,26.76 79.25,27.15 v3(78.7,27.7) ; JDIMM2.184 135.95,16.33 v3(136.21,16.07) ; JDIMM1.65 97.85,37.42 97.28,36.86 97.28,36.53 v3(97.96,35.85) ; JKB1.1 111.35,12.2 v3(110.91,12.64) ; JDIMM1.63 97.24,37.55 96.67,36.98 v3(96.67,34.7) ; JDIMM1.71 99.64,37.61 99.9,37.35 v3(100.71,37.35) ; JDIMM1.55 94.84,39.9 93.69,41.05 v3(92.59,41.05) 92.57,41.03 92.57,40.4 93.04,39.92 JDIMM1.49 ; v3(80.46,33.14) 80.74,32.85 JDIMM1.8 ; JDIMM2.162 129.35,16.19 v3(129.23,16.07) ; JDIMM1.151 126.04,40.42 125.4,41.06 v3(123.03,41.06) ; v3(186.5,88.28) UV1.T24 UV1.R23 ; JDIMM2.170 131.75,16.42 v3(131.39,16.07) 131.15,16.31 JDIMM2.168 ; JDIMM2.8 v3(80.75,16.21) ; v3(140.04,32.02) 139.54,31.53 JDIMM1.196 ; JDIMM1.2 78.94,31.7 v3(78.66,31.99) ; JDIMM1.128 119.15,29.54 119.61,29.07 v3(120.94,29.07) ; 124.84,74 v3(124.85,74) ; v3(95.13,34.32) 95.32,34.32 95.82,34.83 95.82,36.92 96.64,37.74 JDIMM1.61 ; v3(120.94,29.07) 121.31,29.07 121.55,29.31 JDIMM1.136 ; v3(120.94,29.07) JDIMM1.134 ; v3(134.05,36.38) 134.69,37.01 134.69,37.3 134.44,37.54 JDIMM1.179 ; v3(136.93,36.6) 137.61,37.27 137.61,37.43 137.44,37.59 JDIMM1.189 ; JDIMM2.136 121.55,16.22 121.39,16.06 v3(121.39,16.07) 121.37,16.06 121.32,16.06 120.96,16.42 120.95,16.42 JDIMM2.134 ; JDIMM2.28 86.75,16.87 86.75,16.66 87.23,16.18 v3(87.31,16.18) 87.61,16.18 87.95,16.51 87.95,16.61 JDIMM2.32 ; JDIMM1.26 86.15,29.29 v3(86.02,29.16) 86.6,29.16 86.74,29.3 JDIMM1.28 ; v3(98.61,23.1) 99.65,24.13 JDIMM2.71 ; JDIMM1.14 82.54,29.55 v3(82.21,29.21) ; JDIMM1.48 92.75,29.55 v3(92.37,29.17) 92.15,29.4 JDIMM1.46 ; JDIMM2.138 122.15,16.4 122.15,16.3 v3(122.38,16.07) ; JDIMM2.150 125.75,16.89 125.75,16.39 125.43,16.07 v3(124.72,16.07) 124.23,16.07 123.95,16.35 JDIMM2.144 ; JDIMM2.72 99.95,16.6 99.49,16.14 v3(99.39,16.14) ; JDIMM2.178 v3(134.15,16.07) ; JDIMM1.173 132.64,39.9 132.93,40.18 v3(133.76,40.18) 135.87,40.18 136.25,39.81 JDIMM1.185 ; JDIMM1.155 127.24,36.51 v3(127.29,36.46) ; JDIMM2.127 118.85,26.93 118.85,27.25 119.26,27.65 v3(119.7,27.65) 120.08,27.65 120.65,27.08 120.65,26.76 JDIMM2.133 ; JDIMM2.60 96.35,16.23 v3(96.41,16.18)
  BOTTOM w0.381: v3(184.68,111.2) 184.68,111.14 RV108.2 ; RM6.1 197.08,137.83 UM3.3 ; UV3.8 150.57,141.82 v3(150.24,142.15) ; QE12.1 167.14,136.39 167.78,135.75 v3(167.82,135.75) ; CT5.2 250.97,39.03 250.69,38.75 UT2.4 ; v3(241.44,39.09) 241.78,38.75 UT2.25 ; UM7.3 159.69,139.14 159.03,138.48 v3(159.03,137.86) ; UT2.18 241.77,34.2 241.35,33.78 v3(241.35,33.57) ; v3(181.55,141.78) 181.3,141.78 180.68,141.16 v3(180.68,141.02) ; v3(141.54,80.74) 141.25,81.03 UV19.3 ; DI5.3 v3(324.68,51.65) ; v3(224.55,122.26) 224.55,121.9 224.29,121.63 UM4.19 ; v3(12.13,12.73) 11.29,12.73 10.99,13.03 QA14.4 ; UT2.8 v3(247.09,36.15) ; UV3.15 154.47,146.75 154.03,147.19 154.03,147.36 CV23.2 ; CT6.2 250.97,34.52 250.65,34.2 UT2.11 ; v3(218.28,82.22) 218.28,82.54 217.74,83.08 RV166.2 RV161.2 ; UM4.15 221.69,121.55 221.49,121.74 v3(221.49,122.33) ; DI3.3 v3(321.76,64.99)
  BOTTOM w0.406: QA14.1 9.69,15.48 9.78,15.57 9.78,16.12 v3(9.86,16.19) ; RV58.1 156.61,75.99 UV14.3
  BOTTOM w0.457: v3(164.15,132.3) 164.15,132.05 164.02,131.92 CM32.2 ; v3(156.16,145.11) SW1.6 ; RA55.1 13.73,19.62 v3(14.23,19.12) ; v3(238,35.14) 237.54,34.69 RH20.1 ; CM27.2 162.31,16.74 v3(162.26,16.69) ; v3(141.6,130.42) 141.27,130.09 141.27,129.94 141.16,129.82 PC510.2 ; JKB3.8 53.15,9.74 53.38,9.97 v3(54.21,9.97) ; RV146.2 210.36,87.21 v3(210.33,87.25) ; v3(161.21,145.24) SW1.5 ; PC546.1 140.71,122.26 v3(141.23,122.26) ; CA11.1 15.04,19.73 v3(14.76,19.45) ; UE1.3 261.18,30.44 v3(261.18,31.09)
  BOTTOM w0.508: QV21.3 214.27,105.92 v3(214.27,106.45) ; RM38.2 221.49,123.17 v3(221.49,122.33) ; RA111.1 9.43,34.86 v3(9.92,35.36) ; CV282.2 210.19,103.01 v3(210.32,103.15) ; PC940.2 104.68,107.28 v3(104.08,107.28) ; CV156.2 CV201.2 v3(178.95,127.57) ; v3(206.76,29.87) 206.92,29.87 207.25,29.54 RH155.2 RH122.2 ; v3(148.02,36.54) 147.75,36.27 JDIMM2.206 ; CM23.2 192.6,140.29 191.78,141.11 v3(191.78,144.24) ; v3(215.58,125.38) 215.58,125.76 215.25,126.09 C29.2 ; RV107.2 165.29,110.51 v3(164.8,110.03) ; JHDD1.22 158.05,29.75 v3(157.42,29.12) ; v3(131.45,125.44) 131.45,126.11 PC509.1 ; v3(190.18,132.71) 190.18,132.7 190.69,132.19 CV230.2 CV233.2 RV133.2 ; 87.57,103.92 87.19,103.54 v3(87.19,103.13) ; PC7.2 PC6.2 v3(68.07,49.11) ; v3(212.94,21.21) 213.35,21.62 RH158.2 ; JWLAN1.69 165.64,16.43 165.2,15.99 v3(165.2,14.35) ; v3(245.3,29.68) 244.93,29.68 244.59,30.02 PC308.2 ; CM34.2 159.03,137.19 v3(159.03,137.86) ; v3(273.88,12.99) 273.88,14.46 QE6.3 275.06,14.95 275.38,14.63 RE80.2 ; v3(202.5,127.48) 203.57,128.55 CF6.2 ; v3(8.36,32.84) 8.36,32.66 CA99.2 ; PC511.2 135.4,120.82 v3(135.46,120.82) ; v3(228.86,94.26) 229.18,94.59 CV299.2 ; JFAN2.6 237.98,42.74 v3(237.57,42.33) 237.25,42.01 CH5.2 ; v3(9.98,34.33) 9.98,34.19 RA53.1 ; v3(54.21,10.61) 53.77,10.61 53.15,11.23 JKB3.7 ; v3(286.5,8.71) 286.05,9.17 QE9.3 ; CV309.2 RV209.2 CV310.2 220.52,64.44 v3(220.92,64.04) 220.43,63.55 RV213.2 ; JSSD1.69 226.55,11.99 227.03,11.5 v3(227.65,11.5) ; QE1.3 260.32,19.09 v3(261.05,19.81) ; PC924.2 106.97,107.28 v3(107.57,107.28) ; JDIMM2.205 72.85,31.32 v3(73.22,30.95) ; v3(165.1,35.74) 165.1,36.63 165.61,37.13 JWLAN1.68 ; v3(250.7,35.59) 250.97,35.32 CT6.2 ; CZ6.2 238.91,34.2 CT8.2 v3(238.89,33.57) ; v3(164.51,14.34) 164.28,14.57 CM10.1 ; JSSD3.69 177.05,12.03 176.46,11.43 v3(176.02,11.43) ; CV272.2 CV274.2 215.03,84.85 v3(214.84,85.05) ; CE19.2 CE20.2 256.3,43.7 v3(256.28,43.72) ; CI2.2 v3(319.53,58.66) ; CT4.1 199.19,131.94 v3(199.3,131.83) ; PC979.2 104.25,105.35 ; 104.25,105.35 v3(104.27,105.37) ; 104.25,105.35 PC985.2 ; CM25.1 164.57,16.96 v3(164.85,16.96) ; CV155.2 183.99,131.59 183.99,132.18 183.97,132.19 v3(183.97,132.2) ; CV219.2 CV166.2 160.97,123.23 v3(160.61,122.86) ; v3(224.55,122.26) 224.55,122.73 224.28,123 CM16.2 CM17.2 ; JCR.16 v3(303.51,19.1) ; DI2.1 322.86,60.61 v3(323.53,60.61) ; RV546.2 110.45,135.02 v3(110.43,134.99) ; PC660.2 138.53,84.47 v3(138.55,84.46) 138.09,84 CV54.2 ; CV200.2 163.62,129.4 164.04,129.82 v3(164.04,130.01) ; v3(191.57,132.71) 191.8,132.93 CT2.2 CT3.2 ; v3(178.95,120.42) 179.32,120.05 RV121.2 ; QE4.3 270.87,15.9 v3(270.87,15.27) ; v3(234.49,31.29) 234.98,31.78 RH71.2 ; RV305.2 109.3,141.11 109.04,140.86 v3(108.52,140.86) ; RV125.2 v3(143.46,83.19) RV37.2 ; UI3.2 v3(319.09,43.52) ; v3(100.59,109.12) 99.93,109.12 PC938.2 ; v3(215.77,120.95) 215.77,120.66 215.47,120.36 Q2410.3 ; CT7.2 239.77,38.44 v3(239.18,39.03) ; CV148.2 156.22,66.69 155.48,65.94 v3(155.48,65.23) ; YV1.2 v3(171.17,63) ; RV513.2 166.84,64.06 v3(166.88,64.1) 167.09,64.31 CV74.1 ; CA95.2 v3(2.35,30.51) ; C2509.2 R180.2 211.14,120.93 v3(210.62,120.93) ; PC926.2 106.97,109.06 v3(107.57,109.06) ; CM24.1 CM11.1 155.27,16.55 v3(154.27,16.55) ; JCR.2 303.18,32.78 v3(303.5,32.46) ; JRTC1.4 265.6,7.67 v3(265.24,8.03) ; JFAN1.4 58.63,51 58.63,50.62 58.23,50.23 v3(57.71,50.23) ; JCR.21 v3(303.54,13.02) ; v3(156.94,72.32) 157.34,71.91 RV512.2 ; v3(142.69,49.37) 143.09,48.96 JDIMM1.206 ; v3(322.33,49.81) 322.33,49.75 322.07,49.49 DI4.1 ; v3(145.42,138.67) 145.42,137.45 145.62,137.25 CV35.2 ; PC986.2 107.14,106.21 v3(107.13,106.2) ; PR311.2 v3(132.59,113.4) ; v3(156.67,69.22) 156.69,69.24 RV511.2 ; v3(113.36,142.56) 112.16,142.56 111.86,142.27 CV422.2 ; RH25.2 v3(222.63,22.81) ; CV276.2 229.03,99.96 v3(228.84,100.14) ; v3(199.27,116.8) 198.52,116.06 CV213.2 CV211.2 ; v3(172.38,131.24) 172.1,131.52 CV221.2 ; v3(210.23,21.43) 210.23,21.96 RH138.2 RH132.2 ; v3(251.31,41.52) 251.73,41.94 CE57.2 ; v3(173.84,131.3) 173.95,131.19 CV304.2 ; RV18.1 RV17.2 139.88,136.04 v3(139.45,136.48) ; v3(149.77,134.38) 149.77,133.76 CM33.2 ; CV188.2 CV298.2 222,64.66 v3(222.13,64.54) ; PC982.2 104.28,106.21 v3(104.27,106.2) 104.25,106.21 PC980.2 ; CA70.2 11.89,27.65 v3(12.38,28.15) ; CV9.2 v3(86.55,119.79) ; v3(230.21,16.97) 230,17.19 RH38.1 RH24.2 ; v3(99.82,105.37) 99.85,105.35 PC981.2 ; v3(237.44,27.85) 237.38,27.92 CH4.1 ; v3(111.22,140.71) 111.52,141.01 CV429.2 111.91,140.97 RV295.2 ; v3(261.3,8.92) 261.54,9.15 JRTC1.2 ; CH10.2 v3(217.05,16.41) ; RV59.2 156.54,70.3 v3(156.66,70.41) ; CV279.2 CV278.2 v3(211.08,103.15) ; CV248.2 CV173.2 v3(178.95,125.73) ; CV23.2 v3(153.16,147.54) ; CM19.2 223.42,126.49 v3(223.42,127.23) 222.52,127.23 CE26.2 ; PR403.2 PC659.2 141.43,86.04 v3(141.11,85.73) 140.81,86.03 PR685.2 ; v3(159.51,18.58) 160,19.07 JHDD1.24 ; CM30.2 148.78,129.88 v3(148.66,129.76) ; v3(235.71,24.77) 235.42,24.47 RH70.1 ; JSSD4.68 174.25,12 174.81,11.43 v3(175.34,11.43) ; v3(156.05,138.43) 156.05,137.78 CM35.2 ; JFAN1.6 58.31,47.7 v3(56.75,49.27) ; v3(158.09,99.05) 158.09,98.6 CV95.2 ; PC300.2 239.59,27.21 239.21,27.59 v3(239.21,27.84) 239.52,28.16 PR308.2 ; v3(166.89,62.22) 166.89,61.5 167.09,61.3 YV1.4 ; RM29.2 218.89,122.68 v3(219.23,122.33) ; PC989.2 96.98,105.35 v3(97,105.37) 97.03,105.35 PC987.2 ; v3(152.12,138.44) 152.08,138.41 RM72.1 RM87.2 ; RV58.1 v3(157.34,76.06) ; v3(228.43,84.86) CV252.2 CV182.2 ; RV187.2 157.69,72.82 v3(157.24,73.27) ; RV299.2 v3(101.09,138.46) ; v3(230.42,98.57) 230.03,98.18 CV275.2 229.54,98.16 RV158.2 ; v3(154.46,10.9) 153.8,10.9 153.55,11.15 JSSD4.69 ; v3(204.61,20.58) 205.08,20.1 205.08,19.89 204.9,19.71 UH4.4 ; v3(104.51,142.37) 104.76,142.37 104.97,142.57 CV427.2 CV428.2 ; CV426.2 CV423.2 108.38,137.91 v3(108.55,137.75) ; CV377.2 148.92,137.38 CV34.2 148.92,135.59 v3(148.88,135.55) ; RV297.2 RV301.2 v3(101.08,141.73) ; RM64.2 164.14,135.77 v3(164.01,135.89) ; RV16.2 143.71,135.82 UV18.2 143.11,134.9 v3(142.95,135.05) ; v3(223.95,109.2) 224.14,109.4 224.14,111.46 RM21.1 ; CE7.2 267.51,34.29 CE60.2 268.43,35.21 v3(268.43,35.66) ; JKB3.10 57.65,12.83 v3(56.8,13.68) ; PC939.2 96.99,108.93 v3(96.52,108.93) ; RH139.2 215.29,21.16 v3(215.04,21.42) ; v3(89.17,120.35) 89.17,119.87 88.89,119.59 CV373.2 ; v3(276.37,18.25) 276.47,18.25 QE3.3 ; CH3.1 238.34,29.76 RH133.2 238.77,30.65 v3(238.08,30.65) ; v3(96.52,107.22) 96.99,107.22 PC971.2 ; v3(222.51,17.54) 222.51,16.96 223.06,16.4 RA80.2 ; CV218.2 161.18,124.32 v3(160.53,124.97) ; JKBBL1.22 126.05,12.13 126.05,12.13 124.61,13.57 v3(124.61,14.19) ; CV306.2 191.64,130 v3(191.52,129.88) ; v3(100.59,107.28) 100.05,107.28 PC942.2 ; RH51.2 227.23,17.96 v3(227.23,17.43) ; PC16.2 v3(85.42,47.04) ; v3(167.9,131.24) 167.9,130.86 168.16,130.6 RV119.2 ; v3(204.22,11.72) 204.08,11.58 203.14,11.58 203.05,11.68 JSSD2.69 ; RA112.2 v3(6.94,35.21) ; JELC1.8 185.4,16.99 v3(185.84,17.44) ; v3(62.68,55.04) 63.49,55.04 JFAN1.5 ; v3(322.39,45.24) 322.63,45 CI41.2 ; RE33.2 RE34.2 184.42,134.03 v3(184,133.61) ; v3(221.66,22.81) RH26.2 ; PC526.1 PC525.1 148.6,125.69 v3(148.99,125.69) ; v3(138.64,117.27) 138.64,117.95 138.2,118.39 ; v3(177.85,132.34) 177.85,131.71 178.22,131.35 ; RM88.1 165.47,133.91 164.9,134.48 v3(164.81,134.48) ; PC984.2 107.2,105.3 v3(107.13,105.37) ; JCR.9 301.32,25.94 v3(300.62,25.25) ; v3(99.82,106.2) 99.84,106.21 PC983.2 ; v3(160.58,120.63) 160.66,120.55 CV303.2 ; CV187.2 CV254.2 225.74,84.69 v3(225.89,84.85) ; RM25.1 CM21.2 v3(222.51,124.78) ; v3(263.72,11.47) 263.72,12.58 264.09,12.95 JRTC1.3 ; CM36.2 CM9.2 153.55,126.3 v3(153.43,126.3) ; v3(114.11,10.39) 114,10.28 JKB1.31 ; v3(95.52,12.66) 95.15,12.3 JKB1.32 ; v3(181.21,114.59) CV246.2 ; QV25.3 213.84,64.39 v3(213.08,64.39) ; CI40.2 323.59,59.74 v3(323.51,59.82) ; QE7.3 v3(265.6,16.68) ; PC662.2 v3(143.5,84.15) ; v3(196.42,136.04) 197.32,136.95 RM6.1 ; CV47.2 136,134.7 UV5.2 136.43,133.75 v3(135.99,133.31) ; CV268.2 221.55,84.36 220.61,85.3 v3(219.71,85.3) ; PR303.1 239.88,23.83 v3(239.96,23.75) ; CV73.1 170.87,64.31 v3(171.16,64.02) ; v3(248.35,11.33) 248.35,12.41 248.01,12.75 JSSD1.68 ; v3(128.82,107.53) 129.14,107.22 PR312.1 ; v3(160.83,142.94) 160.54,142.64 SW1.2 ; v3(141.2,58.68) 141.43,58.9 PC15.2 ; v3(164.68,130.65) 164.71,130.67 RM65.1 165.33,130.41 165.65,130.09 CV222.2 ; v3(218.4,111.65) 218.42,111.64 CM18.2 ; CV234.2 CV307.2 198.52,122.98 197.88,122.34 RV135.2 ; PC312.2 PR310.2 128.95,110.94 v3(128.67,110.66) ; CH26.2 v3(225.64,52.58) ; v3(319.79,56.73) 319.98,56.54 UI2.2 ; PC990.2 96.99,106.21 v3(97,106.2) 97.02,106.21 PC988.2 ; CV301.2 180.45,121.93 CV198.2 180.65,121.95 181.01,121.6 181.64,121.6 v3(181.74,121.69) ; JELC1.7 178.46,16.99 v3(179.21,16.24) ; v3(244.72,47.32) 244.72,47.67 JFAN2.5 ; v3(216.59,84.11) 216.81,83.89 CV290.2 ; v3(148.91,17.45) 148.66,17.2 C2498.2 ; SW1.1 v3(160.54,145.45) ; v3(210.5,126.25) 210.5,126.41 C2508.2 ; v3(181.21,116.37) CV247.2 ; v3(85.77,120.13) 85.77,120.72 85.24,121.25 84.44,121.25 UV17.2 ; v3(224.4,22.85) 224.49,22.94 RH18.2 ; QE10.3 174.25,133.61 173.76,133.12 v3(173.76,132.74) ; v3(140.59,133.29) 140.76,133.12 PR528.2 ; RV111.2 202.7,93.07 v3(202.83,93.2) ; PC937.2 104.74,109.12 v3(104.08,109.12) ; JHDD1.23 v3(158.05,24.46) ; v3(318.98,53.68) CI4.2 CI5.2 ; CA3.2 15.06,18.01 v3(15.1,18.05) ; CI28.2 CI29.2 v3(319.08,40.6) ; v3(191.04,138.42) 190.74,138.71 RM17.1 ; v3(298.39,35.05) 298.39,35.88 298.82,36.31 CR14.2 ; v3(199.2,115.03) 199.12,115.11 CV211.2 ; v3(133.77,113.57) PC313.2 ; RH79.2 228.97,48.91 v3(228.74,48.68) ; v3(178.62,114.59) CV228.2 ; CE59.2 CE10.2 CE4.1 262.39,31.64 v3(262.51,31.64) ; RE41.2 v3(184.42,136.87) CE53.2 ; v3(187.52,110.41) 187.51,110.41 187.27,110.17 RV79.1 RV78.1 188.69,109.66 189.11,109.24 RV112.2 ; v3(214.56,53.52) 215.32,52.76 YH2.2 ; v3(224.87,82.59) CV295.2 CV267.2 ; v3(151.34,128.79) 150.95,128.41 RM84.1 RM70.1 ; v3(156.28,148.17) 156.67,147.78 CV376.2 ; PR306.2 241.47,30.08 v3(241.47,31.02) ; RV293.1 103.05,138.18 v3(102.85,137.97) ; UE2.4 253.81,34.27 v3(254,34.46) ; JCR.17 v3(303.49,18.34) ; CM70.2 156.05,140.79 155.46,141.38 v3(155.46,141.71) ; CV374.2 v3(85.03,125.19) ; CV211.2 CV210.2 ; RM42.2 165.72,139.94 v3(166.06,140.28) ; RA130.1 RA131.1 3.02,16.47 v3(2.85,16.65) ; C258.2 54.36,13.97 v3(54.61,13.97) ; v3(197.86,9.27) 197.75,9.38 JSSD3.68 ; v3(147.77,73.97) UV10.4 ; RH27.2 223.6,24.46 v3(223.6,25.03) ; v3(111.06,137.82) 110.58,137.34 RV41.1 ; CF5.2 242.36,51.96 v3(241.42,51.02) ; v3(219.11,54.36) YH2.4 ; RE36.2 v3(181.37,133.61) ; RV510.2 157.04,71.02 v3(156.69,71.36) ; CR9.2 v3(299.3,17.78) ; v3(2.95,17.59) 2.95,17.85 RA133.1 RA132.1 ; JDIMM1.205 77.49,49.28 v3(77.41,49.37) ; v3(223.5,14.51) 223.75,14.25 JSSD2.68 ; v3(178.62,116.37) CV227.2 ; v3(156.97,33.81) 157.09,33.93 JHDD1.21 ; CT5.2 250.97,39.79 v3(251.21,40.04) ; UM1.2 159.18,16.08 v3(158.6,16.66) ; CV212.2 v3(153.74,75.22) ; v3(2.35,31.71) CA94.2 ; RH103.2 v3(209.68,52.86)
  vias: v2(20.77,17.31) v2(32.96,27.73) v2(47.58,17.83) v2(50.84,34.99) v2(81.76,115) v2(89.88,122.68) v2(94.79,59.45) v2(101.7,63.64) v2(101.78,58.52) v2(110.52,130.48) v2(113.39,88.85) v2(118.45,129.03) v2(118.79,130.35) v2(124.56,48.2) v2(125.63,130.79) v2(127.13,62.45) v2(127.52,130.7) v2(128.69,129.31) v2(130.74,58.55) v2(144.76,116.77) v2(153.28,100.13) v2(177.55,33.38) v2(194.87,34.56) v2(197.87,47.49) v2(197.93,36.96) v2(254.27,36.02) v2(255.07,30.06) v2(262.77,38.93) v2(272.8,33.29) v2(333.81,33.52) v3(1.21,38.75) v3(2.28,36.93) v3(2.36,40.72) v3(4.19,26.19) v3(4.63,40.68) v3(4.82,37) v3(5.46,22.65) v3(5.72,38.81) v3(5.84,27.84) v3(5.84,26.19) v3(5.84,24.54) v3(7.48,15.98) v3(7.5,26.19) v3(8.07,15.98) v3(8.18,19.46) v3(8.18,18.87) v3(12,41.77) v3(18.49,16.41) v3(18.49,15.2) v3(19.05,36.92) v3(19.69,36.92) v3(19.94,17.1) v3(20.2,15.2) v3(20.32,36.92) v3(20.5,41.77) v3(20.78,13.82) v3(21.15,26.57) v3(21.15,25.55) v3(21.38,24.98) v3(21.59,16.44) v3(21.59,15.2) v3(23.05,29.43) v3(23.05,28.73) v3(23.81,29.43) v3(23.81,28.73) v3(27.18,14.44) v3(27.54,17.74) v3(27.69,29.36) v3(28.32,28.28) v3(28.83,29.17) v3(28.83,28.59) v3(28.83,27.99) v3(29,41.77) v3(29.47,29.17) v3(29.47,28.59) v3(29.47,27.99) v3(29.72,27.41) v3(30.1,29.17) v3(30.1,28.59) v3(30.1,27.99) v3(30.36,27.41) v3(30.74,29.17) v3(30.74,28.59) v3(30.74,27.99) v3(30.99,27.41) v3(31.37,29.17) v3(31.37,28.59) v3(31.37,27.99) v3(31.5,7.78) v3(31.63,27.41) v3(32.01,29.17) v3(32.01,28.59) v3(32.01,27.99) v3(32.26,27.41) v3(32.64,29.17) v3(32.64,28.59) v3(33.28,29.17) v3(33.28,28.59) v3(33.91,29.17) v3(33.91,28.59) v3(34.55,29.17) v3(34.55,28.59) v3(34.99,29.75) v3(35.18,29.05) v3(35.18,28.44) v3(35.82,29.05) v3(35.82,28.44) v3(36.96,22.44) v3(37.59,22.44) v3(37.95,42.75) v3(41.43,7.79) v3(42.11,38.16) v3(42.11,36.63) v3(42.87,37.39) v3(43.63,38.16) v3(43.63,36.63) v3(44.54,39.61) v3(46.48,45.63) v3(48.07,18.19) v3(48.07,17.55) v3(49.41,18.19) v3(49.41,17.55) v3(50.68,35.9) v3(50.7,36.92) v3(50.99,36.41) v3(51.31,36.92) v3(51.31,35.9) v3(51.37,7.78) v3(51.63,36.41) v3(51.95,36.92) v3(51.95,35.9) v3(52.26,36.41) v3(52.58,36.92) v3(52.58,35.9) v3(52.9,36.41) v3(53.22,35.9) v3(53.53,36.41) v3(54.19,50.29) v3(54.42,15.33) v3(54.61,13.34) v3(55.63,15.33) v3(56.14,9.93) v3(60.26,28.67) v3(60.26,28.03) v3(60.26,27.4) v3(60.26,26.76) v3(60.26,26.13) v3(60.26,25.49) v3(60.26,24.86) v3(60.26,24.22) v3(60.2,22.72) v3(60.2,22.14) v3(60.2,21.55) v3(60.2,20.92) v3(60.96,28.67) v3(60.96,28.03) v3(60.96,27.4) v3(60.96,26.76) v3(60.96,26.13) v3(60.96,25.49) v3(60.96,24.86) v3(60.9,22.72) v3(60.9,22.14) v3(60.9,21.55) v3(60.9,20.92) v3(61.3,7.78) v3(61.53,22.72) v3(61.53,22.14) v3(61.53,21.55) v3(61.53,20.92) v3(61.6,28.67) v3(61.6,28.03) v3(61.6,27.4) v3(61.6,26.76) v3(61.6,26.13) v3(61.6,25.49) v3(61.99,58.08) v3(62.11,27.08) v3(62.11,26.44) v3(62.11,25.81) v3(62.11,24.79) v3(62.11,24.16) v3(62.11,21.87) v3(62.11,21.24) v3(62.4,12.97) v3(62.98,12.97) v3(63.21,57.98) v3(63.22,57.38) v3(63.57,12.97) v3(63.51,8.75) v3(64.39,7.11) v3(64.66,10.72) v3(66.64,65.79) v3(66.93,10.68) v3(67.27,7.15) v3(68.02,8.81) v3(69.53,74.32) v3(70.3,7.78) v3(70.51,105.28) v3(70.51,94.28) v3(70.51,83.28) v3(72.65,49.24) v3(72.65,48.6) v3(72.65,47.46) v3(72.65,46.83) v3(72.65,45.81) v3(72.65,45.18) v3(78.42,7.78) v3(78.66,36.57) v3(78.66,35.04) v3(78.66,33.52) v3(78.69,23.04) v3(78.69,21.52) v3(78.69,19.99) v3(79.5,118.65) v3(79.49,110.61) v3(80.46,35.42) v3(80.45,21.19) v3(80.58,127.31) v3(81.21,115.19) v3(81.52,115.7) v3(82.09,36.57) v3(82.09,35.04) v3(82.09,33.52) v3(82,23.1) v3(82,21.57) v3(82,20.05) v3(82.51,43.02) v3(82.51,42.25) v3(83.81,58.18) v3(84.16,36.09) v3(84.16,34.57) v3(84.16,33.04) v3(84.75,23.1) v3(84.75,21.57) v3(84.75,20.05) v3(84.88,56.36) v3(84.95,60.15) v3(85.87,36.47) v3(85.87,34.19) v3(85.99,10.97) v3(86.17,23.48) v3(86.17,21.19) v3(86.54,7.78) v3(86.67,10.97) v3(87.15,36.11) v3(87.15,34.57) v3(87.15,33.17) v3(87.23,60.11) v3(87.34,10.97) v3(87.46,129.01) v3(87.42,56.43) v3(87.44,23.1) v3(87.44,21.57) v3(87.44,20.05) v3(88.32,58.24) v3(89.02,36.11) v3(89.02,34.59) v3(89.02,33.07) v3(90.1,23.1) v3(90.1,21.57) v3(90.1,20.05) v3(90.89,36.49) v3(90.89,34.21) v3(91.47,21.19) v3(92.24,36.11) v3(92.24,34.59) v3(92.93,128.92) v3(93.08,23.1) v3(93.08,21.57) v3(93.08,20.05) v3(93.11,134.66) v3(93.16,119.57) v3(93.39,129.36) v3(93.64,124.6) v3(93.61,119.99) v3(93.79,123.73) v3(94.24,124.25) v3(94.67,7.78) v3(95.13,35.85) v3(95.69,21.57) v3(95.69,20.05) v3(96.75,127.92) v3(97.17,127.48) v3(97.21,62.8) v3(97.21,62.22) v3(97.31,21.19) v3(97.96,34.32) v3(97.96,32.8) v3(98.61,21.57) v3(98.61,20.05) v3(98.77,140.32) v3(99.6,129.39) v3(99.76,64.59) v3(99.76,63.96) v3(99.76,63.29) v3(99.76,62.66) v3(99.76,62.02) v3(99.76,57.94) v3(99.76,57.34) v3(99.76,56.7) v3(99.76,56.03) v3(99.76,55.4) v3(100.21,146.75) v3(100.27,129.39) v3(100.66,129.95) v3(101.28,144.93) v3(101.36,148.72) v3(101.67,83.91) v3(101.98,83.34) v3(102.25,83.91) v3(102.48,7.78) v3(103.37,116.99) v3(103.63,148.68) v3(103.82,145) v3(103.95,116.99) v3(104.08,132.81) v3(104.14,45.63) v3(104.14,45.05) v3(104.53,133.26) v3(104.59,134.01) v3(104.72,146.81) v3(105.26,73.23) v3(105.51,136.35) v3(105.68,149.22) v3(106.06,45.2) v3(106.05,44.6) v3(106.17,45.84) v3(107.73,73.27) v3(107.74,70.67) v3(107.71,69.47) v3(108.46,90.45) v3(108.46,89.56) v3(108.46,88.55) v3(108.46,87.59) v3(108.46,86.64) v3(108.46,85.69) v3(108.92,145.68) v3(109.67,91.85) v3(109.67,91.02) v3(109.78,76.01) v3(110.07,139.3) v3(110.12,71.11) v3(110.75,77.43) v3(110.76,76.01) v3(111.25,91.72) v3(111.29,7.78) v3(111.58,147.03) v3(111.64,126.84) v3(111.64,126.2) v3(111.64,125.57) v3(111.64,124.93) v3(111.64,124.3) v3(111.64,123.66) v3(111.64,123.03) v3(111.64,68.86) v3(111.64,46.13) v3(111.64,45.43) v3(111.76,72.58) v3(111.91,12.63) v3(112.08,89.44) v3(112.08,88.61) v3(112.08,87.59) v3(112.08,86.58) v3(112.27,126.84) v3(112.27,126.2) v3(112.27,125.57) v3(112.27,124.93) v3(112.27,124.3) v3(112.27,123.66) v3(112.27,123.03) v3(112.55,12.63) v3(112.91,126.84) v3(112.91,126.2) v3(112.91,125.57) v3(112.91,124.93) v3(112.91,124.3) v3(112.91,123.66) v3(113.18,12.63) v3(113.41,84.8) v3(113.49,46.15) v3(113.49,45.57) v3(113.71,149.77) v3(113.82,12.63) v3(114.37,145.77) v3(114.45,12.63) v3(114.76,135.02) v3(114.87,90.39) v3(114.87,88.86) v3(114.94,92.99) v3(114.94,91.78) v3(114.97,70.36) v3(115.06,84.8) v3(115.09,72.54) v3(115.7,142.79) v3(116.33,92.67) v3(116.72,91.47) v3(116.78,89.75) v3(116.91,87.97) v3(116.91,84.8) v3(117.13,107.98) v3(117.13,107.34) v3(117.51,72.53) v3(118.15,134.91) v3(118.24,12.63) v3(118.43,84.86) v3(118.81,85.63) v3(119.03,7.78) v3(120.08,126.84) v3(120.08,126.2) v3(120.08,125.57) v3(120.08,124.93) v3(120.08,124.3) v3(120.08,123.66) v3(120.08,123.03) v3(120.27,108.04) v3(120.27,107.41) v3(120.29,34.82) v3(120.29,33.3) v3(120.46,23.3) v3(120.46,21.78) v3(120.46,20.26) v3(120.66,134.34) v3(120.72,127.47) v3(120.72,126.84) v3(120.72,126.2) v3(120.72,125.57) v3(120.72,124.93) v3(120.72,124.3) v3(120.72,123.66) v3(120.72,123.03) v3(121.35,126.2) v3(121.35,125.57) v3(121.35,124.93) v3(121.35,124.3) v3(121.35,123.66) v3(121.98,35.2) v3(122.13,23.68) v3(122.13,21.4) v3(122.26,49.56) v3(122.26,48.95) v3(122.26,48.34) v3(122.26,47.75) v3(123.46,23.3) v3(123.46,21.78) v3(123.46,20.26) v3(123.68,36.35) v3(123.68,34.82) v3(123.68,33.3) v3(124.21,103.53) v3(125.34,64.34) v3(125.34,63.76) v3(125.34,63.17) v3(125.34,62.59) v3(125.34,62.01) v3(125.34,61.42) v3(125.34,60.84) v3(125.34,60.25) v3(125.8,104.1) v3(125.8,96.99) v3(125.86,22.83) v3(125.86,21.31) v3(125.86,19.79) v3(125.92,64.03) v3(125.92,63.44) v3(125.92,62.86) v3(125.92,62.27) v3(125.92,61.69) v3(125.92,61.1) v3(125.92,60.52) v3(125.92,59.94) v3(125.98,33.04) v3(127.16,7.78) v3(127.29,34.18) v3(127.29,21.69) v3(127.29,19.46) v3(128.56,36.08) v3(128.56,34.56) v3(128.56,33.04) v3(128.78,125.82) v3(128.78,125.19) v3(128.78,124.55) v3(128.78,123.92) v3(128.78,123.28) v3(129.42,125.82) v3(129.42,125.19) v3(129.42,124.55) v3(129.42,123.92) v3(129.42,123.28) v3(129.48,22.83) v3(129.48,21.31) v3(129.48,19.79) v3(129.61,126.46) v3(130.05,125.82) v3(130.05,125.19) v3(130.05,124.55) v3(130.05,123.92) v3(130.05,123.28) v3(130.24,126.46) v3(130.69,125.82) v3(130.69,125.19) v3(130.69,124.55) v3(130.62,84.99) v3(131.01,36.38) v3(131.01,34.85) v3(131.01,33.33) v3(131.47,99.07) v3(131.76,23.28) v3(131.76,21.76) v3(131.76,20.24) v3(132.31,35.23) v3(133.03,131.26) v3(133.29,22.14) v3(133.29,19.85) v3(133.44,110.63) v3(133.44,109.87) v3(133.44,109.1) v3(133.5,131.64) v3(133.94,146.04) v3(134.05,144.1) v3(134.05,34.85) v3(134.05,33.33) v3(134.11,131.64) v3(134.3,136.45) v3(134.84,99.27) v3(134.85,23.28) v3(134.85,21.76) v3(134.85,20.24) v3(134.98,142.29) v3(135.07,96.19) v3(135.28,7.78) v3(135.65,145.16) v3(136.04,92.12) v3(136.34,126.46) v3(136.44,10.34) v3(136.63,92.12) v3(136.78,12.79) v3(136.93,35.07) v3(136.93,33.55) v3(137.16,23.28) v3(137.16,21.76) v3(137.16,20.24) v3(137.25,127.48) v3(137.23,92.1) v3(137.29,125.57) v3(137.45,126.42) v3(137.81,92.1) v3(138.15,47.35) v3(138.15,46.59) v3(138.15,45.82) v3(138.2,35.45) v3(138.31,126.52) v3(139.02,22.14) v3(139.02,19.85) v3(139.11,115.62) v3(139.65,116.16) v3(140.08,115.66) v3(140.04,36.6) v3(140.04,35.07) v3(140.04,33.55) v3(140.22,96.45) v3(140.22,95.33) v3(140.22,94.74) v3(140.22,93.55) v3(140.22,92.97) v3(140.22,91.84) v3(140.22,91.25) v3(140.34,116.3) v3(140.4,116.88) v3(140.65,115.79) v3(140.75,23.28) v3(140.75,21.76) v3(140.75,20.24) v3(140.97,116.3) v3(141,89.44) v3(141,87.66) v3(141.15,116.87) v3(141.29,115.79) v3(141.48,88.55) v3(141.67,116.3) v3(141.73,116.93) v3(141.96,89.44) v3(141.96,87.66) v3(141.99,115.79) v3(142.31,116.3) v3(142.5,116.93) v3(142.62,115.79) v3(142.94,116.3) v3(143.26,116.93) v3(143.26,115.79) v3(143.4,7.78) v3(143.64,116.3) v3(143.96,116.93) v3(144.03,29.36) v3(144.27,116.3) v3(145.63,65.19) v3(145.63,7.43) v3(146.24,29.36) v3(146.31,30.76) v3(146.45,5.81) v3(146.78,67.16) v3(146.7,63.38) v3(146.76,9.22) v3(146.88,109.03) v3(146.88,108.4) v3(146.88,107.76) v3(146.88,107.13) v3(146.9,86.45) v3(147.12,87.92) v3(147.74,134.01) v3(147.74,133.36) v3(147.94,149.22) v3(148.43,87.53) v3(148.91,19.78) v3(149.05,67.12) v3(149.03,9.18) v3(149.24,63.44) v3(149.32,86.17) v3(149.48,5.84) v3(150.13,89.42) v3(150.12,65.11) v3(150.12,7.31) v3(150.23,99.65) v3(150.23,99.06) v3(150.24,84.93) v3(150.43,86.83) v3(150.5,28.54) v3(150.77,88.5) v3(150.85,99.65) v3(150.85,99.06) v3(150.89,28.98) v3(151.01,82.32) v3(151.13,90.71) v3(151.32,28.54) v3(151.35,19.8) v3(151.45,41.24) v3(151.98,120.74) v3(152.07,84.43) v3(152.17,85.61) v3(152.21,41.24) v3(152.34,87.26) v3(152.41,89.61) v3(152.55,123.53) v3(152.71,81.62) v3(152.92,78.6) v3(152.97,41.24) v3(153.14,133.76) v3(153.14,132.37) v3(153.14,130.97) v3(153.67,119.29) v3(153.62,58.59) v3(153.61,41.24) v3(153.61,40.6) v3(153.61,39.97) v3(153.86,84.61) v3(154.24,41.24) v3(154.24,40.6) v3(154.24,39.97) v3(154.2,4.78) v3(154.31,82.51) v3(154.82,133.76) v3(154.82,132.37) v3(154.88,41.24) v3(154.88,40.6) v3(154.88,39.97) v3(154.98,51.45) v3(155.44,50.97) v3(155.51,41.3) v3(155.51,40.6) v3(155.51,39.97) v3(155.59,123.92) v3(155.68,119.56) v3(156.02,50.97) v3(156.02,50.38) v3(156.58,100.79) v3(156.67,136.83) v3(156.6,132.37) v3(156.6,130.97) v3(156.68,120.84) v3(157.25,99.09) v3(157.48,126) v3(157.76,136.87) v3(157.77,92.52) v3(157.89,149.22) v3(158.18,92.09) v3(158.38,133.76) v3(158.38,130.97) v3(158.46,132.35) v3(158.94,8.49) v3(159.13,59.71) v3(159.41,8.13) v3(160.03,130.97) v3(160.09,93.94) v3(160.09,93.25) v3(160.36,136.53) v3(160.46,62) v3(160.44,57.37) v3(160.67,126.51) v3(160.59,119.68) v3(160.59,118.84) v3(160.59,117.5) v3(160.59,116.68) v3(160.59,116) v3(160.59,115.15) v3(160.59,114.52) v3(160.59,113.88) v3(160.79,77.18) v3(161.23,70.38) v3(161.19,68.79) v3(161.19,67.97) v3(161.36,135.66) v3(162.01,95.97) v3(162.05,81.62) v3(162,71.98) v3(162.24,93.88) v3(162.2,91.6) v3(162.27,89.18) v3(162.2,86.78) v3(162.2,79.83) v3(162.25,74.78) v3(162.32,84.08) v3(162.42,46.42) v3(162.78,67.95) v3(162.8,93.58) v3(162.8,91.18) v3(162.8,88.78) v3(162.8,86.38) v3(162.8,77.56) v3(162.93,46.71) v3(162.93,46.13) v3(162.99,4.78) v3(163.17,57.37) v3(163.19,62) v3(163.6,95.98) v3(163.6,95.18) v3(163.6,92.78) v3(163.6,90.38) v3(163.6,87.98) v3(163.6,85.58) v3(163.6,83.98) v3(163.6,82.38) v3(163.62,72) v3(163.64,70.39) v3(164.4,95.98) v3(164.4,79.2) v3(164.4,77.58) v3(164.4,74.38) v3(164.39,67.99) v3(164.52,59.78) v3(164.78,96.48) v3(165.6,68.92) v3(165.6,67.83) v3(166,105.58) v3(166.44,149.76) v3(166.77,88.78) v3(166.78,79.95) v3(166.8,95.98) v3(166.8,94.38) v3(166.79,93.56) v3(166.8,91.98) v3(166.8,91.15) v3(166.8,89.58) v3(166.8,87.18) v3(166.8,84.78) v3(166.8,83.98) v3(166.8,81.58) v3(166.82,77.56) v3(166.82,74.41) v3(166.82,73.6) v3(167.6,105.58) v3(167.6,103.98) v3(167.6,93.58) v3(167.6,91.18) v3(167.6,88.78) v3(167.6,81.58) v3(167.6,73.58) v3(167.59,67.97) v3(168.04,52.87) v3(168.3,52.35) v3(168.3,51.77) v3(168.47,83.91) v3(168.6,94.38) v3(168.77,136.87) v3(168.72,56.73) v3(168.72,56.1) v3(168.72,55.46) v3(168.72,54.83) v3(169.23,73.55) v3(169.4,79.98) v3(169.4,77.58) v3(169.93,95.59) v3(170,105.58) v3(170,103.98) v3(170,103.18) v3(170.04,68.81) v3(170.4,75.27) v3(170.4,74.68) v3(170.74,73.56) v3(170.75,72.76) v3(170.77,71.14) v3(170.78,70.35) v3(171.01,136.79) v3(171.79,4.78) v3(172.8,106.08) v3(172.99,137.54) v3(173.18,62.24) v3(173.18,61.66) v3(173.18,61.08) v3(173.18,60.49) v3(173.2,70.36) v3(174.8,104.78) v3(174.8,100.78) v3(174.86,70.36) v3(175.18,149.12) v3(175.2,98.68) v3(175.6,103.98) v3(176.85,37.52) v3(176.87,35.49) v3(176.9,36.57) v3(176.93,34.41) v3(177.18,36.03) v3(177.2,104.78) v3(177.2,103.18) v3(177.22,75.25) v3(177.2,72.78) v3(177.24,37.06) v3(177.22,34.94) v3(177.4,68.98) v3(177.48,52.61) v3(177.48,50.23) v3(177.56,37.58) v3(177.57,35.5) v3(177.51,34.41) v3(177.6,105.98) v3(177.6,101.18) v3(177.59,36.58) v3(177.71,42.09) v3(177.71,41.51) v3(177.71,40.92) v3(177.71,40.34) v3(177.71,39.75) v3(177.9,37.1) v3(177.89,36.01) v3(177.89,34.93) v3(178,71.24) v3(178.16,137.25) v3(178.16,135.98) v3(178.13,38.88) v3(178.11,38.27) v3(178.17,37.66) v3(178.17,36.58) v3(178.21,35.5) v3(178.37,41.8) v3(178.37,41.21) v3(178.37,40.63) v3(178.37,40.05) v3(178.37,39.46) v3(178.39,42.38) v3(178.49,37.15) v3(178.53,36.01) v3(178.53,34.93) v3(178.72,38.88) v3(178.69,38.27) v3(178.81,37.66) v3(178.81,36.58) v3(178.84,35.5) v3(178.98,42.09) v3(178.98,41.51) v3(178.98,40.92) v3(178.98,40.34) v3(178.98,39.75) v3(179.12,37.15) v3(179.16,36.01) v3(179.16,34.93) v3(179.22,53.99) v3(179.43,138.52) v3(179.43,137.25) v3(179.43,135.98) v3(179.44,37.66) v3(179.44,36.58) v3(179.48,35.5) v3(179.6,103.98) v3(179.6,71.17) v3(179.76,37.15) v3(179.86,53.99) v3(179.8,36.01) v3(179.8,34.93) v3(179.96,26.82) v3(179.96,25.66) v3(180,74.88) v3(180.08,37.66) v3(180.08,36.58) v3(180.11,104.6) v3(180.11,35.5) v3(180.4,102.38) v3(180.4,72.78) v3(180.4,69.58) v3(180.4,67.99) v3(180.39,37.15) v3(180.43,36.01) v3(180.43,34.93) v3(180.49,53.99) v3(180.59,4.79) v3(180.7,138.52) v3(180.7,137.25) v3(180.7,135.98) v3(180.71,37.66) v3(180.71,36.58) v3(180.75,35.5) v3(180.76,34.32) v3(180.75,26.05) v3(181.03,37.15) v3(181.07,36.01) v3(181.07,34.93) v3(181.13,53.99) v3(181.15,7.67) v3(181.35,37.66) v3(181.35,36.58) v3(181.36,35.5) v3(181.35,34.32) v3(181.55,26.82) v3(181.55,25.49) v3(181.76,7.67) v3(182,99.98) v3(182,71.18) v3(182.45,67.74) v3(182.8,72.78) v3(182.8,68.77) v3(184.02,149.12) v3(184.4,100.78) v3(184.4,99.98) v3(184.4,71.18) v3(184.63,52.54) v3(184.63,51.96) v3(185.2,71.98) v3(185.2,69.58) v3(185.19,68.77) v3(186.8,103.98) v3(186.8,102.38) v3(186.8,71.18) v3(187.2,67.58) v3(187.31,104.59) v3(187.6,100.78) v3(187.6,98.18) v3(187.6,68.78) v3(189.2,100.78) v3(189.2,69.58) v3(189.38,4.79) v3(189.6,74.88) v3(189.6,67.57) v3(189.94,135.37) v3(189.99,104.74) v3(190,72.78) v3(190,68.78) v3(189.99,29.43) v3(191.56,135.31) v3(191.52,96.93) v3(191.5,76.68) v3(191.61,72.78) v3(191.6,71.18) v3(191.75,149.12) v3(191.78,38.05) v3(191.78,37.42) v3(191.78,36.78) v3(191.78,36.15) v3(191.78,35.51) v3(191.78,34.88) v3(191.77,34.29) v3(191.77,33.66) v3(191.94,105.95) v3(191.9,89.18) v3(191.89,84.14) v3(191.9,81.98) v3(192,67.48) v3(192.34,91.18) v3(192.29,37.73) v3(192.29,37.1) v3(192.29,36.46) v3(192.29,35.83) v3(192.29,35.19) v3(192.29,34.56) v3(192.34,33.87) v3(192.4,103.98) v3(192.4,102.38) v3(192.4,100.78) v3(192.41,96) v3(192.39,87.19) v3(193.2,74.38) v3(193.2,72.78) v3(193.82,135.87) v3(194,99.18) v3(194,94.38) v3(194,91.98) v3(194,89.58) v3(194,86.38) v3(193.99,85.6) v3(194,83.98) v3(194,81.58) v3(194,79.18) v3(194,76.78) v3(194.01,42.15) v3(194.01,41.52) v3(194.01,40.88) v3(194.01,40.25) v3(194.01,39.61) v3(194.12,48.67) v3(194.12,47.97) v3(194.34,53.25) v3(194.34,52.67) v3(194.34,52.08) v3(194.65,42.17) v3(194.65,41.53) v3(194.65,40.9) v3(194.65,40.26) v3(194.65,39.63) v3(194.64,39.04) v3(194.64,38.38) v3(194.8,105.58) v3(194.8,103.18) v3(194.8,81.58) v3(194.8,71.18) v3(194.8,70.38) v3(194.8,69.58) v3(194.8,67.98) v3(195.18,132.9) v3(195.18,38.75) v3(195.18,38.09) v3(195.23,43.78) v3(195.21,43.11) v3(195.19,42.51) v3(195.19,41.87) v3(195.19,41.24) v3(195.19,40.6) v3(195.19,39.97) v3(195.19,39.33) v3(195.6,105.58) v3(195.59,103.18) v3(195.6,98.38) v3(195.6,93.58) v3(195.6,88.78) v3(195.6,87.18) v3(195.6,84.78) v3(195.6,83.98) v3(195.6,82.38) v3(195.6,77.58) v3(195.6,71.98) v3(195.6,71.18) v3(195.75,44.12) v3(195.75,43.49) v3(195.75,42.85) v3(195.72,42.27) v3(195.72,41.63) v3(195.72,41) v3(195.72,40.36) v3(195.72,39.73) v3(195.72,39.09) v3(195.75,38.39) v3(195.75,37.72) v3(195.81,132.9) v3(196.27,42.51) v3(196.27,41.87) v3(196.27,41.24) v3(196.27,40.6) v3(196.27,39.97) v3(196.27,39.33) v3(196.27,38.75) v3(196.27,38.09) v3(196.29,44.49) v3(196.29,43.86) v3(196.29,43.22) v3(196.4,101.58) v3(196.39,99.17) v3(196.4,95.98) v3(196.4,70.38) v3(196.81,44.86) v3(196.81,44.2) v3(196.81,43.56) v3(196.81,42.93) v3(196.84,42.31) v3(196.84,41.67) v3(196.84,41.04) v3(196.84,40.4) v3(196.84,39.77) v3(196.84,39.13) v3(196.81,38.42) v3(196.97,37.85) v3(197.2,89.58) v3(197.2,88.78) v3(197.2,81.58) v3(197.2,75.18) v3(197.2,71.98) v3(197.2,69.58) v3(197.35,44.53) v3(197.35,43.89) v3(197.35,43.26) v3(197.35,42.62) v3(197.35,41.99) v3(197.35,41.35) v3(197.35,40.72) v3(197.35,40.08) v3(197.35,39.45) v3(197.35,38.81) v3(197.36,26.71) v3(197.55,38.25) v3(197.82,89.07) v3(197.88,44.2) v3(197.88,43.56) v3(197.88,42.93) v3(197.88,42.29) v3(197.88,41.66) v3(197.93,49.11) v3(197.93,48.41) v3(197.89,40.96) v3(197.91,40.34) v3(197.91,39.73) v3(197.91,39.12) v3(198,106.31) v3(198,101.58) v3(198,99.18) v3(198,96.69) v3(198,94.38) v3(198,91.98) v3(198,87.18) v3(198,83.98) v3(198,79.18) v3(198,77.58) v3(198,76.78) v3(198.18,4.78) v3(198.31,28.79) v3(198.49,24.68) v3(198.8,103.18) v3(198.83,60.75) v3(198.98,67.58) v3(199.14,93.96) v3(199.09,91.58) v3(199.21,144.4) v3(199.2,118.58) v3(199.25,60.33) v3(199.3,86.78) v3(199.57,104.78) v3(199.57,55.79) v3(199.57,55.15) v3(199.78,69.33) v3(199.9,68.38) v3(200.17,55.25) v3(200.18,54.64) v3(200.24,146.66) v3(200.41,9.81) v3(200.51,142.78) v3(200.6,54.21) v3(200.98,123.09) v3(201.13,59.71) v3(201.31,24.73) v3(201.39,28.75) v3(201.55,58.38) v3(201.81,123.92) v3(202.46,62) v3(202.39,26.72) v3(202.68,4.78) v3(202.72,142.92) v3(202.82,119.03) v3(202.96,146.31) v3(203.33,124.42) v3(203.49,144.27) v3(204.41,119.28) v3(204.49,133.61) v3(205.19,62) v3(205.42,120.11) v3(205.55,20.6) v3(205.87,46.19) v3(205.97,42.55) v3(206.12,61.05) v3(206.52,59.78) v3(207.27,8.03) v3(207.66,7.6) v3(209.53,42.76) v3(209.62,38.25) v3(209.83,128.27) v3(210.38,4.79) v3(210.62,40.83) v3(211.47,28.22) v3(211.65,47.97) v3(211.94,28.6) v3(213.17,40.16) v3(213.11,36.62) v3(213.11,33.68) v3(213.12,32.19) v3(213.24,43.08) v3(214.57,30.38) v3(214.7,46.32) v3(215.03,33.66) v3(215.04,32.68) v3(215.18,41.13) v3(215.26,42.1) v3(215.2,36.59) v3(215.71,35.63) v3(216.19,30.31) v3(216.54,103.15) v3(216.79,116.93) v3(216.85,104.04) v3(217,50.95) v3(217.36,44.29) v3(217.33,31.88) v3(217.5,103.15) v3(217.84,30.31) v3(217.91,128.27) v3(218.04,116.99) v3(218.08,4.79) v3(218.38,103.15) v3(218.38,13.25) v3(218.38,12.6) v3(219.14,118.2) v3(219.14,116.68) v3(219.27,44.35) v3(219.24,39.87) v3(219.29,32.45) v3(219.39,46.38) v3(220.27,31.85) v3(220.96,46.27) v3(222.06,49.56) v3(222.13,103.08) v3(222.72,30.51) v3(222.8,46.3) v3(222.86,44.92) v3(222.86,14.41) v3(223.4,103.03) v3(223.82,44.93) v3(223.82,44.28) v3(224.62,30.48) v3(225.68,35.65) v3(225.78,4.79) v3(225.81,103.18) v3(225.81,44.93) v3(225.91,46.31) v3(225.94,30.31) v3(226,128.27) v3(226.32,35.65) v3(226.32,34.72) v3(226.49,124.77) v3(226.49,118.83) v3(226.49,109.88) v3(226.95,40.16) v3(226.95,39.18) v3(227.01,41.15) v3(227,37.56) v3(227.01,36.6) v3(227.36,32.27) v3(227.41,30.42) v3(228.58,30.04) v3(228.98,44.64) v3(229.03,33.53) v3(229.17,45.77) v3(229.19,36.79) v3(229.46,28.47) v3(229.93,48.4) v3(230.75,29.28) v3(230.92,46.99) v3(230.94,7.67) v3(231.36,68.95) v3(231.35,66.84) v3(231.4,67.92) v3(231.54,7.65) v3(231.62,92.08) v3(231.62,91.2) v3(231.64,90.05) v3(231.62,88.76) v3(231.64,87.95) v3(231.64,84.15) v3(231.64,83.29) v3(231.65,80.65) v3(231.66,79.63) v3(231.65,78.78) v3(231.65,78.04) v3(231.65,76.41) v3(231.66,75.67) v3(231.65,74.81) v3(231.64,73.93) v3(231.68,72.94) v3(231.68,72.11) v3(231.68,71.25) v3(232.5,103.87) v3(233.49,4.79) v3(235.75,61.91) v3(235.87,66.14) v3(236.21,58.46) v3(236.49,103.38) v3(236.49,95.68) v3(236.49,87.98) v3(236.49,80.28) v3(236.5,71.83) v3(237.28,56.65) v3(237.35,60.43) v3(239.33,44.82) v3(239.63,60.39) v3(239.82,56.71) v3(240.15,46.03) v3(240.72,58.52) v3(240.7,44.77) v3(240.83,46.01) v3(241.19,4.79) v3(243.94,56.54) v3(243.97,28.28) v3(243.98,27.51) v3(243.97,26.76) v3(244.05,44.71) v3(245.49,17.74) v3(246.08,17.74) v3(246.66,17.74) v3(247.25,17.74) v3(248.89,4.79) v3(249.93,49.02) v3(251.84,27.69) v3(252.22,28.23) v3(252.45,27.69) v3(252.81,28.23) v3(252.96,36.03) v3(253.05,27.69) v3(253.39,28.23) v3(253.6,36.03) v3(253.68,27.71) v3(253.98,28.23) v3(254.06,8.75) v3(254.26,28.77) v3(254.32,27.65) v3(254.57,28.23) v3(255.02,27.71) v3(255.13,6.94) v3(255.21,10.53) v3(256.59,4.79) v3(257.48,10.49) v3(257.67,7) v3(258.57,8.81) v3(263.16,39.55) v3(263.62,39.12) v3(264.29,4.79) v3(267.43,7.86) v3(268.04,7.86) v3(271.92,34.98) v3(271.99,4.79) v3(272.57,34.98) v3(272.65,39.12) v3(273.15,34.98) v3(273.74,34.98) v3(279.69,4.79) v3(280.48,38.84) v3(287.4,4.79) v3(288.21,40.04) v3(295.1,4.79) v3(295.21,42.51) v3(301.31,45.94) v3(302.8,4.79) v3(303.41,22.74) v3(307.02,50.57) v3(307.28,35.59) v3(307.22,32.41) v3(308.93,37.3) v3(309.36,29.75) v3(309.36,28.54) v3(309.6,33.19) v3(309.95,29.75) v3(309.95,28.54) v3(310.5,4.79) v3(312.8,57.69) v3(314.7,41.49) v3(315.28,41.49) v3(315.53,7.77) v3(315.66,59.02) v3(315.66,58.43) v3(316.49,64.73) v3(317.31,35.14) v3(317.31,34) v3(317.31,32.86) v3(317.59,64.8) v3(317.69,52.95) v3(318.45,35.14) v3(318.45,34) v3(318.45,32.86) v3(318.77,72.48) v3(319.53,62.38) v3(319.66,71.21) v3(319.66,70.6) v3(319.6,35.14) v3(319.6,34) v3(319.6,32.86) v3(320.17,4.92) v3(320.49,48.99) v3(321.82,40.98) v3(322.33,55.15) v3(322.33,54.56) v3(322.42,42.32) v3(322.42,41.62) v3(322.42,40.98) v3(323.53,55.34) v3(323.53,54.75) v3(324.46,3.88) v3(325.57,5.48) v3(326.25,1.27) v3(326.52,19.78) v3(326.52,18.25) v3(327.28,19.01) v3(328.04,19.78) v3(328.04,18.25) v3(328.96,3.95) v3(329.25,5.49) v3(330.32,3.32) v3(330.51,41.01) v3(331.35,41) v3(332.93,57.37) v3(333.85,61.17) v3(333.89,35.33) v3(333.89,34.63) v3(336.04,41.02) v3(336.17,30.16) v3(336.17,20.63) v3(336.17,11.1) v3(338.2,57.37) v3(339.07,90.24) v3(339.07,87.19) v3(339.07,84.14) v3(339.07,81.09) v3(339,42.85) v3(339.41,60.92) v3(339.47,58.7) v3(341,30.16) v3(341,20.63) v3(341.49,38.6) v3(341.49,11.2)
