# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
BSPR on BOTTOM (solid shape): 2.82,29.59 2.82,27.62 3.52,26.93 3.52,26.83 3.43,26.74 3.32,26.74 2.54,27.52 2.54,28.68 2.18,29.05 1.4,29.05 1.34,29.11 1.34,29.75 1.4,29.81 2.61,29.81
BST_3V on TOP (solid shape): 23.94,27.99 23.94,27.1 24.45,26.6 24.45,26.44 24.7,26.19 24.96,26.19 25.08,26.06 25.08,25.3 24.2,25.3 24.12,25.38 24.12,26.52 23.74,26.9 23.74,27.99 23.79,28.04 23.89,28.04
BST_5V on TOP (solid shape): 24.83,31.85 23.94,30.96 23.94,30.08 23.89,30.02 23.79,30.02 23.74,30.08 23.74,31.19 23.94,31.4 23.94,32.49 24.83,32.49
BTST_CHG on TOP (solid shape): 43.82,41.81 43.82,41.24 43.75,41.18 43.37,41.18 43.12,40.92 43.12,40.1 43.07,40.05 43.07,40.05 42.99,39.97 42.99,39.04 42.94,38.99 42.81,38.99 42.76,39.04 42.76,40.06 42.86,40.16 42.86,41.81 42.93,41.87 43.75,41.87
CHG on BOTTOM (solid shape): 64.71,48.1 64.71,46.29 63.34,46.29 62.98,45.94 63.34,45.58 64.62,45.58 64.71,45.49 64.71,39.74 64.7,39.73 64.7,39.15 64.37,38.81 63.78,38.81 63.35,38.38 58.07,38.38 57.69,38.76 57.69,39.37 57.34,39.71 57.34,45.43 57.53,45.62 58.93,45.62 61.79,48.48 64.33,48.48
CHG_B+ on TOP (solid shape): 62.49,37.17 62.49,32.54 61.28,31.33 51.44,31.33 50.74,32.03 50.74,33.49 51.44,34.19 55.31,34.19 55.44,34.32 57.28,34.32 57.53,34.57 57.53,37.24 57.91,37.62 62.04,37.62
CHG_B+ on BOTTOM (solid shape): 57.63,34.54 57.63,32.51 57.34,32.22 52.52,32.22 51.64,31.35 47.87,31.35 47.6,31.62 47.6,34.48 47.78,34.66 57.51,34.66
COMP on BOTTOM (solid shape): 140.36,127.59 140.63,127.47 140.89,127.58 141.12,127.58 141.18,127.52 141.18,127.27 141.12,127.21 140.39,127.21 140.26,127.34 140.21,127.34 140.21,127.34 140.18,127.34 140.13,127.35 140.08,127.34 139.93,127.34 139.38,126.8 139.3,126.8 139.24,126.86 139.24,126.94 139.89,127.59
CPU_B+ on TOP (solid shape): 112.74,132.77 121.14,132.77 121.18,132.81 121.66,132.81 122.81,132.81 124.4,131.22 124.4,127.73 123.76,127.09 123.76,122.96 123.7,122.9 121.8,122.9 121.73,122.96 121.73,126.2 122.02,126.49 122.35,126.49 122.6,126.74 122.6,127.56 122.3,127.85 121.54,127.85 121.3,128.09 121.3,130.05 119.94,131.41 115.89,131.41 115.7,131.22 115.7,127.54 115.25,127.09 115.25,122.96 115.18,122.89 113.36,122.89 113.32,122.91 113.3,122.95 113.3,126.11 113.45,126.27 113.73,126.27 114.3,126.84 114.3,127.92 114.11,128.11 113.29,128.11 113.1,128.3 113.1,130.77 112.46,131.41 107.58,131.41 107.42,131.25 107.42,127.71 106.87,127.15 106.87,123.09 106.68,122.9 104.9,122.9 104.84,122.96 104.84,126.01 105.03,126.2 105.54,126.2 105.79,126.46 105.79,131.35 107.25,132.81 107.26,132.81 107.59,133.13 112.38,133.13
CPU_B+ on BOTTOM (solid shape): outline of 770 points within 85.6,107.98 124.27,132.45
CPU_B+ on IN1: 124.25,129.25 124.25,127.38 123.93,127.06 123.93,124.5 123.58,124.14 122.4,124.14 122.13,124.41 122.13,127.72 121.76,128.08 116.36,128.08 115.34,127.06 115.34,123.9 114.96,123.52 113.88,123.52 113.76,123.64 113.76,129.25 114.04,129.53 123.97,129.53
CPU_B+ on IN3: 106.82,123.61 104.87,123.61 104.66,123.82 104.66,130.29 106.13,131.77 123.44,131.77 124.25,130.95 124.25,127.38 123.93,127.06 123.93,124.5 123.58,124.14 122.4,124.14 122.13,124.41 122.13,127.72 121.76,128.08 116.36,128.08 115.34,127.06 115.34,123.9 114.96,123.52 113.88,123.52 113.76,123.64 113.76,127.53 113.3,127.99 107.87,127.99 107,127.12 107,123.79
CPU_B+ on IN4: 106.82,123.61 105.46,123.61 105.23,123.84 105.23,127.41 107.16,129.34 123.89,129.34 124.25,128.98 124.25,127.38 123.93,127.06 123.93,124.5 123.58,124.14 122.4,124.14 122.13,124.41 122.13,127.72 121.76,128.08 116.36,128.08 115.34,127.06 115.34,123.9 114.96,123.52 113.88,123.52 113.76,123.64 113.76,127.53 113.3,127.99 107.87,127.99 107,127.12 107,123.79
CPU_B+ on IN5: 106.82,123.61 104.85,123.61 104.63,123.83 104.63,130.26 106.13,131.77 123.44,131.77 124.25,130.95 124.25,127.38 123.93,127.06 123.93,124.5 123.58,124.14 122.4,124.14 122.13,124.41 122.13,127.72 121.76,128.08 116.36,128.08 115.34,127.06 115.34,123.9 114.96,123.52 113.88,123.52 113.76,123.64 113.76,127.53 113.3,127.99 107.87,127.99 107,127.12 107,123.79
CPU_B+ on IN6: 106.82,123.61 104.86,123.61 104.63,123.84 104.63,129.86 105.88,131.1 122.7,131.1 124.25,129.55 124.25,127.38 123.93,127.06 123.93,124.5 123.58,124.14 122.4,124.14 122.13,124.41 122.13,127.72 121.76,128.08 116.36,128.08 115.34,127.06 115.34,123.9 114.96,123.52 113.88,123.52 113.76,123.64 113.76,127.53 113.3,127.99 107.87,127.99 107,127.12 107,123.79
DEW1 on TOP (solid shape): 160.68,15.37 160.68,14.21 159.7,13.24 158.66,13.24 158.26,12.83 158.26,12.32 158.16,12.22 156.72,12.22 156.66,12.28 156.66,12.92 156.78,13.04 157.44,13.04 158.27,13.87 159.36,13.87 160.15,14.66 160.15,15.27 160.31,15.43 160.62,15.43
DH_1.35V on TOP (solid shape): 149.7,40.47 149.7,39.54 149.63,39.47 148.56,39.47 148.43,39.6 148.43,40.41 148.57,40.55 149.62,40.55
DH_1.35V on TOP (solid shape): 151.64,31.79 151.82,31.74 152,31.79 152.15,31.79 152.25,31.69 152.25,31.43 152.08,31.26 151.5,31.26 151.4,31.16 151.4,30.12 151.36,30.08 151.22,30.08 151.18,30.12 151.18,31.12 151.17,31.13 151.17,31.69 151.27,31.79
DH_1.35V on IN2 (solid shape): 149.6,40.38 149.6,39.28 149.61,39.28 149.61,38.8 149.52,38.71 148.47,38.71 148.35,38.83 148.35,40.47 148.4,40.53 149.46,40.53
DH_1.35V on IN2 (solid shape): 152.26,32.67 152.26,31.38 152.16,31.28 151.15,31.28 151.09,31.35 151.09,31.78 151.09,31.78 151.09,32.75 151.16,32.82 152.11,32.82
DH_CHG on TOP (solid shape): 58.29,39.4 58.29,38.5 58.09,38.3 57.23,38.3 57.03,38.51 57.03,39.4 57.24,39.61 58.08,39.61
DH_CHG on TOP (solid shape): 42.72,41.06 42.72,40.21 42.61,40.1 42.61,40.09 42.58,40.06 42.58,39.05 42.52,38.99 42.41,38.99 42.36,39.05 42.36,40.1 42.23,40.22 42.23,41.05 42.36,41.18 42.61,41.18
DH_CHG on IN4 (solid shape): 57.53,39.4 57.53,38.51 57.41,38.38 56.14,38.38 55.88,38.64 55.88,39.59 57.34,39.59
DH_CHG on IN4 (solid shape): 43.88,41.18 42.8,40.1 42.42,40.1 42.23,40.29 42.23,41.24 42.99,42 43.88,42
DL_1.35V on TOP (solid shape): 151.17,40.78 151.17,39.89 151.01,39.73 150.21,39.73 150.11,39.83 150.11,40.77 150.24,40.9 151.05,40.9
DL_1.35V on TOP (solid shape): 153.34,30.38 153.34,29.97 153.04,29.68 152.05,29.68 152,29.73 152,29.89 152.22,30.11 152.22,30.36 152.35,30.49 153.22,30.49
DL_1.35V on IN2 (solid shape): 151.05,41.6 151.05,39.92 150.85,39.71 149.9,39.71 149.73,39.88 149.73,41.56 149.88,41.71 150.95,41.71
DL_1.35V on IN2 (solid shape): 153.43,30.34 153.43,30.06 153.2,29.82 152.76,29.82 152.47,29.53 152.46,29.54 151.55,29.54 151.44,29.65 151.44,30.36 151.67,30.6 153.17,30.6
DL_CHG on TOP (solid shape): 56.96,36.58 56.96,35.75 56.82,35.61 56.05,35.61 55.91,35.75 55.91,36.57 56.05,36.7 56.83,36.7
DL_CHG on TOP (solid shape): 44.77,40.48 44.77,40.16 44.64,40.03 43.94,40.03 43.82,39.91 43.82,39.08 43.73,38.99 43.63,38.99 43.56,39.05 43.56,39.9 43.63,39.96 43.63,40.54 43.75,40.67 44.58,40.67
DL_CHG on IN4 (solid shape): 56.96,36.54 56.96,35.71 56.83,35.59 55.76,35.59 55.56,35.78 55.56,36.67 56.83,36.67
DL_CHG on IN4 (solid shape): 44.82,40.71 44.86,40.71 45.09,40.63 45.32,40.71 45.87,40.71 46.23,40.35 46.23,39.78 46.1,39.65 44.9,39.65 44.64,39.96 44.26,39.83 43.73,39.83 43.63,39.94 43.63,40.48 43.92,40.77 44.77,40.77
EN_1.5V on TOP (solid shape): 205.04,19.8 205.04,18.6 205.08,18.56 205.08,17.83 205,17.74 203.79,17.74 203.63,17.9 203.63,19.35 203.69,19.42 204.41,19.42 204.54,19.55 204.54,19.78 204.71,19.95 204.89,19.95
EN_TPLED on BOTTOM (solid shape): 211.84,123.81 211.84,122.57 212.44,121.97 212.44,121.66 212.7,121.41 213.67,121.41 213.82,121.25 213.82,119.3 213.62,119.1 212.15,119.1 211.74,119.51 211.74,121.95 211.21,122.48 211.21,123.8 211.3,123.88 211.76,123.88
ENVDD_R on BOTTOM (solid shape): 85.36,118.8 85.36,118.67 84.08,117.39 83.94,117.39 82.68,118.65 82.68,118.95 83.81,120.07 84.09,120.07
FB on BOTTOM (solid shape): 140.36,127.06 140.7,127.06 141.16,126.6 141.16,126.33 140.97,126.14 140.78,126.14 140.62,126.3 140.62,126.43 140.33,126.71 139.88,126.71 139.68,126.51 139.58,126.51 139.52,126.58 139.52,126.66 140.07,127.21 140.2,127.21
FB_1.5V on TOP (solid shape): 205.98,22.5 205.98,21.36 205.89,21.26 205.73,21.26 205.65,21.34 205.65,22.04 205.29,22.4 204.18,22.4 203.92,22.15 203.42,22.15 203.34,22.22 203.34,22.68 203.91,23.25 205.23,23.25
GPU_B+ on TOP (solid shape): outline of 171 points within 167.9,32.5 174.91,43.69
GPU_B+ on TOP (solid shape): outline of 196 points within 183.31,33.41 189.58,43.64
GPU_B+ on BOTTOM (solid shape): 171.91,42.74 172.98,42.74 172.98,38.7 172.34,38.7 171.71,39.33 171.07,39.33 170.94,39.21 170.94,39.12 170.93,39.11 170.93,38.23 170.79,38.09 169.41,38.09 168.91,38.59 168.91,43.26 169.3,43.65 170.99,43.65
GPU_B+ on BOTTOM (solid shape): outline of 102 points within 183.76,34.99 189.12,43.11
GPU_B+ on IN1 (solid shape): 186.82,37.87 186.94,37.87 187.15,37.8 187.37,37.86 188.06,37.16 188.06,36.01 187.7,35.64 182.33,35.64 182.14,35.83 182.14,37.61 182.4,37.87 186.81,37.87
GPU_B+ on IN1 (solid shape): outline of 155 points within 169.17,34.42 176.43,43.68
GPU_B+ on BOTTOM: 161.61,40.42 160.17,40.42 159.81,40.78 159.81,43.94 160.11,44.24 162.46,44.24 163,43.7 163,41.81
GPU_B+ on IN2: 162.05,44.57 162.05,41.47 165.34,38.18 170.79,38.18 171.07,38.45 171.07,38.48 171.8,39.21 171.8,43.44 170.53,44.7 162.19,44.7
GPU_B+ on IN3: 171.98,34.83 170.3,34.83 169.76,35.36 169.76,36.06 169.17,36.66 169.17,43.25 169.6,43.68 170.25,43.68 170.25,43.68 170.88,43.68 171.86,42.7 175.9,42.7 176.43,42.17 176.43,34.16 176.7,33.89 181.68,33.89 182.14,34.35 182.14,42.15 182.57,42.58 187.07,42.58 187.95,41.7 187.95,33.38 187.09,32.53 174.27,32.53
GPU_B+ on IN4: 187.83,33.43 188.17,33.76 188.17,37.41 187.74,37.83 185.5,37.83 185.16,37.48 185.16,33.71 185.43,33.43
GPU_B+ on IN4: 170.81,37.99 169.57,37.99 169.28,38.28 169.28,43.4 169.81,43.93 170.65,43.93 171.14,43.44 171.14,38.31
GPU_B+ on IN5: 171.98,34.83 170.3,34.83 169.76,35.36 169.76,36.06 169.17,36.66 169.17,43.25 169.6,43.68 170.25,43.68 170.25,43.68 170.88,43.68 171.86,42.7 175.9,42.7 176.43,42.17 176.43,34.12 176.72,33.82 181.62,33.82 182.14,34.33 182.14,37.61 182.4,37.87 186.81,37.87 186.87,37.82 187.37,37.82 187.94,37.25 187.94,33.28 187.19,32.53 174.27,32.53
GPU_B+ on IN6: 171.98,34.83 170.3,34.83 169.76,35.36 169.76,36.06 169.17,36.66 169.17,43.25 169.6,43.68 170.25,43.68 170.25,43.68 170.88,43.68 171.86,42.7 175.9,42.7 176.43,42.17 176.43,34.13 176.75,33.81 181.54,33.81 182.14,34.41 182.14,37.61 182.4,37.87 187.36,37.87 188.05,37.19 188.05,33.21 187.36,32.53 174.27,32.53
GPU_B++ on TOP (solid shape): 170.74,50.53 170.74,44.77 170.38,44.41 167.9,44.41 167.86,44.45 167.86,45.54 167.72,45.68 167.12,45.68 166.97,45.84 166.97,47.53 167.5,47.53 167.5,48.23 166.97,48.23 166.97,48.73 167.5,48.73 167.5,49.43 166.97,49.43 166.97,50.66 167.34,51.04 170.23,51.04
GPU_PLLVDD on TOP (solid shape): outline of 150 points within 150.51,100.17 163.47,103.78
HDD_REXT_SATA0 on TOP (solid shape): 162.92,15.36 162.92,14.94 164.75,13.11 165.29,13.11 165.42,12.98 165.42,12.33 165.35,12.26 163.9,12.26 163.82,12.33 163.82,12.9 162.41,14.31 162.41,15.36 162.5,15.45 162.83,15.45
LG_3V on TOP (solid shape): 27.43,26.25 29.02,26.25 29.21,26.06 29.21,25.05 29.09,24.92 27.69,24.92 24.45,28.16 24.45,28.28 24.51,28.35 25.34,28.35
LG_5V on TOP (solid shape): 34.48,30.7 34.48,29.75 34.29,29.55 33.4,29.55 33.28,29.68 33.28,30.89 33.47,31.08 34.1,31.08
LG_5V on TOP (solid shape): 25.87,30.51 25.9,30.51 25.97,30.43 25.97,30.23 25.8,30.05 25.71,30.05 25.4,29.75 24.51,29.75 24.45,29.81 24.45,29.9 25.08,30.53 25.85,30.53
LG_5V on IN1 (solid shape): 34.51,30.56 34.51,29.75 34.38,29.62 33.26,29.62 33.26,30.63 33.34,30.71 34.36,30.71
LG_5V on IN1 (solid shape): 27.18,29.75 26.43,29.75 26.18,30 25.11,30 24.93,30.18 24.93,30.43 25.26,30.76 27.18,30.76
LG_+1.05VSP on BOTTOM (solid shape): 255.72,27.29 255.72,26.33 255.59,26.21 254.68,26.21 254.6,26.29 254.6,27.24 254.71,27.35 255.65,27.35
LG_+1.05VSP on BOTTOM (solid shape): 246.07,29.19 246.07,28.56 245.88,28.36 245.55,28.36 245.55,28.36 245.08,28.36 245.03,28.41 245.03,28.76 244.92,28.87 244.92,29.18 245.03,29.29 245.98,29.29
LG_+1.05VSP on IN2 (solid shape): 247.43,29.19 247.43,28.5 247.27,28.34 245.06,28.34 244.94,28.46 244.94,29.17 245.08,29.31 245.63,29.31 245.68,29.37 247.26,29.37
LG_+1.05VSP on IN2 (solid shape): 255.72,27.17 255.72,26.22 255.52,26.02 254.11,26.02 253.93,26.19 253.93,26.91 254.19,27.17 255.12,27.17 255.27,27.33 255.56,27.33
LG_+1.35VS_VGAP on TOP (solid shape): 138.11,115.1 138.11,114.1 137.97,113.95 136.67,113.95 136.54,114.08 136.54,115.09 136.75,115.3 137.92,115.3
LG_+1.35VS_VGAP on BOTTOM (solid shape): 135.72,111.62 135.72,110.81 135.63,110.72 134.58,110.72 134.45,110.86 134.45,111.62 134.52,111.69 135.65,111.69
LG_+1.35VS_VGAP on IN2 (solid shape): 136.54,111.84 136.54,111 136.38,110.84 134.49,110.84 134.43,110.91 134.43,111.88 134.59,112.04 136.34,112.04
LG_+1.35VS_VGAP on IN2 (solid shape): 137.51,115.05 137.51,113.82 137.52,113.82 137.52,113.39 137.48,113.36 136.61,113.36 136.45,113.52 136.45,115.12 136.57,115.24 136.57,115.25 136.62,115.29 137.26,115.29
LGATE1 on TOP (solid shape): 129.16,127.22 129.16,126.33 129.03,126.2 128.08,126.2 127.51,126.77 127.51,127.22 127.83,127.54 128.84,127.54
LGATE1 on BOTTOM (solid shape): 128.11,123.38 128.11,123.12 128.53,122.71 128.53,122.46 128.34,122.26 127.64,122.26 127.51,122.39 127.51,123.41 127.7,123.6 127.89,123.6
LGATE1 on BOTTOM (solid shape): 136.23,125.41 136.23,125.34 135.4,124.51 134.93,124.51 134.4,123.98 133.84,123.98 133.67,124.15 133.63,124.19 133.63,124.33 134.09,124.8 134.16,124.8 135.4,124.8 136.08,125.48 136.16,125.48
LGATE1 on IN2 (solid shape): 134.78,124.65 134.78,124.46 133.87,123.55 132.64,123.55 132.39,123.8 132.39,124.29 132.58,124.49 133.68,124.49 134.11,124.93 134.5,124.93
LGATE1 on IN2 (solid shape): 129.03,126.52 129.03,126.33 128.91,126.2 128.59,126.2 128.4,126.01 128.4,122.96 128.53,122.84 130.3,122.84 130.3,121.95 130.18,121.82 127.89,121.82 127.45,122.26 127.45,126.33 127.7,126.58 128.02,126.58 128.08,126.65 128.91,126.65
LGATE2 on TOP (solid shape): 119.62,127.8 119.62,126.89 119.43,126.7 119.08,126.7 118.91,126.87 118.91,127.22 118.56,127.57 118.56,127.82 118.7,127.95 119.47,127.95
LGATE2 on BOTTOM (solid shape): 119.62,123.38 119.62,122.88 119.81,122.7 119.81,122.48 119.67,122.34 118.87,122.34 118.75,122.47 118.75,122.68 118.94,122.87 118.94,123.34 119.16,123.56 119.44,123.56
LGATE2 on BOTTOM (solid shape): 135.1,126.36 135.28,126.36 135.37,126.26 135.37,126.18 134.8,125.61 134.72,125.61 134.42,125.91 134.11,125.91 133.95,126.08 133.95,126.29 134.28,126.63 134.84,126.63
LGATE2 on IN2 (solid shape): 134.98,126.5 134.98,126.35 133.86,125.23 132.67,125.23 132.64,125.26 132.64,126.17 132.74,126.26 133.56,126.26 134.1,126.79 134.68,126.79
LGATE2 on IN2 (solid shape): 120.08,128.61 120.08,128.36 119.57,127.85 119.57,122.96 119.76,122.77 119.76,122.52 119.64,122.39 118.75,122.39 118.62,122.52 118.62,123.17 118.7,123.4 118.62,123.63 118.62,123.8 118.7,124.03 118.62,124.26 118.62,125.99 118.68,126.2 118.62,126.41 118.62,126.62 118.68,126.84 118.62,127.05 118.62,128.3 119.13,128.81 119.89,128.81
LGATE3 on TOP (solid shape): 111.43,127.77 111.43,127.26 111.25,127.09 111.25,126.89 111.06,126.7 110.7,126.7 110.49,126.9 110.49,127.43 110.37,127.56 110.37,127.76 110.5,127.9 111.3,127.9
LGATE3 on BOTTOM (solid shape): 111.25,123.37 111.25,122.84 111.26,122.82 111.44,122.63 111.44,122.39 111.32,122.26 110.48,122.26 110.37,122.38 110.37,122.65 110.56,122.84 110.56,123.41 110.7,123.56 111.07,123.56
LGATE3 on IN2 (solid shape): 106.62,119.22 106.62,118.84 105.41,117.63 104.84,117.63 104.71,117.76 104.71,118.52 105.73,119.53 106.3,119.53
LGATE3 on IN2 (solid shape): 111.38,127.79 111.38,127.6 111.25,127.47 111.25,122.71 111.38,122.58 111.38,121.31 111.13,121.06 110.56,121.06 110.17,121.44 110.17,121.95 110.37,122.14 110.37,127.79 110.56,127.98 111.19,127.98
LID_SW_IN# on TOP (solid shape): 339.4,35.01 339.4,34.54 338.49,33.63 335.22,33.63 335.1,33.75 335.1,34.54 335.26,34.69 337.43,34.69 338.12,35.38 339.03,35.38
LX_3V on TOP (solid shape): 23.54,27.99 23.54,26.9 23.97,26.47 23.97,24.94 23.86,24.84 23.24,24.84 23.1,24.97 23.1,26.74 23.33,26.98 23.33,27.99 23.38,28.04 23.48,28.04
LX_3V on TOP (solid shape): 33.02,23.97 36.32,23.97 36.48,23.81 36.48,22.98 36.13,22.63 35.82,22.63 35.4,22.21 35.4,21.32 34.33,20.25 33.37,20.25 33.06,19.94 33.06,19.62 33.02,19.59 28.58,19.59 28.58,23.9 28.83,24.16 32.83,24.16
LX_3V on BOTTOM (solid shape): 35.18,27.59 35.2,27.56 35.2,24.05 33.91,22.76 31.69,22.76 31.43,22.51 31.43,21.11 31.18,20.86 30.23,20.86 29.47,21.62 29.47,23.27 30.01,23.81 30.01,26.18 30.23,26.41 32.4,26.41 32.71,26.72 32.71,27.45 32.84,27.59 35.05,27.59
LX_3V on IN1 (solid shape): 25.28,25.36 25.28,24.92 25.15,24.79 24.39,24.79 23.5,25.68 23.5,26.44 23.62,26.57 24.07,26.57
LX_3V on IN1 (solid shape): 32.67,24.04 32.67,21.2 32.29,20.81 29.16,20.81 28.22,21.76 28.22,24.03 28.52,24.33 32.38,24.33
LX_3V on IN2 (solid shape): 34.72,24.95 34.72,21.15 34.39,20.82 29.71,20.82 29.28,21.25 29.28,25.05 29.67,25.44 34.22,25.44
LX_3V on IN3 (solid shape): 34.72,24.95 34.72,21.15 34.39,20.82 29.71,20.82 29.28,21.25 29.28,25.05 29.67,25.44 34.22,25.44
LX_3V on IN4 (solid shape): 34.72,24.95 34.72,21.15 34.39,20.82 29.71,20.82 29.28,21.25 29.28,25.05 29.67,25.44 34.22,25.44
LX_3V on IN5 (solid shape): 34.72,24.95 34.72,21.15 34.39,20.82 29.71,20.82 29.28,21.25 29.28,25.05 29.67,25.44 34.22,25.44
LX_3V on IN6 (solid shape): 34.72,24.95 34.72,21.15 34.39,20.82 29.71,20.82 29.28,21.25 29.28,25.05 29.67,25.44 34.22,25.44
LX_5V on TOP (solid shape): 23.79,32.77 23.79,31.42 23.61,31.25 23.61,31.24 23.54,31.17 23.54,30.08 23.48,30.02 23.38,30.02 23.33,30.08 23.33,31.14 23.03,31.45 23.03,32.92 23.64,32.92
LX_5V on TOP (solid shape): 29.01,36.48 33.85,36.48 33.91,36.41 33.91,35.41 33.92,35.4 33.92,35.2 35.82,33.3 35.82,31.65 35.69,31.52 34.8,31.52 34.42,31.9 29.66,31.9 29.47,32.09 29.47,34.02 29.19,34.3 27.24,34.3 26.99,34.54 26.99,36.51 27.1,36.62 28.87,36.62
LX_5V on BOTTOM (solid shape): 35.75,35.02 35.75,31.46 35.63,31.33 31.05,31.33 30.74,31.64 30.74,34.77 31.12,35.14 35.63,35.14
LX_5V on IN1 (solid shape): 33.66,35.63 33.66,31.75 33.45,31.55 30.61,31.55 30.29,31.87 30.29,35.69 30.53,35.93 33.35,35.93
LX_5V on IN2 (solid shape): 33.8,35.39 33.8,31.7 33.41,31.32 30.57,31.32 30.06,31.83 30.06,35.26 30.49,35.69 33.49,35.69
LX_5V on IN3 (solid shape): 33.8,35.39 33.8,31.7 33.41,31.32 30.57,31.32 30.06,31.83 30.06,35.26 30.49,35.69 33.49,35.69
LX_5V on IN4 (solid shape): 33.8,35.39 33.8,31.7 33.41,31.32 30.57,31.32 30.06,31.83 30.06,35.26 30.49,35.69 33.49,35.69
LX_5V on IN5 (solid shape): 33.8,35.39 33.8,31.7 33.41,31.32 30.57,31.32 30.06,31.83 30.06,35.26 30.49,35.69 33.49,35.69
LX_5V on IN6 (solid shape): 24.7,32.29 23.62,31.21 23.31,31.21 23.18,31.33 23.18,32.35 24.13,33.3 24.7,33.3
LX_5V on IN6 (solid shape): 31.18,33.24 31.18,32.41 31.05,32.29 30.1,32.29 30.04,32.35 30.04,33.3 30.1,33.36 31.05,33.36
LX_+1.05V_GPUP on BOTTOM (solid shape): 146.54,92.18 146.54,88.34 145.9,87.71 144.14,87.71 143.47,88.38 142.62,88.38 142.57,88.43 142.57,89.71 142.65,89.79 143.84,89.79 144.22,90.17 144.22,92.68 144.33,92.79 145.93,92.79
LX_CHG on TOP (solid shape): 42.55,41.87 42.55,41.37 42.5,41.32 42.43,41.31 42.39,41.3 42.29,41.3 42.1,41.11 42.1,40.16 42.18,40.08 42.18,39.05 42.12,39 42,39 41.95,39.04 41.95,39.86 41.59,40.22 41.59,41.62 41.91,41.94 42.48,41.94
LX_CHG on TOP (solid shape): 62.17,42.13 62.17,38.57 61.91,38.32 58.93,38.32 58.8,38.44 58.8,39.65 58.49,39.97 58.26,39.97 58.17,40.06 58.17,40.33 58.09,40.4 58.09,40.43 57.64,40.63 57.74,40.14 57.79,40.13 57.79,40.02 57.74,39.97 56.83,39.97 56.52,39.65 56.52,37.43 56.35,37.27 53.76,37.27 53.53,37.49 53.53,41.05 53.28,41.3 50.99,41.3 50.87,41.43 50.87,42.51 51.21,42.86 61.44,42.86
LX_CHG on BOTTOM (solid shape): 56.45,42.64 56.45,39.21 55.61,38.37 50.18,38.37 50.04,38.51 50.04,42.95 50.42,43.33 55.76,43.33
LX_CHG on IN4 (solid shape): 54.93,42.7 54.93,41.87 54.8,41.75 53.66,41.75 53.41,42 53.41,42.64 53.66,42.89 54.74,42.89
LX_CHG on IN4 (solid shape): 44.26,43.08 44.26,42.45 44.01,42.19 42.99,42.19 42.1,41.3 42.1,40.22 41.98,40.1 41.72,40.1 41.47,40.35 41.47,42 42.74,43.27 44.07,43.27
MIC_IN on TOP (solid shape): outline of 191 points within 3.74,8.89 11.78,14.86
NC on TOP (solid shape): 340.75,114.15 340.75,110.38 340.73,110.24 340.69,110.1 340.42,109.76 340,109.63 333.43,109.63 333.31,109.75 333.31,112.93 333.49,113.11 338.5,113.11 339.74,114.35 340.54,114.35
NC on BOTTOM (solid shape): 340.75,114.15 340.75,110.38 340.73,110.24 340.69,110.1 340.42,109.76 340,109.63 333.43,109.63 333.31,109.75 333.31,112.93 333.49,113.11 338.5,113.11 339.74,114.35 340.54,114.35
NC on IN1 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on IN2 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on IN3 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on IN4 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on IN5 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on IN6 (solid shape): 337.5,118.52 339.8,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63 333.7,109.63 333.49,109.84 333.49,112.35 333.32,112.52 329.76,112.52 329.53,112.76 329,113.28 329,115.28 329.13,116.18 329.51,117.02 330.69,118.12 332.25,118.52
NC on GND1, VCC, GND2, GND3: 333.3,109.63 333.3,110.77 333.31,110.78 333.3,111.3 333.3,111.82 333.3,111.83 332.92,112.19 332.56,112.56 332.54,112.57 332.02,112.56 331.5,112.56 331.5,112.56 330.83,112.55 328.54,112.55 328.88,112.99 329,113.53 329,115.28 329.96,117.57 332.25,118.52 337.5,118.52 339.79,117.57 340.75,115.28 340.75,110.38 340.53,109.85 340,109.63
P1 on TOP (solid shape): outline of 241 points within 35.94,14.85 44.79,21.45
P1 on BOTTOM (solid shape): 44.79,17.08 44.79,13.57 44.22,13 33.7,13 33.49,13.21 33.49,14.59 33.59,14.68 33.59,15.38 33.4,15.57 33.4,16.65 33.58,16.83 35.8,16.83 36.28,17.32 36.9,17.32 37.06,17.15 37.06,16.27 37.54,15.79 40.05,15.79 40.15,15.88 40.56,15.88 40.83,16.16 40.83,17.11 41.12,17.4 44.47,17.4
P2 on TOP (solid shape): 43.44,25.73 43.59,25.57 46.39,25.57 46.4,25.58 46.99,24.98 46.99,23.32 46.98,23.31 45.62,23.31 45.26,22.95 45.62,22.59 46.99,22.59 46.99,21.81 46.67,21.49 44.9,21.49 44.33,22.06 39.25,22.06 38.99,22.32 38.99,26.57 43.44,26.57
PHASE1 on TOP (solid shape): 127.1,123.12 126.75,122.77 126.75,121.25 126.56,121.06 125.8,121.06 125.61,120.87 125.61,120.11 125.26,119.76 124.49,119.76 124.27,119.98 124.27,122.84 124.4,122.96 124.4,127.12 127.1,127.12
PHASE1 on BOTTOM (solid shape): 127.09,123.05 126.81,122.77 126.81,118.02 126.55,117.76 125.41,117.76 125.41,120.13 124.65,120.13 124.65,117.76 121.86,117.76 121.26,118.36 121.26,121.09 122.3,122.14 123.95,122.14 124.4,122.58 124.4,127.12 127.09,127.12
PHASE1 on BOTTOM (solid shape): 136.51,125.12 136.51,125.05 135.64,124.18 135.62,124.16 135.53,124.16 134.7,123.32 134.7,123.09 134.23,122.62 134.07,122.62 133.47,123.22 133.47,123.31 133.97,123.81 134.44,123.81 134.98,124.35 135.49,124.35 135.51,124.35 136.36,125.2 136.44,125.2
PHASE1 on IN1 (solid shape): 127.16,126.97 127.16,121.13 126.76,120.72 124.52,120.72 124.16,121.08 124.16,126.89 124.43,127.16 126.98,127.16
PHASE1 on IN2 (solid shape): 127.14,121.11 127.75,121.11 127.8,121.06 127.8,120.3 127.61,120.11 127.16,120.11 127.14,120.12 126.41,120.12 125.61,120.93 125.61,121.44 125.73,121.57 126.68,121.57
PHASE1 on IN2 (solid shape): 135.46,124.23 135.46,124.06 134.86,123.46 134.86,123.45 134.84,123.43 134.84,123.15 133.96,122.26 133.64,122.26 133.21,122.7 133.21,122.93 133.55,123.28 133.89,123.28 135.08,124.46 135.22,124.46
PHASE1 on IN3 (solid shape): 127.16,127.02 127.16,121.13 126.76,120.72 124.52,120.72 124.16,121.08 124.16,126.95 124.42,127.21 126.98,127.21
PHASE1 on IN4 (solid shape): 127.16,126.93 127.16,120.56 126.87,120.26 124.53,120.26 124.16,120.63 124.16,126.95 124.37,127.16 126.94,127.16
PHASE1 on IN5 (solid shape): 127.16,127.03 127.16,121.13 126.76,120.72 124.52,120.72 124.16,121.08 124.16,126.84 124.49,127.17 127.02,127.17
PHASE1 on IN6: 124.52,120.72 126.76,120.72 127.16,121.13 127.16,126.97 127.01,127.13 124.44,127.13 124.16,126.85 124.16,121.08
PHASE2 on TOP (solid shape): 118.62,127.09 118.62,123.03 117.73,122.14 117.73,121.12 117.6,120.99 116.52,120.99 116.4,120.87 116.4,119.92 116.27,119.79 115.57,119.79 115.25,120.11 115.25,122.65 115.89,123.28 115.89,127.09 115.95,127.15 118.56,127.15
PHASE2 on BOTTOM (solid shape): 132.45,128.26 133.47,127.25 134.8,127.25 135.38,126.67 135.38,126.58 135.29,126.5 135.2,126.5 134.92,126.77 133.66,126.77 133.24,126.35 132.83,126.35 131.64,127.54 131.64,127.75 132.26,128.37 132.34,128.37
PHASE2 on BOTTOM (solid shape): 118.6,122.34 119.35,121.6 119.35,118.17 119.1,117.92 118.27,117.92 117.95,118.23 117.95,120.26 117.89,120.33 117.13,120.33 117.06,120.26 117.06,118.04 116.94,117.92 115.54,117.92 115.32,118.14 115.32,122.52 115.91,123.11 115.91,127.14 118.6,127.14
PHASE2 on IN1 (solid shape): 118.57,127.02 118.57,120.59 118.28,120.3 115.26,120.3 114.8,120.76 114.8,122.82 115.64,123.66 115.64,126.9 115.9,127.17 118.43,127.17
PHASE2 on IN2 (solid shape): 117.02,127.7 117.02,126.13 116.83,125.94 116,125.94 115.88,126.07 115.88,127.62 116.07,127.81 116.9,127.81
PHASE2 on IN2 (solid shape): 133.27,127.85 133.83,127.29 133.83,126.92 133.62,126.71 132.98,126.71 131.99,127.71 131.99,128.51 132.16,128.68 132.44,128.68
PHASE2 on IN3 (solid shape): 118.57,127 118.57,120.59 118.28,120.3 115.26,120.3 114.8,120.76 114.8,122.82 115.64,123.66 115.64,126.87 115.92,127.16 118.41,127.16
PHASE2 on IN4 (solid shape): 118.57,126.63 118.57,120.11 118.32,119.86 114.92,119.86 114.8,119.99 114.8,122.82 115.64,123.66 115.64,126.68 115.92,126.96 118.24,126.96
PHASE2 on IN5 (solid shape): 118.57,127.05 118.57,120.59 118.28,120.3 115.26,120.3 114.8,120.76 114.8,122.82 115.64,123.66 115.64,126.95 115.85,127.16 118.46,127.16
PHASE2 on IN6: 118.57,119.91 118.57,126.63 118.24,126.96 115.92,126.96 115.64,126.68 115.64,123.66 114.8,122.82 114.8,119.76 115.15,119.4 118.06,119.4
PHASE3 on TOP (solid shape): 102.43,118.52 102.94,118.52 103.06,118.39 103.06,117.69 102.94,117.57 102.73,117.57 102.24,117.57 101.73,118.07 101.09,118.07 101.03,118.14 101.03,118.77 101.09,118.84 102.11,118.84
PHASE3 on TOP (solid shape): 110.24,127.09 110.24,122.77 109.54,122.07 109.54,121.34 109.44,121.25 108.59,121.25 108.21,120.87 108.21,120.22 108.03,120.04 107.19,120.04 106.94,120.3 106.94,122.65 107.51,123.22 107.51,127.15 110.17,127.15
PHASE3 on BOTTOM (solid shape): 110.3,127.09 110.3,123.03 110.17,122.9 110.17,122.14 111.89,120.42 111.89,118.14 111.57,117.82 110.3,117.82 110.3,120.26 109.54,120.26 109.54,117.82 107.32,117.82 107,118.14 107,122.71 107.38,123.09 107.38,127.03 107.57,127.22 110.17,127.22
PHASE3 on IN2 (solid shape): 103.7,119.22 103.7,118.61 102.62,117.53 102.36,117.53 102.17,117.72 102.17,118.68 102.97,119.47 103.44,119.47
PHASE3 on IN2 (solid shape): 107.57,122.14 107.57,121.38 107.38,121.19 106.62,121.19 106.43,121.38 106.43,122.14 106.56,122.26 107.44,122.26
PHASE3 on IN1: 110.3,118.83 110.3,126.97 110.18,127.09 107.63,127.09 107.26,126.72 107.26,123.57 106.96,123.26 106.96,118.8 107.38,118.38 109.85,118.38
PHASE3 on IN3, IN5: 110.3,118.83 110.3,126.8 110.08,127.01 107.58,127.01 107.26,126.69 107.26,123.57 106.96,123.26 106.96,118.8 107.38,118.38 109.85,118.38
PHASE3 on IN4: 110.3,119.57 110.3,126.98 110.16,127.12 107.69,127.12 107.26,126.69 107.26,123.57 106.96,123.26 106.96,119.54 107.6,118.9 109.63,118.9
PHASE3 on IN6: 110.3,118.83 110.3,126.94 110.13,127.11 107.67,127.11 107.26,126.69 107.26,123.57 106.96,123.26 106.96,118.8 107.38,118.38 109.85,118.38
PWM3 on BOTTOM (solid shape): 135.95,125.68 135.95,125.62 135.4,125.07 135.26,124.93 134.05,124.93 133.16,124.04 133.07,124.04 132.73,124.39 132.73,124.45 133.41,125.13 135.17,125.13 135.79,125.76 135.88,125.76
PWR_SRC_ON on TOP (solid shape): 85.66,115.55 85.66,115.15 84.52,114.01 83.19,114.01 83,114.2 82.95,114.27 82.87,114.32 82.74,114.45 82.74,115.21 83.02,115.49 83.46,115.49 84.47,116.5 84.71,116.5
RING2 on TOP (solid shape): outline of 245 points within 2.99,11.9 11.78,15.66
RJ45_CT on TOP (solid shape): 336.04,86.08 336.04,85.24 335.67,84.87 325.47,84.87 325.24,85.1 325.24,86.06 325.47,86.3 335.82,86.3
RJ45_CT on BOTTOM (solid shape): 325.95,86.23 325.95,85.25 325.77,85.08 324.6,85.08 324.46,85.22 324.46,86.2 324.57,86.31 325.86,86.31
SNB_CPU_P1 on TOP (solid shape): 128.08,121.42 128.08,119.88 127.95,119.76 126.02,119.76 125.97,119.8 125.97,120.7 126.05,120.77 126.81,120.77 127,120.96 127,121.43 127.08,121.5 128,121.5
SNB_CPU_P2 on TOP (solid shape): 119.06,121.88 119.06,120.3 118.56,119.79 117.03,119.79 116.91,119.92 116.91,120.74 116.97,120.8 117.67,120.8 117.86,120.99 117.86,121.95 117.99,122.07 118.87,122.07
SNB_CPU_P3 on TOP (solid shape): 111,121.69 111,120.17 110.87,120.04 108.9,120.04 108.78,120.17 108.78,120.93 108.84,120.99 109.54,120.99 109.73,121.19 109.73,121.73 109.88,121.88 110.81,121.88
SPK_MUTE# on BOTTOM (solid shape): 4.37,29.47 4.37,28.92 4.93,28.36 4.93,28.24 4.49,27.81 4.39,27.81 3.64,28.55 3.64,29.46 3.73,29.55 4.29,29.55
SPKL+ on BOTTOM (solid shape): 6.76,22.97 6.76,22.85 6.31,22.4 6.31,21.07 6.13,20.9 6.13,20.89 5.45,20.21 5.45,19.42 5.76,19.1 5.76,18.6 5.65,18.49 5.27,18.49 4.97,18.78 4.39,18.78 4.31,18.86 4.31,19.6 4.73,20.02 4.73,20.59 5.44,21.3 5.44,22.1 5.91,22.57 5.91,23.28 6.12,23.5 6.24,23.5
SPKL- on BOTTOM (solid shape): 5.29,23.77 5.29,23.68 4.79,23.18 4.79,22.72 5.18,22.33 5.18,21.42 4.56,20.8 4.56,20.8 4.46,20.7 4.46,20.13 4.03,19.7 4.03,18.95 3.95,18.87 3.23,18.87 3.1,19 3.1,20.04 3.39,20.33 3.76,20.7 3.76,21.42 4.42,22.08 4.42,23.18 4.89,23.65 4.89,23.65 5.1,23.86 5.2,23.86
SPKR+ on BOTTOM (solid shape): 2.29,28.31 2.29,27.45 3.16,26.58 3.16,26.48 2.74,26.06 2.74,26.06 2.1,26.06 2.1,26.06 1.99,26.06 1.3,26.75 1.3,28.32 1.34,28.37 2.23,28.37
SPKR- on BOTTOM (solid shape): 3.52,25.54 3.52,25.45 3.3,25.23 3.27,25.21 3.24,25.19 2.5,24.45 2.5,23.67 2.2,23.37 2.2,22.69 3.45,21.45 3.47,21.42 3.47,20.77 3.28,20.58 2.32,20.58 2.26,20.64 2.26,21.19 2.1,21.34 2.1,21.75 1.77,22.07 1.58,22.07 1.28,22.37 1.28,24.15 2.03,24.9 2.6,24.9 3.33,25.64 3.42,25.64
SW_1.35V on TOP (solid shape): 155.2,39.15 155.2,36.41 155.01,36.22 153.86,36.22 153.67,36.03 153.67,34.63 153.39,34.35 151.19,34.35 150.94,34.6 150.94,36.01 150.25,36.7 148.88,36.7 148.67,36.91 148.67,39.09 148.84,39.26 150.83,39.26 150.91,39.34 155.01,39.34
SW_1.35V on TOP (solid shape): 153.48,33.72 153.48,30.78 153.43,30.73 152.04,30.73 151.97,30.66 151.97,30.19 151.86,30.08 151.63,30.08 151.58,30.13 151.58,31.05 151.67,31.13 152.13,31.13 152.47,31.47 152.47,32.21 152.21,32.47 152.21,33.75 152.29,33.83 153.37,33.83
SW_1.35V on BOTTOM (solid shape): 155.79,39.08 155.79,35.65 154.82,34.67 151.3,34.67 150.86,35.12 150.86,38.96 151.17,39.28 155.6,39.28
SW_1.35V on IN2 (solid shape): 153.67,35.38 153.67,34.32 153.16,33.81 153.04,33.81 152.76,34.09 152.57,33.9 152.54,33.93 152.54,35.39 152.72,35.57 153.48,35.57
SW_1.35V on IN2 (solid shape): 153.29,32.92 153.29,32.92 153.55,32.92 153.55,31.01 153.29,30.76 152.55,30.76 152.45,30.86 152.45,31.01 152.45,31.01 152.45,33.1 152.78,33.43
SW_+1.05VSP on BOTTOM (solid shape): 248.1,27.8 248.1,26.91 248.02,26.83 247.2,26.83 246.74,27.29 245.97,27.29 245.9,27.36 245.07,27.36 245.03,27.41 245.03,27.62 245.06,27.66 245.97,27.66 246.33,28.02 247.89,28.02
SW_+1.05VSP on BOTTOM (solid shape): 256.39,25.47 257.73,25.47 257.9,25.3 257.9,24.37 257.75,24.22 257.75,19.91 256.99,19.15 252.83,19.15 252.3,19.67 252.3,23.27 251.89,23.69 249.77,23.69 249.5,23.95 249.5,25.3 249.55,25.35 249.59,25.35 249.59,25.34 251.33,25.34 252,26.02 255.84,26.02
SW_+1.05VSP on IN2 (solid shape): 251.94,25.33 251.94,24.21 251.82,24.09 250.74,24.09 250.47,24.37 250.47,25.36 250.62,25.51 251.76,25.51
SW_+1.05VSP on IN2 (solid shape): 248.1,27.65 248.1,27.01 247.72,26.63 247.1,27.25 246.14,27.25 246.14,27.25 246,27.25 245.83,27.42 245.83,28.06 245.92,28.15 247.6,28.15
SW_+1.35VS_VGAP on TOP (solid shape): 144.66,114.41 144.66,111.54 144.4,111.28 143.13,111.28 142.12,110.26 142.12,109.31 142.56,108.87 143.89,108.87 143.96,108.8 143.96,107.28 143.83,107.15 142.43,107.15 142.05,107.54 137.36,107.54 136.86,108.04 136.86,112.87 137.11,113.12 142.12,113.12 143.59,114.59 144.48,114.59
SW_+1.35VS_VGAP on BOTTOM (solid shape): 142.95,114.31 142.95,108.24 142.17,107.47 137.78,107.47 137.56,107.69 137.56,110.41 137.27,110.7 137.27,114.44 137.67,114.84 142.43,114.84
SW_+1.35VS_VGAP on BOTTOM (solid shape): 137.27,109.95 137.27,107.9 137.18,107.81 136.22,107.81 136.15,107.89 136.15,109.45 135.95,109.64 135.43,109.64 135.35,109.72 134.58,109.72 134.49,109.81 134.49,109.93 134.58,110.02 135.42,110.02 135.52,110.11 135.85,110.11 136.71,110.11 137.11,110.11
SW_+1.35VS_VGAP on IN2 (solid shape): 138.62,110.26 138.62,109.5 138.47,109.35 137.73,109.35 137.55,109.53 137.54,109.53 137.45,109.63 135.7,109.63 135.57,109.76 135.57,110.04 135.75,110.22 137.35,110.22 137.59,110.45 138.43,110.45
U2_BOOT1 on TOP (solid shape): 178.27,30.09 178.27,29.37 178.2,29.29 178.2,28.38 178.44,28.14 179.01,28.14 179.08,28.06 179.08,27.59 179.3,27.37 179.3,27.22 179.25,27.17 178.27,27.17 177.19,28.25 177.19,30.06 177.29,30.15 178.21,30.15
U2_BOOT2 on TOP (solid shape): 185.36,30.11 185.36,28.93 185.13,28.71 184.49,28.71 183.28,27.49 183.28,27.28 183.17,27.17 182.25,27.17 182.2,27.22 182.2,27.4 182.25,27.45 182.74,27.45 184.31,29.02 184.31,30.07 184.44,30.2 185.27,30.2
U2_LGATE1 on TOP (solid shape): 178.64,43.97 178.64,42.98 178.55,42.89 177.71,42.89 177.7,42.89 176.83,42.89 176.72,43 176.72,43.36 177.48,44.12 178.49,44.12
U2_LGATE1 on TOP (solid shape): 180.37,30.55 180.37,30 180.23,29.86 180.23,28.83 180.15,28.74 180.15,27.56 180.08,27.49 179.94,27.49 179.87,27.56 179.87,28.55 179.76,28.65 179.76,30.01 179.75,30.02 179.75,30.52 179.81,30.58 180.34,30.58
U2_LGATE1 on BOTTOM (solid shape): 177.7,39.07 177.7,38.08 177.57,37.94 176.62,37.94 176.54,38.02 176.54,39.08 176.63,39.17 177.6,39.17
U2_LGATE1 on IN2 (solid shape): 178.61,44.05 178.61,43.18 178.4,42.98 178.4,42.98 177.91,42.48 177.36,42.48 177.07,42.78 177.07,43.36 177.41,43.7 177.41,44.06 177.53,44.18 178.47,44.18
U2_LGATE1 on IN2 (solid shape): 177.64,39.24 177.64,38.03 177.54,37.94 177.52,37.93 176.77,37.93 176.65,37.82 176.6,37.77 176.55,37.71 176.17,37.33 175.57,37.33 175.29,37.61 175.29,37.91 176.42,39.04 176.42,39.51 176.57,39.66 177.22,39.66
U2_LGATE1 on IN2 (solid shape): 180.7,30.56 180.7,30.18 180.27,29.75 180.27,29.25 180.27,29.25 180.25,29.14 180.27,29.03 180.27,29.02 180.27,28.96 180.12,28.81 179.69,28.81 179.66,28.83 179.66,30.64 179.73,30.71 180.55,30.71
U2_LGATE2 on TOP (solid shape): 182.5,29.3 182.5,28.92 182.34,28.75 181.92,28.75 181.63,28.47 181.63,27.58 181.55,27.5 181.44,27.5 181.37,27.56 181.37,29.26 181.51,29.39 182.41,29.39
U2_LGATE2 on TOP (solid shape): 179.86,39.81 180.06,39.81 180.22,39.65 180.22,39.29 180.67,38.83 180.97,38.83 181.17,38.64 181.17,38.15 181.04,38.02 179.7,38.02 179.48,38.25 179.48,39.67 179.62,39.81 179.86,39.81
U2_LGATE2 on BOTTOM (solid shape): 180.14,43.93 180.14,42.48 179.98,42.32 179.48,42.32 178.84,42.96 178.84,44.06 178.98,44.2 179.87,44.2
U2_LGATE2 on IN2 (solid shape): 180.05,44.1 180.05,42.86 179.92,42.73 179,42.73 178.78,42.95 178.78,44.14 178.86,44.23 179.92,44.23
U2_LGATE2 on IN2 (solid shape): 182.56,30.31 182.56,29.07 182.2,28.71 181.36,28.71 181.19,28.88 181.19,30.32 181.49,30.61 182.26,30.61
U2_LGATE2 on IN2 (solid shape): 181.25,38.84 181.25,38.19 181.08,38.02 179.43,38.02 179.43,38.02 179.25,38.02 179.16,38.11 179.16,38.97 179.29,39.1 180.99,39.1
U2_LGATE3 on TOP (solid shape): 194.12,43.73 194.12,42.83 194.04,42.74 192.93,42.74 192.74,42.94 192.74,43.49 193.11,43.87 193.98,43.87
U2_LGATE3 on TOP (solid shape): 192.86,30.55 192.86,30.26 192.14,29.54 190.64,29.54 190.57,29.61 190.57,29.74 190.64,29.81 191.46,29.81 191.75,30.11 191.75,30.51 191.92,30.68 192.72,30.68
U2_LGATE3 on BOTTOM (solid shape): 193.82,39.1 193.82,38.04 193.68,37.9 192.78,37.9 192.62,38.05 192.62,39.06 192.74,39.17 193.75,39.17
U2_LGATE3 on IN2 (solid shape): 193.41,31.44 193.41,29.91 193.05,29.55 191.76,29.55 191.53,29.78 191.53,31.71 191.55,31.71 191.86,32.01 192.83,32.01
U2_LGATE3 on IN2 (solid shape): 194.14,43.76 194.14,42.99 193.47,42.32 193.47,39.1 194.03,38.54 194.03,36.77 193.93,36.67 192.89,36.67 192.75,36.81 192.75,37.83 192.3,38.28 192.3,42.81 193.4,43.91 193.99,43.91
U2_PHASE1 on TOP (solid shape): 177.7,49.43 177.7,46.78 177.22,46.3 177.22,44.1 176.48,43.36 176.48,39.4 176.36,39.27 173.5,39.27 173.33,39.44 173.33,43.58 172.73,44.18 172.21,44.18 171.84,44.55 171.84,49.31 172.14,49.62 177.51,49.62
U2_PHASE1 on TOP (solid shape): 179.62,30.01 179.62,29.97 179.64,29.95 179.64,29.15 179.63,29.14 179.62,29.03 179.63,28.93 179.64,28.92 179.64,28.6 179.64,28.59 179.64,27.58 179.57,27.5 179.35,27.5 179.21,27.64 179.21,28.11 179.18,28.14 179.18,28.24 179.09,28.33 178.45,28.33 178.33,28.45 178.33,29.16 178.44,29.27 178.44,30.06 178.53,30.14 179.48,30.14
U2_PHASE1 on BOTTOM (solid shape): 178.63,48.6 178.63,45.62 177.36,44.35 177.36,43.91 176.34,42.89 176.34,38.7 173.64,38.7 173.64,43.81 173.29,44.16 171.41,44.16 170.36,45.21 170.36,49.14 170.84,49.62 177.61,49.62
U2_PHASE1 on IN2 (solid shape): 174.96,44.03 174.96,43.17 174.75,42.96 173.85,42.96 173.68,43.12 173.68,44.06 173.79,44.17 174.83,44.17
U2_PHASE1 on IN2 (solid shape): 179.48,29.51 179.48,28.54 179.28,28.35 177.73,28.35 177.58,28.5 177.58,29.62 177.79,29.82 179.17,29.82
U2_PHASE1 on IN2 (solid shape): 178,49.44 178,45.82 177.17,44.99 177.17,43.83 176.74,43.4 175.28,43.4 175.16,43.51 175.16,44.3 174.99,44.47 173.7,44.47 173.36,44.12 171.79,44.12 171.52,44.4 171.52,49.38 171.93,49.79 177.64,49.79
U2_PHASE1 on IN1, IN3, IN5, IN6: 171.24,44.48 171.63,44.1 173.25,44.1 173.87,43.48 177.22,43.48 177.83,44.09 177.83,49.47 177.37,49.93 171.64,49.93 171.24,49.54
U2_PHASE1 on IN4: 177.6,49.85 172.27,49.85 171.6,49.18 171.6,44.49 171.84,44.25 173.43,44.25 173.7,43.98 173.7,43.67 173.78,43.58 177.05,43.58 177.34,43.87 177.34,44.33 177.83,44.82 177.83,49.63
U2_PHASE2 on TOP (solid shape): 184.1,30.12 184.1,29.14 182.53,27.57 182.2,27.57 182.14,27.52 181.92,27.52 181.86,27.58 181.86,28.5 181.92,28.57 182.72,28.57 183,28.84 183,30.04 183.15,30.19 184.03,30.19
U2_PHASE2 on TOP (solid shape): 185.56,49.49 185.56,44.05 185.4,43.89 184.09,43.89 184.08,43.91 183.61,43.91 183.25,43.55 183.25,39.38 183.2,39.33 180.72,39.33 180.48,39.58 180.48,46.17 179.89,46.76 179.84,46.76 179.23,47.37 179.23,49.45 179.47,49.69 185.36,49.69
U2_PHASE2 on BOTTOM (solid shape): 185.57,49.32 185.57,43.69 185.27,43.39 183.57,43.39 183.2,43.02 183.2,38.76 180.53,38.76 180.53,43.91 180.1,44.34 180.09,44.34 179.35,45.08 179.35,49.32 179.73,49.69 185.2,49.69
U2_PHASE2 on IN2 (solid shape): 182.45,44.13 183.74,44.13 184.15,43.72 184.15,42.24 183.88,41.97 182.56,41.97 182.23,42.29 182.23,44.03 182.34,44.13 182.45,44.13
U2_PHASE2 on IN2 (solid shape): 184.15,29.37 184.15,28.07 184.03,27.95 182.32,27.95 182.19,28.08 182.19,28.5 182.24,28.55 182.47,28.55 182.84,28.91 182.84,29.4 182.94,29.5 184.02,29.5
U2_PHASE2 on IN2 (solid shape): 185.74,49.51 185.74,44.35 185.33,43.94 184.28,43.94 183.81,44.41 182.26,44.41 181.98,44.13 181.98,43.53 181.81,43.37 180.56,43.37 180.42,43.51 180.42,44.62 179.59,45.44 179.59,49.6 179.9,49.91 185.34,49.91
U2_PHASE2 on IN1, IN3, IN5, IN6: 179.87,43.36 185.28,43.36 185.85,43.93 185.85,49.51 185.45,49.91 179.64,49.91 179.35,49.62 179.35,43.87
U2_PHASE2 on IN4: 185.48,50.2 180.06,50.2 179.61,49.74 179.61,45.77 180.3,45.08 180.3,43.68 180.61,43.37 185.26,43.37 185.75,43.86 185.75,49.92
U2_PHASE3 on TOP (solid shape): 192.67,49.43 192.67,43.61 192.34,43.28 192.34,39.27 189.68,39.27 189.68,43.27 189.42,43.52 188.03,43.52 188.01,43.51 187.78,43.51 187.63,43.66 187.63,44.18 187.29,44.52 187.29,49.46 187.55,49.72 192.38,49.72
U2_PHASE3 on TOP (solid shape): 188.5,29.85 189.37,29.85 189.42,29.81 189.42,29.55 189.39,29.52 188.32,29.52 188.3,29.52 188.23,29.6 187.34,29.6 187.33,29.59 187.29,29.59 187.28,29.58 186.22,29.58 186.14,29.67 186.14,30.35 186.22,30.43 187.92,30.43
U2_PHASE3 on BOTTOM (solid shape): 192.64,49.69 192.64,43.59 192.45,43.39 192.45,38.75 192.42,38.73 189.77,38.73 189.74,38.76 189.74,42.83 189.1,43.47 187.8,43.47 187.56,43.7 187.56,44.48 186.81,45.23 186.81,49.67 186.94,49.8 192.54,49.8
U2_PHASE3 on IN2 (solid shape): 192.78,49.7 192.78,43.73 192.19,43.14 187.8,43.14 187.63,43.31 187.63,44.82 186.99,45.46 186.99,49.34 187.64,49.99 192.48,49.99
U2_PHASE3 on IN4 (solid shape): 188.46,30.86 188.46,29.68 188.39,29.62 187.42,29.62 187.29,29.75 187.29,30.87 187.36,30.94 188.38,30.94
U2_PHASE3 on IN4 (solid shape): 190.35,43.92 190.35,42.95 190.08,42.68 189.32,42.68 189.18,42.81 189.18,43.93 189.26,44 190.27,44
U2_PHASE3 on IN1, IN3, IN5, IN6: 187.21,42.95 192.45,42.95 192.96,43.46 192.96,49.4 192.5,49.85 186.99,49.85 186.58,49.44 186.58,43.58
U2_PHASE3 on IN4: 188.66,43.4 187.77,43.4 187.61,43.56 187.61,44.08 187.15,44.53 187.15,49.57 187.74,50.16 192.38,50.16 193.27,49.27 193.27,43.77 192.8,43.3 190.78,43.3 190.57,43.51 190.57,43.96 190.37,44.16 189.1,44.16 188.97,44.03 188.97,43.7
U2_UGATE1 on TOP (solid shape): 172.35,43.82 172.35,42.97 172.24,42.86 171.14,42.86 171.04,42.97 171.04,43.85 171.15,43.96 172.2,43.96
U2_UGATE1 on TOP (solid shape): 178.29,26.93 179.22,26.93 179.3,26.85 179.3,26.74 179.23,26.67 178.26,26.67 178.21,26.62 177.7,26.62 177.12,27.2 177.12,27.48 177.25,27.62 177.6,27.62
U2_UGATE1 on BOTTOM (solid shape): 172.23,38.57 172.63,38.57 172.75,38.44 172.75,38.06 172.55,37.86 171.22,37.86 171.06,38.02 171.06,39.05 171.2,39.2 171.59,39.2
U2_UGATE1 on IN4 (solid shape): 178.33,27.47 178.33,27.03 177.88,26.58 177.13,26.58 176.27,27.44 176.27,27.65 177.07,28.44 177.35,28.44
U2_UGATE1 on IN4 (solid shape): 172.67,43.84 172.67,38.76 173.51,37.92 173.51,37.39 173.12,37 172.77,37 171.57,38.2 171.57,43.65 171.91,44 172.52,44
U2_UGATE2 on TOP (solid shape): 186.46,39.83 186.46,38.92 186.36,38.83 184.93,38.83 184.86,38.9 184.86,39.84 184.97,39.95 186.34,39.95
U2_UGATE2 on TOP (solid shape): 184.22,27.58 184.22,26.98 183.84,26.6 182.29,26.6 182.2,26.69 182.2,26.86 182.28,26.94 183.24,26.94 183.65,27.35 183.65,27.59 183.79,27.73 184.07,27.73
U2_UGATE2 on BOTTOM (solid shape): 186.49,42.97 186.49,42.08 186.36,41.95 185.2,41.95 185.06,42.09 185.06,43 185.15,43.08 186.38,43.08
U2_UGATE2 on IN4 (solid shape): 184.61,28.38 184.61,26.7 184.42,26.51 183.47,26.51 183.36,26.62 183.36,27.93 183.92,28.5 184.49,28.5
U2_UGATE2 on IN4 (solid shape): 186.45,42.86 186.45,42.12 185.81,41.47 185.81,40.38 186.45,39.73 186.45,38.94 185.76,38.25 185.34,38.25 185.25,38.34 185.25,38.38 184.78,38.84 184.78,41.92 185.92,43.06 186.26,43.06
U2_UGATE3 on TOP (solid shape): 187.48,44 187.48,43.63 187.72,43.39 187.72,43.01 187.57,42.86 186.72,42.86 186.28,43.3 186.28,43.97 186.44,44.13 187.34,44.13
U2_UGATE3 on TOP (solid shape): 188.33,29.31 189.36,29.31 189.42,29.26 189.42,29.11 189.42,29.06 189.34,28.98 187.44,28.98 187.43,28.98 187.37,28.98 187.27,29.09 187.27,29.35 187.39,29.47 188.17,29.47
U2_UGATE3 on BOTTOM (solid shape): 187.21,39.21 187.98,39.21 188.09,39.1 188.09,37.96 187.97,37.84 186.96,37.84 186.87,37.93 186.87,39.06 187.03,39.22 187.2,39.22
U2_UGATE3 on IN2 (solid shape): 188.99,29.41 188.99,28.47 188.88,28.36 187.46,28.36 187.22,28.6 187.22,29.31 187.39,29.48 188.91,29.48
U2_UGATE3 on IN2 (solid shape): 189.34,38.16 189.34,37.23 189.13,37.02 188.63,37.02 187.97,37.68 187.21,37.68 186.83,38.07 186.83,39.04 187.08,39.29 188.2,39.29
U2_UGATE3 on IN2 (solid shape): 186.54,44.13 187.4,44.13 187.5,44.04 187.5,42.67 187.22,42.38 186.67,42.38 186.55,42.5 186.55,43.03 186.34,43.24 186.34,44.05 186.43,44.14 186.54,44.14
UG_3V on TOP (solid shape): 37.91,23.9 37.91,23.08 37.78,22.95 36.83,22.95 36.71,23.08 36.71,23.84 36.9,24.03 37.78,24.03
UG_3V on TOP (solid shape): 25.08,27.21 25.08,26.51 24.96,26.38 24.7,26.38 24.58,26.51 24.58,26.7 24.13,27.14 24.13,27.97 24.2,28.03 24.26,28.03
UG_3V on IN1 (solid shape): 25.85,26.51 26.16,26.51 26.16,25.49 25.47,25.49 24.39,26.57 24.39,27.4 24.51,27.52 24.83,27.52
UG_3V on IN1 (solid shape): 37.91,23.9 37.91,23.08 37.72,22.89 36.39,22.89 36.26,23.01 36.26,23.59 36.71,24.03 37.78,24.03
UG_5V on TOP (solid shape): 35.82,31.14 35.82,30.38 35.69,30.25 34.86,30.25 34.74,30.38 34.74,31.14 34.86,31.27 35.69,31.27
UG_5V on TOP (solid shape): 25.28,31.4 25.28,31.14 24.39,30.25 24.39,30.14 24.27,30.02 24.2,30.02 24.14,30.08 24.14,30.96 24.7,31.52 25.15,31.52
UG_5V on IN6 (solid shape): 26.1,31.14 26.04,31.08 25.28,31.08 24.77,30.57 24.58,30.57 24.39,30.76 24.39,31.33 25.15,32.09 26.1,32.09
UG_5V on IN6 (solid shape): 35.82,31.84 35.82,30.38 35.69,30.25 34.86,30.25 34.74,30.38 34.74,30.82 34.48,31.08 34.29,31.08 34.29,32.03 34.36,32.09 35.56,32.09
UG_+1.05VSP on BOTTOM (solid shape): 248.32,25.39 249.15,25.39 249.28,25.27 249.28,24.14 249.14,24 248.22,24 248.15,24.07 248.15,25.3 248.25,25.39 248.31,25.39
UG_+1.05VSP on BOTTOM (solid shape): 245.17,27.14 246.59,27.14 246.84,26.89 246.84,26.12 246.7,25.98 246.32,25.98 246.13,26.17 246.13,26.46 246.03,26.56 246.03,26.75 245.92,26.86 245.1,26.86 245.04,26.92 245.04,27.11 245.08,27.14
UG_+1.05VSP on IN2 (solid shape): 248.82,25.07 248.82,24.05 248.66,23.88 247.8,23.88 245.87,25.82 245.87,26.88 246.02,27.03 246.87,27.03
UG_+1.35VS_VGAP on TOP (solid shape): 144.72,110.58 144.72,109.63 144.53,109.44 143.58,109.44 143.39,109.63 143.39,110.58 143.58,110.77 144.53,110.77
UG_+1.35VS_VGAP on BOTTOM (solid shape): 136.02,109.31 136.02,108.3 135.92,108.2 135.6,108.2 135.49,108.31 135.49,109.11 135.37,109.23 134.58,109.23 134.5,109.31 134.58,109.51 135.82,109.51
UG_+1.35VS_VGAP on IN2 (solid shape): 136.56,109.13 136.56,107.26 136.35,107.04 135.77,107.04 135.09,107.71 135.09,109.23 135.28,109.42 136.27,109.42
UG_+1.35VS_VGAP on IN2 (solid shape): 144.59,109.88 144.59,108.87 144.34,108.61 143.7,108.61 143.45,108.87 143.45,109.82 143.64,110.01 144.46,110.01
UGATE1 on TOP (solid shape): 122.47,127.43 122.47,126.86 122.25,126.65 121.33,126.65 121.19,126.79 121.19,127.56 121.35,127.73 122.18,127.73
UGATE1 on BOTTOM (solid shape): 122.46,123.38 122.46,122.76 122.42,122.72 122.42,122.42 122.28,122.28 121.47,122.28 121.34,122.41 121.34,122.89 122.02,123.57 122.27,123.57
UGATE1 on BOTTOM (solid shape): 136.79,124.85 136.79,124.76 136.03,124.01 136.03,123.73 135.39,123.09 135.2,123.09 135.04,123.25 135.04,123.46 135.6,124.02 136.64,124.91 136.72,124.91
UGATE1 on IN2 (solid shape): 136.34,123.56 136.34,122.71 134.81,121.18 134.66,121.18 134.08,121.76 134.08,122 134.99,122.91 134.99,123.41 135.63,124.05 135.85,124.05
UGATE1 on IN2 (solid shape): 122.81,127.6 122.81,124.74 122.48,124.36 122.81,123.98 122.81,123.13 122.43,122.75 122.43,121.41 122.18,121.15 121.6,121.15 121.29,121.47 121.29,123.09 121.51,123.32 121.52,123.32 121.62,123.39 121.69,123.49 121.7,123.5 121.73,123.53 121.73,126.52 121.6,126.65 121.35,126.65 121.22,126.77 121.22,127.66 121.45,127.88 122.53,127.88
UGATE2 on TOP (solid shape): 114.11,127.82 114.11,126.93 113.87,126.69 113.48,126.69 113.32,126.85 113.32,127.15 113.1,127.38 113.1,127.82 113.22,127.95 113.98,127.95
UGATE2 on BOTTOM (solid shape): 114.24,123.15 114.24,122.39 114.11,122.26 113.3,122.26 113.19,122.38 113.19,123.25 113.49,123.55 113.84,123.55
UGATE2 on BOTTOM (solid shape): 135.68,126.96 135.68,126.86 135.6,126.78 135.5,126.78 135.05,127.23 135.04,127.23 134.94,127.33 134.94,127.34 134.89,127.39 133.83,127.39 133.68,127.55 133.68,127.82 133.83,127.97 134.66,127.97
UGATE2 on IN2 (solid shape): 135,128.28 135,127.73 134.72,127.45 133.9,127.45 133.26,128.09 133.26,128.44 133.8,128.98 134.3,128.98
UGATE2 on IN2 (solid shape): 114.3,128.61 114.3,124.74 113.95,124.36 114.3,123.98 114.3,122.39 114.11,122.2 113.29,122.2 113.16,122.33 113.16,123.38 113.29,123.65 113.18,123.93 113.16,123.95 113.16,124.01 113.18,124.03 113.29,124.3 113.18,124.56 113.16,124.58 113.16,124.65 113.18,124.66 113.29,124.93 113.18,125.2 113.16,125.22 113.16,125.28 113.18,125.3 113.29,125.57 113.18,125.83 113.16,125.85 113.16,125.92 113.18,125.93 113.29,126.2 113.18,126.47 113.16,126.49 113.16,126.55 113.18,126.57 113.29,126.85 113.16,127.12 113.16,128.68 113.54,129.06 113.86,129.06
UGATE3 on TOP (solid shape): 105.79,122.46 105.79,122.07 105.6,121.88 103.7,121.88 103.51,122.07 103.51,122.65 103.57,122.71 105.54,122.71
UGATE3 on TOP (solid shape): 105.6,127.15 105.6,126.58 105.41,126.39 104.59,126.39 104.33,126.14 103.89,126.14 103.57,126.46 103.57,126.9 104.02,127.34 105.41,127.34
UGATE3 on BOTTOM (solid shape): 105.78,123.23 105.78,122.36 105.64,122.22 104.8,122.22 104.71,122.3 104.71,123.25 105.03,123.57 105.44,123.57
UGATE3 on IN2 (solid shape): 102.62,116.39 102.62,115.57 102.55,115.5 101.16,115.5 100.86,115.8 100.86,116.34 100.97,116.45 102.55,116.45
UGATE3 on IN2 (solid shape): 105.76,122.55 105.76,122.42 104.21,120.87 103.82,120.87 103.44,121.25 103.44,121.57 104.68,122.8 105.51,122.8
