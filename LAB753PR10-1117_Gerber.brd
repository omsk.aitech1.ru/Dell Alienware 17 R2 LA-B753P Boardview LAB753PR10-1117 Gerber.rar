# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Nets (continued)
EC_SMB_DA2: QH3.4 QV13.6 RE90.1 RM68.1 RM90.1 U2407.9 U2410.7 UE5.80
EC_SMI#: UE5.15 UH1.Y1
EC_TX: JWLAN1.30 RM31.1 UE5.30
ECAGND: CE33.2 CE35.1 LE2.2 PH1.2 UE5.69
EDP_AUX#_C: CV13.1 JEDP1.14
EDP_AUX_C: CV12.1 JEDP1.13
EDP_COMP: CPU1.AG6 RC32.2
EDP_DISP_UTIL: CPU1.E12 RC33.1
EDP_HPD_R: CPU1.E14 QC1.1 RC34.1
EDP_TX0#_C: CV2.1 JEDP1.2
EDP_TX0_C: CV1.1 JEDP1.1
EDP_TX1#_C: CV4.1 JEDP1.5
EDP_TX1_C: CV3.1 JEDP1.4
EDP_TX2#_C: CV6.1 JEDP1.8
EDP_TX2_C: CV8.1 JEDP1.7
EDP_TX3#_C: CV11.1 JEDP1.11
EDP_TX3_C: CV7.1 JEDP1.10
ELC_8051_C2CK_RST#: JELC1.2 RE7.2 UE1.9
ELC_8051_C2D_P3: JELC1.3 UE1.10
EN_0.675VSP: PC214.1 PR209.2 PU200.7
EN_1.2V: CA112.1 RA128.1 UA5.5
EN_1.5V: PC409.1 PR407.1 PU401.5
EN_1.35V: PC213.1 PR208.2 PU200.8
EN_+1.05V_GPUP: PC659.1 PR403.1 PR677.2 PU602.5
EN_+1.05VSP: PC300.1 PR300.2 PR304.2 PU300.3
EN_+1.35VS_VGAP: PC312.1 PR313.2 PR315.2 PU301.3
EN_INVPWR: QV2.2 RE80.1 UE5.68
EN_TPLED: C2509.1 Q2409.3 Q2410.1 R179.1 R180.1
EN_WOL#: CL42.1 RE79.2 UE5.98 UL2.4
ENSMB: RM64.1 RM66.1 UM8.48
ENVDD_R: RV3.2 UV17.4
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
FB: PR533.2 PR537.2 PR543.2 PU500.8
FB_1.2V: RA127.1 RA129.2 UA5.2
FB_1.5V: PR405.2 PR406.1 PU401.2
FB_1.35V: PR205.1 PR207.1 PU200.6
FB_3V: PR101.2 PR103.2 PU100.4
FB_5V: PR102.1 PR104.1 PU100.2
FB_+1.05V_GPUP: PC661.2 PR681.2 PR685.1 PU602.6
FB_+1.05VSP: PR307.1 PR308.1 PU300.4
FB_+1.35VS_VGAP: PR310.1 PR316.1 PU301.4
FB_VDDQ_SENSE: PR317.2 UV1.R49
FBA_ABI#_H: UV1.AN49 UV7.J4
FBA_ABI#_L: UV1.AA48 UV6.J4
FBA_CAS#_H: UV1.BB49 UV7.G3
FBA_CAS#_L: UV1.U47 UV6.L3
FBA_CKE_H: RV109.2 UV1.BA48 UV7.J3
FBA_CKE_L: RV110.2 UV1.U48 UV6.J3
FBA_CLK0: RV123.1 UV1.AF41 UV6.J12
FBA_CLK0#: RV123.2 UV1.AF40 UV6.J11
FBA_CLK1: RV175.1 UV1.AJ44 UV7.J12
FBA_CLK1#: RV175.2 UV1.AJ45 UV7.J11
FBA_CS#_H: UV1.AG49 UV7.L12
FBA_CS#_L: UV1.AF48 UV6.G12
FBA_D0: UV1.V43 UV6.A4
FBA_D1: UV1.V41 UV6.A2
FBA_D2: UV1.V44 UV6.B4
FBA_D3: UV1.V42 UV6.B2
FBA_D4: UV1.U43 UV6.E4
FBA_D5: UV1.U44 UV6.E2
FBA_D6: UV1.U41 UV6.F4
FBA_D7: UV1.U42 UV6.F2
FBA_D8: UV1.AA46 UV6.A11
FBA_D9: UV1.AC46 UV6.A13
FBA_D10: UV1.AA45 UV6.B11
FBA_D11: UV1.AA47 UV6.B13
FBA_D12: UV1.Y46 UV6.E11
FBA_D13: UV1.Y49 UV6.E13
FBA_D14: UV1.Y45 UV6.F11
FBA_D15: UV1.Y48 UV6.F13
FBA_D16: UV1.AJ46 UV6.U11
FBA_D17: UV1.AG47 UV6.U13
FBA_D18: UV1.AG46 UV6.T11
FBA_D19: UV1.AG45 UV6.T13
FBA_D20: UV1.AF44 UV6.N11
FBA_D21: UV1.AF45 UV6.N13
FBA_D22: UV1.AD46 UV6.M11
FBA_D23: UV1.AD45 UV6.M13
FBA_D24: UV1.AD44 UV6.U4
FBA_D25: UV1.AD43 UV6.U2
FBA_D26: UV1.AD42 UV6.T4
FBA_D27: UV1.AC42 UV6.T2
FBA_D28: UV1.AA44 UV6.N4
FBA_D29: UV1.AA43 UV6.N2
FBA_D30: UV1.AA42 UV6.M4
FBA_D31: UV1.AA40 UV6.M2
FBA_D32: UV1.AT48 UV7.U4
FBA_D33: UV1.AT46 UV7.U2
FBA_D34: UV1.AT49 UV7.T4
FBA_D35: UV1.AT47 UV7.T2
FBA_D36: UV1.AW47 UV7.N4
FBA_D37: UV1.AW48 UV7.N2
FBA_D38: UV1.BA47 UV7.M4
FBA_D39: UV1.AW46 UV7.M2
FBA_D40: UV1.AR46 UV7.U11
FBA_D41: UV1.AN45 UV7.U13
FBA_D42: UV1.AR49 UV7.T11
FBA_D43: UV1.AR48 UV7.T13
FBA_D44: UV1.AT45 UV7.N11
FBA_D45: UV1.AR44 UV7.N13
FBA_D46: UV1.AN41 UV7.M11
FBA_D47: UV1.AN42 UV7.M13
FBA_D48: UV1.AG40 UV7.A11
FBA_D49: UV1.AG43 UV7.A13
FBA_D50: UV1.AG41 UV7.B11
FBA_D51: UV1.AJ43 UV7.B13
FBA_D52: UV1.AJ40 UV7.E11
FBA_D53: UV1.AK40 UV7.E13
FBA_D54: UV1.AK42 UV7.F11
FBA_D55: UV1.AK41 UV7.F13
FBA_D56: UV1.AK45 UV7.A4
FBA_D57: UV1.AK43 UV7.A2
FBA_D58: UV1.AK48 UV7.B4
FBA_D59: UV1.AK49 UV7.B2
FBA_D60: UV1.AM45 UV7.E4
FBA_D61: UV1.AM44 UV7.E2
FBA_D62: UV1.AK44 UV7.F4
FBA_D63: UV1.AM43 UV7.F2
FBA_DBI0#: UV1.U40 UV6.D2
FBA_DBI1#: UV1.AC45 UV6.D13
FBA_DBI2#: UV1.AG44 UV6.P13
FBA_DBI3#: UV1.AA41 UV6.P2
FBA_DBI4#: UV1.AV45 UV7.P2
FBA_DBI5#: UV1.AR45 UV7.P13
FBA_DBI6#: UV1.AG42 UV7.D13
FBA_DBI7#: UV1.AM46 UV7.D2
FBA_EDC0: UV1.U45 UV6.C2
FBA_EDC1: UV1.Y43 UV6.C13
FBA_EDC2: UV1.AF42 UV6.R13
FBA_EDC3: UV1.AC44 UV6.R2
FBA_EDC4: UV1.AV47 UV7.R2
FBA_EDC5: UV1.AN43 UV7.R13
FBA_EDC6: UV1.AJ42 UV7.C13
FBA_EDC7: UV1.AK47 UV7.C2
FBA_MA0_MA10_H: UV1.AV49 UV7.K4
FBA_MA0_MA10_L: UV1.V47 UV6.H4
FBA_MA1_MA9_H: UV1.AV48 UV7.K5
FBA_MA1_MA9_L: UV1.V49 UV6.H5
FBA_MA2_BA0_H: UV1.AJ48 UV7.K11
FBA_MA2_BA0_L: UV1.AD47 UV6.H11
FBA_MA3_BA3_H: UV1.AG48 UV7.K10
FBA_MA3_BA3_L: UV1.AF47 UV6.H10
FBA_MA4_BA2_H: UV1.AJ49 UV7.H11
FBA_MA4_BA2_L: UV1.AD48 UV6.K11
FBA_MA5_BA1_H: UV1.AJ47 UV7.H10
FBA_MA5_BA1_L: UV1.AD49 UV6.K10
FBA_MA6_MA11_H: UV1.AM47 UV7.H5
FBA_MA6_MA11_L: UV1.AC48 UV6.K5
FBA_MA7_MA8_H: UV1.AM49 UV7.H4
FBA_MA7_MA8_L: UV1.AC49 UV6.K4
FBA_MA12_RFU_H: UV1.AN48 UV7.J5
FBA_MA12_RFU_L: UV1.AA49 UV6.J5
FBA_RAS#_H: UV1.AW49 UV7.L3
FBA_RAS#_L: UV1.V48 UV6.G3
FBA_RST#_H: RV107.1 UV1.BA49 UV7.J2
FBA_RST#_L: RV108.1 UV1.U49 UV6.J2
FBA_WCK0: UV1.V46 UV6.D4
FBA_WCK0_N: UV1.V45 UV6.D5
FBA_WCK1: UV1.AD41 UV6.P4
FBA_WCK1_N: UV1.AD40 UV6.P5
FBA_WCK2: UV1.AT44 UV7.P4
FBA_WCK2_N: UV1.AT43 UV7.P5
FBA_WCK3: UV1.AM42 UV7.D4
FBA_WCK3_N: UV1.AM41 UV7.D5
FBA_WE#_H: UV1.AM48 UV7.G12
FBA_WE#_L: UV1.AC47 UV6.L12
FBB_ABI#_H: UV1.B44 UV9.J4
FBB_ABI#_L: UV1.C32 UV8.J4
FBB_CAS#_H: UV1.D49 UV9.G3
FBB_CAS#_L: UV1.C29 UV8.L3
FBB_CKE_H: RV113.2 UV1.C48 UV9.J3
FBB_CKE_L: RV114.2 UV1.B29 UV8.J3
FBB_CLK0: RV178.1 UV1.E41 UV8.J12
FBB_CLK0#: RV178.2 UV1.F41 UV8.J11
FBB_CLK1: RV138.1 UV1.E42 UV9.J12
FBB_CLK1#: RV138.2 UV1.D42 UV9.J11
FBB_CS#_H: UV1.A39 UV9.L12
FBB_CS#_L: UV1.B38 UV8.G12
FBB_D0: UV1.D30 UV8.A4
FBB_D1: UV1.G30 UV8.A2
FBB_D2: UV1.E30 UV8.B4
FBB_D3: UV1.F30 UV8.B2
FBB_D4: UV1.G29 UV8.E4
FBB_D5: UV1.F29 UV8.E2
FBB_D6: UV1.J29 UV8.F4
FBB_D7: UV1.H29 UV8.F2
FBB_D8: UV1.C33 UV8.A11
FBB_D9: UV1.E33 UV8.A13
FBB_D10: UV1.F33 UV8.B11
FBB_D11: UV1.D33 UV8.B13
FBB_D12: UV1.C30 UV8.E11
FBB_D13: UV1.K33 UV8.E13
FBB_D14: UV1.E32 UV8.F11
FBB_D15: UV1.D32 UV8.F13
FBB_D16: UV1.H39 UV8.U11
FBB_D17: UV1.G39 UV8.U13
FBB_D18: UV1.F39 UV8.T11
FBB_D19: UV1.D41 UV8.T13
FBB_D20: UV1.F38 UV8.N11
FBB_D21: UV1.G38 UV8.N13
FBB_D22: UV1.D38 UV8.M11
FBB_D23: UV1.E38 UV8.M13
FBB_D24: UV1.F36 UV8.U4
FBB_D25: UV1.K35 UV8.U2
FBB_D26: UV1.E36 UV8.T4
FBB_D27: UV1.D36 UV8.T2
FBB_D28: UV1.G35 UV8.N4
FBB_D29: UV1.F35 UV8.N2
FBB_D30: UV1.D35 UV8.M4
FBB_D31: UV1.E35 UV8.M2
FBB_D32: UV1.M44 UV9.U4
FBB_D33: UV1.P42 UV9.U2
FBB_D34: UV1.M43 UV9.T4
FBB_D35: UV1.P43 UV9.T2
FBB_D36: UV1.R45 UV9.N4
FBB_D37: UV1.R46 UV9.N2
FBB_D38: UV1.R43 UV9.M4
FBB_D39: UV1.R44 UV9.M2
FBB_D40: UV1.M47 UV9.U11
FBB_D41: UV1.P44 UV9.U13
FBB_D42: UV1.M46 UV9.T11
FBB_D43: UV1.M45 UV9.T13
FBB_D44: UV1.P47 UV9.N11
FBB_D45: UV1.P49 UV9.N13
FBB_D46: UV1.P45 UV9.M11
FBB_D47: UV1.P46 UV9.M13
FBB_D48: UV1.F46 UV9.A11
FBB_D49: UV1.E47 UV9.A13
FBB_D50: UV1.D47 UV9.B11
FBB_D51: UV1.D48 UV9.B13
FBB_D52: UV1.F48 UV9.E11
FBB_D53: UV1.H46 UV9.E13
FBB_D54: UV1.H47 UV9.F11
FBB_D55: UV1.H48 UV9.F13
FBB_D56: UV1.L45 UV9.A4
FBB_D57: UV1.L44 UV9.A2
FBB_D58: UV1.J46 UV9.B4
FBB_D59: UV1.H49 UV9.B2
FBB_D60: UV1.L47 UV9.E4
FBB_D61: UV1.J49 UV9.E2
FBB_D62: UV1.L48 UV9.F4
FBB_D63: UV1.L49 UV9.F2
FBB_DBI0#: UV1.E29 UV8.D2
FBB_DBI1#: UV1.G33 UV8.D13
FBB_DBI2#: UV1.H38 UV8.P13
FBB_DBI3#: UV1.C36 UV8.P2
FBB_DBI4#: UV1.P41 UV9.P2
FBB_DBI5#: UV1.P48 UV9.P13
FBB_DBI6#: UV1.F47 UV9.D13
FBB_DBI7#: UV1.L46 UV9.D2
FBB_EDC0: UV1.J30 UV8.C2
FBB_EDC1: UV1.H33 UV8.C13
FBB_EDC2: UV1.D39 UV8.R13
FBB_EDC3: UV1.J35 UV8.R2
FBB_EDC4: UV1.R42 UV9.R2
FBB_EDC5: UV1.M48 UV9.R13
FBB_EDC6: UV1.F49 UV9.C13
FBB_EDC7: UV1.J47 UV9.C2
FBB_MA0_MA10_H: UV1.C44 UV9.K4
FBB_MA0_MA10_L: UV1.B32 UV8.H4
FBB_MA1_MA9_H: UV1.A45 UV9.K5
FBB_MA1_MA9_L: UV1.B30 UV8.H5
FBB_MA2_BA0_H: UV1.C39 UV9.K11
FBB_MA2_BA0_L: UV1.A36 UV8.H11
FBB_MA3_BA3_H: UV1.B39 UV9.K10
FBB_MA3_BA3_L: UV1.B36 UV8.H10
FBB_MA4_BA2_H: UV1.B41 UV9.H11
FBB_MA4_BA2_L: UV1.C35 UV8.K11
FBB_MA5_BA1_H: UV1.A41 UV9.H10
FBB_MA5_BA1_L: UV1.A35 UV8.K10
FBB_MA6_MA11_H: UV1.C42 UV9.H5
FBB_MA6_MA11_L: UV1.A33 UV8.K5
FBB_MA7_MA8_H: UV1.B42 UV9.H4
FBB_MA7_MA8_L: UV1.B33 UV8.K4
FBB_MA12_RFU_H: UV1.A44 UV9.J5
FBB_MA12_RFU_L: UV1.A32 UV8.J5
FBB_RAS#_H: UV1.A46 UV9.L3
FBB_RAS#_L: UV1.A30 UV8.G3
FBB_RST#_H: RV112.1 UV1.B46 UV9.J2
FBB_RST#_L: RV111.1 UV1.A29 UV8.J2
FBB_WCK0: UV1.F32 UV8.D4
FBB_WCK0_N: UV1.G32 UV8.D5
FBB_WCK1: UV1.G36 UV8.P4
FBB_WCK1_N: UV1.H36 UV8.P5
FBB_WCK2: UV1.M42 UV9.P4
FBB_WCK2_N: UV1.M41 UV9.P5
FBB_WCK3: UV1.H45 UV9.D4
FBB_WCK3_N: UV1.H44 UV9.D5
FBB_WE#_H: UV1.A42 UV9.G12
FBB_WE#_L: UV1.B35 UV8.L12
FBC_ABI#_H: UV1.B23 UV12.J4
FBC_ABI#_L: UV1.A11 UV13.J4
FBC_CAS#_H: UV1.C27 UV12.G3
FBC_CAS#_L: UV1.B3 UV13.L3
FBC_CKE_H: RV148.2 UV1.B27 UV12.J3
FBC_CKE_L: RV147.2 UV1.A4 UV13.J3
FBC_CLK0: RV179.1 UV1.F15 UV13.J12
FBC_CLK0#: RV179.2 UV1.E15 UV13.J11
FBC_CLK1: RV141.1 UV1.J18 UV12.J12
FBC_CLK1#: RV141.2 UV1.K18 UV12.J11
FBC_CS#_H: UV1.B18 UV12.L12
FBC_CS#_L: UV1.A17 UV13.G12
FBC_D0: UV1.A8 UV13.A4
FBC_D1: UV1.D8 UV13.A2
FBC_D2: UV1.B8 UV13.B4
FBC_D3: UV1.C8 UV13.B2
FBC_D4: UV1.C5 UV13.E4
FBC_D5: UV1.B5 UV13.E2
FBC_D6: UV1.D5 UV13.F4
FBC_D7: UV1.C4 UV13.F2
FBC_D8: UV1.B9 UV13.A11
FBC_D9: UV1.E11 UV13.A13
FBC_D10: UV1.D9 UV13.B11
FBC_D11: UV1.A9 UV13.B13
FBC_D12: UV1.H11 UV13.E11
FBC_D13: UV1.F9 UV13.E13
FBC_D14: UV1.J11 UV13.F11
FBC_D15: UV1.E8 UV13.F13
FBC_D16: UV1.K17 UV13.U11
FBC_D17: UV1.G17 UV13.U13
FBC_D18: UV1.J17 UV13.T11
FBC_D19: UV1.G15 UV13.T13
FBC_D20: UV1.K15 UV13.N11
FBC_D21: UV1.K14 UV13.N13
FBC_D22: UV1.H14 UV13.M11
FBC_D23: UV1.J14 UV13.M13
FBC_D24: UV1.E14 UV13.U4
FBC_D25: UV1.F14 UV13.U2
FBC_D26: UV1.A14 UV13.T4
FBC_D27: UV1.B14 UV13.T2
FBC_D28: UV1.E12 UV13.N4
FBC_D29: UV1.F12 UV13.N2
FBC_D30: UV1.G12 UV13.M4
FBC_D31: UV1.G14 UV13.M2
FBC_D32: UV1.G26 UV12.U4
FBC_D33: UV1.J26 UV12.U2
FBC_D34: UV1.F26 UV12.T4
FBC_D35: UV1.H26 UV12.T2
FBC_D36: UV1.G27 UV12.N4
FBC_D37: UV1.F27 UV12.N2
FBC_D38: UV1.J27 UV12.M4
FBC_D39: UV1.H27 UV12.M2
FBC_D40: UV1.E23 UV12.U11
FBC_D41: UV1.D21 UV12.U13
FBC_D42: UV1.D23 UV12.T11
FBC_D43: UV1.C23 UV12.T13
FBC_D44: UV1.A24 UV12.N11
FBC_D45: UV1.B24 UV12.N13
FBC_D46: UV1.E24 UV12.M11
FBC_D47: UV1.D24 UV12.M13
FBC_D48: UV1.D15 UV12.A11
FBC_D49: UV1.C17 UV12.A13
FBC_D50: UV1.D17 UV12.B11
FBC_D51: UV1.E17 UV12.B13
FBC_D52: UV1.F18 UV12.E11
FBC_D53: UV1.E18 UV12.E13
FBC_D54: UV1.D20 UV12.F11
FBC_D55: UV1.E20 UV12.F13
FBC_D56: UV1.G20 UV12.A4
FBC_D57: UV1.H20 UV12.A2
FBC_D58: UV1.F20 UV12.B4
FBC_D59: UV1.H21 UV12.B2
FBC_D60: UV1.F23 UV12.E4
FBC_D61: UV1.G23 UV12.E2
FBC_D62: UV1.H23 UV12.F4
FBC_D63: UV1.K23 UV12.F2
FBC_DBI0#: UV1.E6 UV13.D2
FBC_DBI1#: UV1.E9 UV13.D13
FBC_DBI2#: UV1.H17 UV13.P13
FBC_DBI3#: UV1.D12 UV13.P2
FBC_DBI4#: UV1.K27 UV12.P2
FBC_DBI5#: UV1.E21 UV12.P13
FBC_DBI6#: UV1.F17 UV12.D13
FBC_DBI7#: UV1.J23 UV12.D2
FBC_EDC0: UV1.D6 UV13.C2
FBC_EDC1: UV1.F11 UV13.C13
FBC_EDC2: UV1.H15 UV13.R13
FBC_EDC3: UV1.C14 UV13.R2
FBC_EDC4: UV1.E27 UV12.R2
FBC_EDC5: UV1.F24 UV12.R13
FBC_EDC6: UV1.H18 UV12.C13
FBC_EDC7: UV1.G21 UV12.C2
FBC_MA0_MA10_H: UV1.B26 UV12.K4
FBC_MA0_MA10_L: UV1.B6 UV13.H4
FBC_MA1_MA9_H: UV1.A26 UV12.K5
FBC_MA1_MA9_L: UV1.A6 UV13.H5
FBC_MA2_BA0_H: UV1.C20 UV12.K11
FBC_MA2_BA0_L: UV1.B15 UV13.H11
FBC_MA3_BA3_H: UV1.C18 UV12.K10
FBC_MA3_BA3_L: UV1.B17 UV13.H10
FBC_MA4_BA2_H: UV1.B20 UV12.H11
FBC_MA4_BA2_L: UV1.A15 UV13.K11
FBC_MA5_BA1_H: UV1.A20 UV12.H10
FBC_MA5_BA1_L: UV1.C15 UV13.K10
FBC_MA6_MA11_H: UV1.B21 UV12.H5
FBC_MA6_MA11_L: UV1.C12 UV13.K5
FBC_MA7_MA8_H: UV1.A21 UV12.H4
FBC_MA7_MA8_L: UV1.A12 UV13.K4
FBC_MA12_RFU_H: UV1.A23 UV12.J5
FBC_MA12_RFU_L: UV1.B11 UV13.J5
FBC_RAS#_H: UV1.C26 UV12.L3
FBC_RAS#_L: UV1.A5 UV13.G3
FBC_RST#_H: RV115.1 UV1.A27 UV12.J2
FBC_RST#_L: RV146.1 UV1.B4 UV13.J2
FBC_WCK0: UV1.F8 UV13.D4
FBC_WCK0_N: UV1.G8 UV13.D5
FBC_WCK1: UV1.H12 UV13.P4
FBC_WCK1_N: UV1.J12 UV13.P5
FBC_WCK2: UV1.D26 UV12.P4
FBC_WCK2_N: UV1.E26 UV12.P5
FBC_WCK3: UV1.J20 UV12.D4
FBC_WCK3_N: UV1.K20 UV12.D5
FBC_WE#_H: UV1.C21 UV12.G12
FBC_WE#_L: UV1.B12 UV13.L12
FBD_ABI#_H: UV1.L1 UV16.J4
FBD_ABI#_L: UV1.AC2 UV15.J4
FBD_CAS#_H: UV1.C2 UV16.G3
FBD_CAS#_L: UV1.AG3 UV15.L3
FBD_CKE_H: RV152.2 UV1.D1 UV16.J3
FBD_CKE_L: RV150.2 UV1.AG2 UV15.J3
FBD_CLK0: RV182.1 UV1.V9 UV15.J12
FBD_CLK0#: RV182.2 UV1.V10 UV15.J11
FBD_CLK1: RV212.1 UV1.R6 UV16.J12
FBD_CLK1#: RV212.2 UV1.R5 UV16.J11
FBD_CS#_H: UV1.U1 UV16.L12
FBD_CS#_L: UV1.V2 UV15.G12
FBD_D0: UV1.AF7 UV15.A4
FBD_D1: UV1.AF9 UV15.A2
FBD_D2: UV1.AF6 UV15.B4
FBD_D3: UV1.AF8 UV15.B2
FBD_D4: UV1.AG7 UV15.E4
FBD_D5: UV1.AG6 UV15.E2
FBD_D6: UV1.AG9 UV15.F4
FBD_D7: UV1.AG8 UV15.F2
FBD_D8: UV1.AC5 UV15.A11
FBD_D9: UV1.AA4 UV15.A13
FBD_D10: UV1.AC4 UV15.B11
FBD_D11: UV1.AC3 UV15.B13
FBD_D12: UV1.AD4 UV15.E11
FBD_D13: UV1.AD2 UV15.E13
FBD_D14: UV1.AD5 UV15.F11
FBD_D15: UV1.AD1 UV15.F13
FBD_D16: UV1.R4 UV15.U11
FBD_D17: UV1.U3 UV15.U13
FBD_D18: UV1.U4 UV15.T11
FBD_D19: UV1.U5 UV15.T13
FBD_D20: UV1.V6 UV15.N11
FBD_D21: UV1.V5 UV15.N13
FBD_D22: UV1.Y4 UV15.M11
FBD_D23: UV1.Y5 UV15.M13
FBD_D24: UV1.Y6 UV15.U4
FBD_D25: UV1.Y7 UV15.U2
FBD_D26: UV1.Y8 UV15.T4
FBD_D27: UV1.AC9 UV15.T2
FBD_D28: UV1.AC7 UV15.N4
FBD_D29: UV1.AC6 UV15.N2
FBD_D30: UV1.AC8 UV15.M4
FBD_D31: UV1.AC10 UV15.M2
FBD_D32: UV1.H2 UV16.U4
FBD_D33: UV1.H4 UV16.U2
FBD_D34: UV1.H1 UV16.T4
FBD_D35: UV1.H3 UV16.T2
FBD_D36: UV1.F5 UV16.N4
FBD_D37: UV1.E2 UV16.N2
FBD_D38: UV1.E4 UV16.M4
FBD_D39: UV1.D3 UV16.M2
FBD_D40: UV1.J4 UV16.U11
FBD_D41: UV1.L5 UV16.U13
FBD_D42: UV1.J2 UV16.T11
FBD_D43: UV1.J1 UV16.T13
FBD_D44: UV1.J6 UV16.N11
FBD_D45: UV1.H5 UV16.N13
FBD_D46: UV1.L9 UV16.M11
FBD_D47: UV1.L8 UV16.M13
FBD_D48: UV1.U10 UV16.A11
FBD_D49: UV1.U7 UV16.A13
FBD_D50: UV1.U9 UV16.B11
FBD_D51: UV1.R7 UV16.B13
FBD_D52: UV1.R10 UV16.E11
FBD_D53: UV1.P10 UV16.E13
FBD_D54: UV1.P8 UV16.F11
FBD_D55: UV1.P9 UV16.F13
FBD_D56: UV1.P5 UV16.A4
FBD_D57: UV1.P6 UV16.A2
FBD_D58: UV1.P2 UV16.B4
FBD_D59: UV1.P1 UV16.B2
FBD_D60: UV1.M5 UV16.E4
FBD_D61: UV1.M6 UV16.E2
FBD_D62: UV1.M7 UV16.F4
FBD_D63: UV1.P7 UV16.F2
FBD_DBI0#: UV1.AG10 UV15.D2
FBD_DBI1#: UV1.AA5 UV15.D13
FBD_DBI2#: UV1.U6 UV15.P13
FBD_DBI3#: UV1.AA8 UV15.P2
FBD_DBI4#: UV1.E3 UV16.P2
FBD_DBI5#: UV1.J5 UV16.P13
FBD_DBI6#: UV1.U8 UV16.D13
FBD_DBI7#: UV1.M4 UV16.D2
FBD_EDC0: UV1.AG5 UV15.C2
FBD_EDC1: UV1.AD7 UV15.C13
FBD_EDC2: UV1.V8 UV15.R13
FBD_EDC3: UV1.AA7 UV15.R2
FBD_EDC4: UV1.F4 UV16.R2
FBD_EDC5: UV1.L7 UV16.R13
FBD_EDC6: UV1.R8 UV16.C13
FBD_EDC7: UV1.P3 UV16.C2
FBD_MA0_MA10_H: UV1.F1 UV16.K4
FBD_MA0_MA10_L: UV1.AF2 UV15.H4
FBD_MA1_MA9_H: UV1.F2 UV16.K5
FBD_MA1_MA9_L: UV1.AF1 UV15.H5
FBD_MA2_BA0_H: UV1.R2 UV16.K11
FBD_MA2_BA0_L: UV1.Y3 UV15.H11
FBD_MA3_BA3_H: UV1.U2 UV16.K10
FBD_MA3_BA3_L: UV1.V3 UV15.H10
FBD_MA4_BA2_H: UV1.R1 UV16.H11
FBD_MA4_BA2_L: UV1.Y2 UV15.K11
FBD_MA5_BA1_H: UV1.R3 UV16.H10
FBD_MA5_BA1_L: UV1.Y1 UV15.K10
FBD_MA6_MA11_H: UV1.M3 UV16.H5
FBD_MA6_MA11_L: UV1.AA2 UV15.K5
FBD_MA7_MA8_H: UV1.M1 UV16.H4
FBD_MA7_MA8_L: UV1.AA1 UV15.K4
FBD_MA12_RFU_H: UV1.L2 UV16.J5
FBD_MA12_RFU_L: UV1.AC1 UV15.J5
FBD_RAS#_H: UV1.E1 UV16.L3
FBD_RAS#_L: UV1.AF3 UV15.G3
FBD_RST#_H: RV149.1 UV1.D2 UV16.J2
FBD_RST#_L: RV151.1 UV1.AG1 UV15.J2
FBD_WCK0: UV1.AF4 UV15.D4
FBD_WCK0_N: UV1.AF5 UV15.D5
FBD_WCK1: UV1.Y9 UV15.P4
FBD_WCK1_N: UV1.Y10 UV15.P5
FBD_WCK2: UV1.H6 UV16.P4
FBD_WCK2_N: UV1.H7 UV16.P5
FBD_WCK3: UV1.M8 UV16.D4
FBD_WCK3_N: UV1.M9 UV16.D5
FBD_WE#_H: UV1.M2 UV16.G12
FBD_WE#_L: UV1.AA3 UV15.L12
FBVDD_EN: DV4.1 PR313.1 RV125.1
FC_D3: CPU1.D3 RC53.2 RC55.1
FDI_CSYNC: CPU1.F11 UH1.AL39
FDI_INT: CPU1.F12 UH1.AL40
FDI_IREF: RH40.1 UH1.AT45
FDI_RCOMP: RH41.2 UH1.AR44
FFS_INT1: UH1.M15 UN2.11
FFS_INT2: QN3.3 RH1.1 UE6.21 UN2.9
FFS_INT2_CONN: DN1.2 JHDD1.18 RN24.2
FFS_INT2_EC: RH2.1 UE6.17
GATEA20: RH112.2 UH1.AN10
GC6_EVENT#: DV9.1 UH1.AD11
GC6_EVENT#_D: DV9.2 RV50.1 UV1.AV1
GPIO3_OC_WARN#: RV53.1 RV554.2 UV1.AW4
GPIO9_THERMAL_ALERT#: QV91.4 RV526.1 UV1.AW7
GPIO55: RH85.1 UH1.AL6
GPU_ALERT#: QV91.3 RE99.1 UE6.18
GPU_B+: PC600.1 PC601.1 PC602.1 PC603.1 PC604.1 PC605.1 PC606.1 PC607.1 PC608.1 PC609.1 PC634.1 PQ605.2 PQ606.2 PQ607.2 PQ608.2 PQ609.2 PQ611.2 PR604.1 PR650.2
GPU_B++: PJP600.2 PR604.4
GPU_DSBL/ISEN1: PR648.2 PU600.15
GPU_EN: PC618.1 PR614.2 PR615.1 PR621.1 PR641.2 PU600.3
GPU_FAN_FB: DF2.2 RF4.1 UE5.29
GPU_FAN_PWM: JFAN2.2 RF5.1 UE5.27
GPU_GC6_FB_EN: DV4.2 RV37.1 UH1.AB11 UV1.AT7
GPU_JTAG_TCK: T100.1(TP-1) UV1.BJ20
GPU_JTAG_TDI: T97.1(TP-1) UV1.BG20
GPU_JTAG_TDO: T98.1(TP-1) UV1.BH20
GPU_JTAG_TMS: T99.1(TP-1) UV1.BF20
GPU_JTAG_TRST#: RV69.1 UV1.BF21
GPU_OVERT#: QV91.6 RE102.1 UE6.23
GPU_PEX_RST_HOLD#: DV8.3 RV63.1 UV1.AV3
GPU_PGOOD: DV4.3 PR619.2 PR677.1 UV22.4
GPU_PGOOD1: PC627.1 PR619.1 PR639.2 PU600.16
GPU_PLLVDD: CV75.1 CV108.1 CV109.1 CV131.1 CV147.1 CV149.1 CV394.1 CV396.1 LV9.1 UV1.AC39 UV1.AD11 UV1.AT11 UV1.L21 UV1.Y39
GPU_PSI: PC614.1 PR607.1 PU600.4
GPU_REFADJ: PR613.2 PU600.6
GPU_REFIN: PC616.1 PR611.1 PR616.2 PR623.1 PU600.7
GPU_TALERT/ISEN2: PR646.2 PU600.14
GPU_TON: PR650.1 PU600.9
GPU_TSNS/ISEN3: PR638.2 PU600.13
GPU_VID: PR600.2 PR602.1 PR610.1 PU600.5
GPU_VREF: PC613.1 PR606.1 PU600.8
H_CATERR#: CPU1.G50 T1.1(TP-1)
H_CPU_RSVD: CPU1.F21 RC40.2
H_CPU_SVIDALRT#: CPU1.J53 RC48.2
H_CPU_TESTLO: CPU1.F20 RC38.2
H_CPUPWRGD: CC29.1 CPU1.F50 RC18.2 UH1.AV3
H_DRAMRST#: CC27.1 CPU1.BE51 R1.1
H_PECI: CPU1.G51 RE76.2
H_PECI_R: T81.1(TP-1) UH1.AY1
H_PM_SYNC: CPU1.D52 T78.1(TP-1) UH1.AY3
H_PROCHOT#: CE51.1 PQ8.1 PR724.1 R2.1 RC11.2 RE78.1 UE7.4
H_PROCHOT#_R: CPU1.E50 R2.2
H_THERMTRIP#: CPU1.D53 RH124.2
HDA_SPKR: CA68.1 RH5.2 UH1.AL10
HDD_A0_PRE0: RN10.2 RN22.1 UN1.9
HDD_A0_PRE1: RN14.2 RN21.1 UN1.19
HDD_B: JPWR1.16 QE13.3
HDD_B0_PRE0: RN11.2 RN19.1 UN1.8
HDD_B0_PRE1: RN13.2 RN20.1 UN1.17
HDD_B_7313#: QE13.4 UE3.21
HDD_DET#: JHDD1.12 RH123.1 UH1.U12
HDD_G: JPWR1.15 QE12.3
HDD_G_7313#: QE12.4 UE3.20
HDD_R: JPWR1.14 QE13.6
HDD_R_7313#: QE13.1 UE3.19
HDD_REXT_SATA0: RN9.2 RN23.1 UN1.20
HDMI_BUF: RV300.2 RV301.1 UV4.14
HDMI_CFG: RV302.2 UV4.23
HDMI_DCIN_EN: RV303.2 UV4.13
HDMI_EQ: RV298.2 RV299.1 UV4.17
HDMI_HPLUG: JHDMI1.19 RV41.2 RV545.1 UV4.28
HDMI_ISET: RV294.2 RV295.1 UV4.34
HDMI_PD#: RV545.2 RV546.1 UV4.36
HDMI_PRE: RV296.2 RV297.1 UV4.16
HP2_D_L1: CA89.1 UA1.33
HP2_D_L2: CA89.2 RA107.1 UA6.11
HP2_D_R1: CA90.1 UA1.31
HP2_D_R2: CA90.2 RA108.1 UA6.9
HP_MIC_LINE_IN_L: JIO.32 UA6.2
HP_MIC_LINE_IN_R: JIO.31 UA6.3
HPOUT-L: JIO.36 UA1.28
HPOUT-R: JIO.34 UA1.26
I2C_CLK: CE58.1 QE16.6 RE2.2 RM46.2 UE1.29 UE3.25
I2C_CLK_347: QE16.1 RE46.2 UE4.25 UE8.25
I2C_CTL_EN: RV305.1 RV306.2 UV4.8
I2C_DAT: QE16.3 RE1.2 RM45.2 UE1.30 UE3.26
I2C_DAT_347: QE16.4 RE47.2 UE4.26 UE8.26
I2CC_SCL: QV89.3 RV551.2 UV20.6
I2CC_SCL_R: QV89.4 RV548.2 UV1.BD2
I2CC_SDA: QV89.6 RV552.2 UV20.7
I2CC_SDA_R: QV89.1 RV547.2 UV1.BD1
ICLK_IREF: RH91.2 UH1.AM45
IMON: PC500.2 PR521.1 PU500.4
IMVP_PWRGD: PR519.1 PR522.1 UH2.2
IMVP_VR_ON: CE38.1 DE2.3 PR511.1 RE72.2 UE5.121
INTRUDER#: RH12.2 UH1.A8
ISEN1: PC539.2 PR553.2 PR555.1 PR557.1 PU500.12
ISEN2: PC540.2 PR538.2 PR546.1 PR547.1 PU500.11
ISEN3: PC544.2 PR510.1 PR516.2 PR518.2 PU500.10
IST_TRIGGER: CPU1.W49 T63.1(TP-1)
ISUMN: PC528.1 PC539.1 PC540.1 PC544.1 PC547.1 PH501.1 PR515.1 PR535.2 PR544.2 PR545.1 PR548.1 PR549.1 PR556.2
ISUMP: PC528.2 PC529.2 PC538.2 PR514.1 PR536.1 PR549.2 PR551.2 PR552.1 PR558.2 PU500.15
IVR_ERROR: CPU1.AM49 T62.1(TP-1)
JACK1_PLUG: JIO.1 QA3.2 QA14.2 RA93.1 RA138.2
JACK1_PLUG#: QA3.1 RA46.1
JACK1_PLUG_C: CA81.1 QA14.3 RA115.2 RA138.1 UA3.5
JACK2_PLUG#: JIO.33 RA47.1 RA49.1
JRTC1: PD5.2 PR2.1
KB_DET#: JKB1.30 RH131.1 RH133.1 UH1.D13
KB_LED_B1_DRV: Q30.2 Q30.3 R156.2
KB_LED_B1_DRV#: Q30.5 R158.2 UE4.5
KB_LED_B1_DRV#_A#: JKBBL1.5 Q30.6
KB_LED_B2_DRV: Q33.2 Q33.3 R168.2
KB_LED_B2_DRV#: Q33.5 R170.2 UE4.9
KB_LED_B2_DRV#_A#: JKBBL1.8 Q33.6
KB_LED_B3_DRV: Q36.2 Q36.3 R157.2
KB_LED_B3_DRV#: Q36.5 R159.2 UE4.14
KB_LED_B3_DRV#_A#: JKBBL1.11 Q36.6
KB_LED_B4_DRV: Q39.2 Q39.3 R169.2
KB_LED_B4_DRV#: Q39.5 R171.2 UE4.17
KB_LED_B4_DRV#_A#: JKBBL1.14 Q39.6
KB_LED_B5_DRV: Q2413.2 Q2413.3 R173.2
KB_LED_B5_DRV#: JKB3.2 UE8.17
KB_LED_G1_DRV: Q29.2 Q29.3 R150.2
KB_LED_G1_DRV#: Q29.5 R154.2 UE4.4
KB_LED_G1_DRV#_A#: JKBBL1.4 Q29.6
KB_LED_G2_DRV: Q32.2 Q32.3 R164.2
KB_LED_G2_DRV#: Q32.5 R166.2 UE4.8
KB_LED_G2_DRV#_A#: JKBBL1.7 Q32.6
KB_LED_G3_DRV: Q35.2 Q35.3 R151.2
KB_LED_G3_DRV#: Q35.5 R155.2 UE4.11
KB_LED_G3_DRV#_A#: JKBBL1.10 Q35.6
KB_LED_G4_DRV: Q38.2 Q38.3 R165.2
KB_LED_G4_DRV#: Q38.5 R167.2 UE4.16
KB_LED_G4_DRV#_A#: JKBBL1.13 Q38.6
KB_LED_G5_DRV: Q2412.2 Q2412.3 R153.2
KB_LED_G5_DRV#: JKB3.3 UE8.16
KB_LED_R1_DRV: Q28.2 Q28.3 R144.2
KB_LED_R1_DRV#: Q28.5 R146.2 UE4.3
KB_LED_R1_DRV#_A#: JKBBL1.3 Q28.6
KB_LED_R2_DRV: Q31.2 Q31.3 R160.2
KB_LED_R2_DRV#: Q31.5 R162.2 UE4.6
KB_LED_R2_DRV#_A#: JKBBL1.6 Q31.6
KB_LED_R3_DRV: Q34.2 Q34.3 R145.2
KB_LED_R3_DRV#: Q34.5 R147.2 UE4.10
KB_LED_R3_DRV#_A#: JKBBL1.9 Q34.6
KB_LED_R4_DRV: Q37.2 Q37.3 R161.2
KB_LED_R4_DRV#: Q37.5 R163.2 UE4.15
KB_LED_R4_DRV#_A#: JKBBL1.12 Q37.6
KB_LED_R5_DRV: Q2411.2 Q2411.3 R149.2
KB_LED_R5_DRV#: JKB3.4 UE8.15
KB_RST#: RH114.2 UE5.2 UH1.AT6
KP_DET#: JKB2.1 JKB2.2 UE5.123
KSI0: JKB1.17 JKB2.5 JKB2.6 UE5.55
KSI1: JKB1.27 JKB2.9 JKB2.10 UE5.56
KSI2: JKB1.20 JKB2.13 JKB2.14 UE5.57
KSI3: JKB1.18 JKB2.15 JKB2.16 UE5.58
KSI4: JKB1.21 JKB2.11 JKB2.12 UE5.59
KSI5: JKB1.23 JKB2.7 JKB2.8 UE5.60
KSI6: JKB1.24 UE5.61
KSI7: JKB1.26 UE5.62
KSO0: JKB1.28 UE5.39
KSO1: JKB1.19 UE5.40
KSO2: JKB1.14 UE5.41
KSO3: JKB1.22 UE5.42
KSO4: JKB1.13 UE5.43
KSO5: JKB1.15 UE5.44
KSO6: JKB1.11 UE5.45
KSO7: JKB1.29 UE5.46
KSO8: JKB1.12 UE5.47
KSO9: JKB1.25 UE5.48
KSO10: JKB1.9 UE5.49
KSO11: JKB1.10 UE5.50
KSO12: JKB1.8 UE5.51
KSO13: JKB1.16 UE5.52
KSO14: JKB1.7 UE5.53
KSO15: JKB1.6 UE5.54
KSO16: JKB1.5 JKB2.3 JKB2.4 UE5.81
KSO17: JKB1.4 UE5.82
LAN_ACTIVITY#: CL27.1 JLAN.10 UL1.38
LAN_LED2#: CL29.1 JLAN.13 RL15.1
LAN_LED2#_R: RL15.2 UL1.23
LAN_LINK#: CL28.1 JLAN.11 RL13.1
LAN_LINK#_R: QL3.2 RL4.2 UL1.39
LAN_MDIN0: TL1.11 UL1.12
LAN_MDIN1: TL1.8 UL1.15
LAN_MDIN2: TL1.5 UL1.18
LAN_MDIN3: TL1.2 UL1.21
LAN_MDIP0: TL1.12 UL1.11
LAN_MDIP1: TL1.9 UL1.14
LAN_MDIP2: TL1.6 UL1.17
LAN_MDIP3: TL1.3 UL1.20
LANCLK_REQ#: RH77.2 UH1.AF3 UL1.4
LCD_TEST: JEDP1.33 UE5.72
LED_B_7313#_A#: JPWR1.13 UE3.14
LED_G_7313#_A#: JPWR1.12 UE3.11
LED_R_7313#_A#: JPWR1.11 UE3.10
LG_3V: PQ101.4 PU100.11
LG_5V: PQ103.4 PU100.15
LG_+1.05VSP: PQ301.4 PU300.6
LG_+1.35VS_VGAP: PQ302.4 PU301.6
LGATE1: PQ501.6 PQ502.6 PU500.21
LGATE2: PQ503.6 PQ504.6 PU500.24
LGATE3: PQ505.6 PQ506.6 PU501.5
LID_SW: JLOGO1.3 QE10.1 QE14.2 RE38.2
LID_SW_IN#: CE43.1 CH100.1 DE1.1 QE10.2 RE70.2 RH102.2 UE5.115 UH5.3
LID_SW_IN#_D: DE1.2 RE8.2 UE1.23
LOGO_LED_B_DRV#: JLOGO1.6 UE3.9
LOGO_LED_G_DRV#: JLOGO1.5 UE3.8
LOGO_LED_R_DRV#: JLOGO1.4 UE3.6
LPBK: RM74.2 RM78.2 UM8.23
LPC_AD0: UE5.10 UH1.A20
LPC_AD1: UE5.8 UH1.C20
LPC_AD2: UE5.7 UH1.A18
LPC_AD3: UE5.5 UH1.C18
LPC_FRAME#: UE5.4 UH1.B21
LTRON_LED_B_DRV#: JTRONF.8 UE8.9
LTRON_LED_G_DRV#: JTRONF.7 UE8.8
LTRON_LED_R_DRV#: JTRONF.6 UE8.6
LX_3V: PC105.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ101.5 PR110.1 PU100.8
LX_5V: PC106.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ103.5 PR111.1 PU100.18
LX_+1.05V_GPUP: PL605.1 PR674.1 PU602.1 PU602.2 PU602.3
LX_CHG: PC702.1 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PR713.1 PU700.27
M_CLK_DDR0: CPU1.BF25 JDIMM1.101
M_CLK_DDR1: CPU1.BC25 JDIMM1.102
M_CLK_DDR2: CPU1.AV27 JDIMM2.101
M_CLK_DDR3: CPU1.AV26 JDIMM2.102
M_CLK_DDR#0: CPU1.BE25 JDIMM1.103
M_CLK_DDR#1: CPU1.BD25 JDIMM1.104
M_CLK_DDR#2: CPU1.AW27 JDIMM2.103
M_CLK_DDR#3: CPU1.AW26 JDIMM2.104
M_ODT0: CPU1.BC16 JDIMM1.116
M_ODT1: CPU1.BF16 JDIMM1.120
M_ODT2: CPU1.AY20 JDIMM2.116
M_ODT3: CPU1.BA19 JDIMM2.120
M_THERMAL#: JDIMM1.198 JDIMM2.198 RE77.2 UE5.70
MDP_LANE_N0_C: CV27.2 JDP1.5
MDP_LANE_N1_C: CV30.2 JDP1.11
MDP_LANE_N2_C: CV33.2 JDP1.17
MDP_LANE_N3_C: CV31.2 JDP1.12
MDP_LANE_P0_C: CV26.2 JDP1.3
MDP_LANE_P1_C: CV28.2 JDP1.9
MDP_LANE_P2_C: CV32.2 JDP1.15
MDP_LANE_P3_C: CV29.2 JDP1.10
ME_EN: RE81.1 RH16.1 UE5.99
ME_SUS_PWR_ACK: RH31.2 RH55.1 UE5.34
ME_SUS_PWR_ACK_R: RH34.1 RH55.2 UH1.J4
MEM_SMBCLK: QH4.6 RH95.2 RH97.2 UH1.R10
MEM_SMBDATA: QH4.3 RH96.2 RH99.2 UH1.U11
MEM_VREF: QV21.2 QV23.2 QV24.2 QV25.2 RV38.2 UV1.AT6
MIC1: CA13.2 RA126.2 UA3.11
MIC1_C_L: CA13.1 UA1.45 UA1.46
MIC_BIAS_B: CA15.2 QA11.3 QA13.3 UA1.42
MIC_BIAS_C: CA24.2 QA12.3 UA1.41
MIC_C_PLUG: RA48.1 UA3.8
MIC_CLK: JEDP1.30 LA2.2 RV13.1
MIC_CLK_C: LA2.1 UA1.55
MIC_DATA: JEDP1.32 UA1.51
MIC_IN: JIO.38 QA7.3 UA3.6 UA3.15
MIC_LINE_IN_L: CA76.1 UA1.44
MIC_LINE_IN_L2: CA76.2 RA102.2 RA106.1 UA6.12
MIC_LINE_IN_R: CA77.1 UA1.43
MIC_LINE_IN_R2: CA77.2 RA100.2 RA105.1 UA6.10
MPIO_2: RA101.4 UA1.56 UA6.1
MPIO_4_PB#_PD: RA101.3 UA1.50 UA6.4
MS_INS#: JCR.8 UR1.31
NC: H1.1(TP-1) H3.1(TP-1) JLAN.16 JLAN.17
NTC: PR525.2 PU500.6
NUMLOCK LED_A#: JPWR1.30 UE5.36
NVVDD PSI: PR607.2 RV35.1 UV1.AT1
NVVDD PWM_VID: PR610.2 UV1.AT9
ON/OFFBTN#: CE27.1 JPWR1.27 RE63.1 SW1.3 SW1.4 SW2.3 SW2.4 UE5.114
OVERT#: QV91.1 RV527.1 RV553.2 UV1.AV7
P1: PC701.1 PQ700.3 PQ701.1 PQ701.2 PQ701.3 PQ702.1 PQ702.2 PQ702.3 PQ707.1 PQ707.2 PQ707.3 PR701.2 PR706.1
P1_SW: PL503.3 PR552.2 PR553.1
P2: PQ702.5 PR702.1
P2_SW: PL502.3 PR536.2 PR538.1
P3_SW: PL501.3 PR510.2 PR514.2
PANEL_BKLEN: UE5.76 UH1.K36
PBTN_OUT#: RH56.1 UE5.106
PC_BEEP: CA65.2 CA66.2 CA72.2 RA80.1 RA81.2 RA84.2
PC_BEEP_1: CA65.1 UA1.53
PC_BEEP_L: CA66.1 RA140.1
PC_BEEP_R: CA72.1 RA139.1
PCH_AZ_BITCLK: RH29.2 UH1.B25
PCH_AZ_CODEC_BITCLK: CH5.1 RA96.1 RH29.1 UA1.5
PCH_AZ_CODEC_RST#: RP2.4 UA1.2
PCH_AZ_CODEC_SDIN0: RA40.1 UH1.L22
PCH_AZ_CODEC_SDIN0_R: RA40.2 UA1.7
PCH_AZ_CODEC_SDOUT: RP2.2 UA1.4
PCH_AZ_CODEC_SYNC: RP2.3 UA1.3
PCH_AZ_RST#: RP2.5 UH1.C24
PCH_AZ_SDOUT: RH6.2 RH16.2 RP2.7 UH1.A24
PCH_AZ_SYNC: QH1.1 UH1.A22
PCH_AZ_SYNC_Q: QH1.3 RH20.2 RP2.6
PCH_BATLOW#: RH58.2 UH1.K7
PCH_CLK_BIASREF: RH92.1 UH1.AN44
PCH_DP_AUXN_C: CV25.1 UV3.5
PCH_DP_AUXP_C: CV24.1 UV3.2
PCH_DPB_HDMI_CLK: UH1.R40 UV4.38
PCH_DPB_HDMI_DAT: UH1.R39 UV4.39
PCH_DPC_AUX: CV24.2 UH1.K45
PCH_DPC_AUX#: CV25.2 UH1.K43
PCH_DPC_CLK: RV528.2 UH1.R35 UV3.3
PCH_DPC_DAT: RV529.2 UH1.R36 UV3.6
PCH_DPWROK: RH45.2 UE5.127
PCH_DRWROK_R: RH45.1 RH46.1 UH1.L13
PCH_ENVDD: RH54.2 RV3.1 UH1.G36
PCH_GPIO0: RH113.2 UH1.AT8
PCH_GPIO1: RH115.2 UH1.F13
PCH_GPIO13: RH60.2 UH1.C22
PCH_GPIO16: JSSD3.61 RH130.2 RH132.1 UH1.AN2
PCH_GPIO19: RH8.2 UH1.AU2
PCH_GPIO21: RH7.1 UH1.AT1
PCH_GPIO22: RH118.2 UH1.BB4
PCH_GPIO33: RH14.2 UH1.B17
PCH_GPIO35: RH126.1 UH1.AP1
PCH_GPIO36: RH136.1 RH138.1 UH1.AT3
PCH_GPIO37: RH137.2 RH139.1 UH1.AK1
PCH_GPIO39: RH119.2 UH1.AM3
PCH_GPIO49: JSSD2.61 RH157.2 RH158.1 UH1.AK3
PCH_GPIO65: RPH3.2 UH1.F38
PCH_GPIO66: RPH3.3 UH1.F36
PCH_GPIO70: RH120.2 UH1.G13
PCH_GPIO71: RH121.2 UH1.H15
PCH_GPIO74: RH101.2 UH1.H6
PCH_HDMI_HPD: RV42.2 UH1.K40 UV4.3
PCH_INTVRMEN: RH3.2 RH4.1 UH1.G10
PCH_INV_PWM: JEDP1.36 RC33.2 RV8.1 UH1.N36
PCH_JTAG_TCK: RH18.1 UH1.AB3
PCH_JTAG_TDI: RH21.2 RH26.1 UH1.AE2
PCH_JTAG_TDO: RH23.2 RH27.1 UH1.AD3
PCH_JTAG_TMS: RH19.2 RH25.1 UH1.AD1
PCH_LID_SW_IN#: RH102.1 RH127.1 UH1.N7
PCH_MDP_HPD: JDP1.2 RH57.2 UH1.K38
PCH_PCIE_IREF: RH110.1 UH1.BE30
PCH_PCIE_RCOMP: RH111.2 UH1.BD29
PCH_PLTRST#: UH1.Y11 UH3.1 UH3.2 UM3.2 UV14.2
PCH_PWR_EN: RE62.2 RE74.1
PCH_PWROK: CE44.1 RE75.1 RH49.1 RH50.1 UE5.32 UH2.1
PCH_PWROK_R: RH49.2 UH1.F10
PCH_RI#: RH37.2 UH1.N4
PCH_RSMRST#: RH38.2 RH53.1 UE5.100
PCH_RSMRST#_R: RH46.2 RH53.2 UH1.J2
PCH_RTCRST#: CH4.2 CMOS1.2 RH13.2 UH1.D9
PCH_RTCX1: RH9.1 RH11.1 UH1.B5
PCH_RTCX1_R: CH1.2 RH9.2 YH1.1
PCH_RTCX2: CH2.2 RH11.2 UH1.B4 YH1.2
PCH_SATALED#: QE12.2 RH10.1 UH1.AP3
PCH_SMBCLK: JDIMM1.202 JDIMM2.202 JPWR1.24 QH4.1 RH93.2 RH95.1 UN2.4
PCH_SMBDATA: JDIMM1.200 JDIMM2.200 JPWR1.25 QH4.4 RH94.2 RH96.1 UN2.6
PCH_SPI_CLK: RH104.2 RT14.1 UH1.AJ11
PCH_SPI_CLK_R: RH104.1 RH108.2 UH4.6
PCH_SPI_CLK_T: RT14.2 RT16.2 UT2.21
PCH_SPI_CS0#: RH107.1 UH1.AJ7 UH4.1
PCH_SPI_CS1#: RT15.1 UH1.AL7
PCH_SPI_CS1#_T: RT15.2 UT2.22
PCH_SPI_DO2: RPH5.5 UH1.AJ4
PCH_SPI_DO3: RPH5.6 UH1.AJ2
PCH_SPI_S0_R: RPH5.1 UH4.2
PCH_SPI_SI: RPH5.7 RT12.1 UH1.AH1
PCH_SPI_SI_R: RPH5.2 UH4.5
PCH_SPI_SI_T: RT12.2 UT2.26
PCH_SPI_SO: RPH5.8 RT13.1 UH1.AH3
PCH_SPI_SO_T: RT13.2 UT2.23
PCH_TD_IREF: RH103.1 UH1.AY43
PCH_THRMTRIP#_R_R: RH124.1 UH1.AV1
PCH_TP25: RH24.1 UH1.F8
PCI_PIRQA#: RH62.2 UH1.H20
PCI_PIRQB#: RH63.2 UH1.L20
PCI_PIRQC#: RH64.2 UH1.K17
PCI_PIRQD#: RH66.2 UH1.M20
PCIE_GEN3#_GEN2: UE1.18 UE6.11
PCIE_PRX_C_DTX_N1: CR11.2 UR1.8
PCIE_PRX_C_DTX_P1: CR10.2 UR1.7
PCIE_PRX_CARDTX_N5: CR11.1 UH1.AW36
PCIE_PRX_CARDTX_P5: CR10.1 UH1.AV36
PCIE_PRX_GLANTX_N3: CL2.2 UH1.AW33
PCIE_PRX_GLANTX_P3: CL1.2 UH1.AY33
PCIE_PRX_LANTX_N3_C: CL2.1 UL1.29
PCIE_PRX_LANTX_P3_C: CL1.1 UL1.30
PCIE_PRX_WLANTX_N4: JWLAN1.35 UH1.AT33
PCIE_PRX_WLANTX_P4: JWLAN1.33 UH1.AR33
PCIE_PTX_CARDRX_N5: CH16.1 UR1.4
PCIE_PTX_CARDRX_N5_C: CH16.2 UH1.BD37
PCIE_PTX_CARDRX_P5: CH17.1 UR1.3
PCIE_PTX_CARDRX_P5_C: CH17.2 UH1.BB37
PCIE_PTX_GLANRX_N3: CH12.1 UL1.36
PCIE_PTX_GLANRX_N3_C: CH12.2 UH1.BE34
PCIE_PTX_GLANRX_P3: CH13.1 UL1.35
PCIE_PTX_GLANRX_P3_C: CH13.2 UH1.BC34
PCIE_PTX_WLANRX_N4: CH14.1 JWLAN1.29
PCIE_PTX_WLANRX_N4_C: CH14.2 UH1.BE36
PCIE_PTX_WLANRX_P4: CH15.1 JWLAN1.27
PCIE_PTX_WLANRX_P4_C: CH15.2 UH1.BC36
PCIE_WAKE#: RH35.2 RH48.2 RL1.2 UE5.64 UL1.3
PECI_KB9012: RE76.1 UE5.118
PEG_COMP: CPU1.AH6 RC1.2
PEG_GTX_HRX_C_N8: CM66.2 UM8.4
PEG_GTX_HRX_C_N9: CM65.2 UM8.8
PEG_GTX_HRX_C_N10: CM62.2 UM8.6
PEG_GTX_HRX_C_N11: CM69.2 UM8.2
PEG_GTX_HRX_C_P8: CM63.2 UM8.3
PEG_GTX_HRX_C_P9: CM64.2 UM8.7
PEG_GTX_HRX_C_P10: CM68.2 UM8.5
PEG_GTX_HRX_C_P11: CM67.2 UM8.1
PEG_GTX_HRX_N0: CPU1.E10 CV62.1
PEG_GTX_HRX_N0_C: CV62.2 UV1.BD21
PEG_GTX_HRX_N1: CPU1.C10 CV60.1
PEG_GTX_HRX_N1_C: CV60.2 UV1.BE23
PEG_GTX_HRX_N2: CPU1.B10 CV63.1
PEG_GTX_HRX_N2_C: CV63.2 UV1.BC23
PEG_GTX_HRX_N3: CPU1.E9 CV61.1
PEG_GTX_HRX_N3_C: CV61.2 UV1.BD24
PEG_GTX_HRX_N4: CPU1.D9 CV71.1
PEG_GTX_HRX_N4_C: CV71.2 UV1.BE25
PEG_GTX_HRX_N5: CPU1.B9 CV68.1
PEG_GTX_HRX_N5_C: CV68.2 UV1.BC26
PEG_GTX_HRX_N6: CPU1.L5 CV70.1
PEG_GTX_HRX_N6_C: CV70.2 UV1.BD27
PEG_GTX_HRX_N7: CPU1.L2 CV66.1
PEG_GTX_HRX_N7_C: CV66.2 UV1.BE29
PEG_GTX_HRX_N8: CM66.1 CPU1.M4
PEG_GTX_HRX_N9: CM65.1 CPU1.L4
PEG_GTX_HRX_N10: CM62.1 CPU1.M2
PEG_GTX_HRX_N11: CM69.1 CPU1.V5
PEG_GTX_HRX_P0: CPU1.F10 CV57.1
PEG_GTX_HRX_P0_C: CV57.2 UV1.BC21
PEG_GTX_HRX_P1: CPU1.D10 CV59.1
PEG_GTX_HRX_P1_C: CV59.2 UV1.BE22
PEG_GTX_HRX_P2: CPU1.A10 CV58.1
PEG_GTX_HRX_P2_C: CV58.2 UV1.BD23
PEG_GTX_HRX_P3: CPU1.F9 CV64.1
PEG_GTX_HRX_P3_C: CV64.2 UV1.BC24
PEG_GTX_HRX_P4: CPU1.C9 CV67.1
PEG_GTX_HRX_P4_C: CV67.2 UV1.BE26
PEG_GTX_HRX_P5: CPU1.A9 CV69.1
PEG_GTX_HRX_P5_C: CV69.2 UV1.BD26
PEG_GTX_HRX_P6: CPU1.M5 CV65.1
PEG_GTX_HRX_P6_C: CV65.2 UV1.BC27
PEG_GTX_HRX_P7: CPU1.L1 CV72.1
PEG_GTX_HRX_P7_C: CV72.2 UV1.BE28
PEG_GTX_HRX_P8: CM63.1 CPU1.M3
PEG_GTX_HRX_P9: CM64.1 CPU1.L3
PEG_GTX_HRX_P10: CM68.1 CPU1.M1
PEG_GTX_HRX_P11: CM67.1 CPU1.Y5
PEG_HTX_C_GRX_N0: CC1.2 UV1.BG21
PEG_HTX_C_GRX_N1: CC2.2 UV1.BH23
PEG_HTX_C_GRX_N2: CC3.2 UV1.BJ24
PEG_HTX_C_GRX_N3: CC4.2 UV1.BG24
PEG_HTX_C_GRX_N4: CC5.2 UV1.BH26
PEG_HTX_C_GRX_N5: CC6.2 UV1.BJ27
PEG_HTX_C_GRX_N6: CC7.2 UV1.BG27
PEG_HTX_C_GRX_N7: CC8.2 UV1.BH29
PEG_HTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_HTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_HTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_HTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_HTX_C_GRX_P0: CC13.2 UV1.BH21
PEG_HTX_C_GRX_P1: CC14.2 UV1.BG23
PEG_HTX_C_GRX_P2: CC15.2 UV1.BJ23
PEG_HTX_C_GRX_P3: CC16.2 UV1.BH24
PEG_HTX_C_GRX_P4: CC17.2 UV1.BG26
PEG_HTX_C_GRX_P5: CC18.2 UV1.BJ26
PEG_HTX_C_GRX_P6: CC19.2 UV1.BH27
PEG_HTX_C_GRX_P7: CC20.2 UV1.BG29
PEG_HTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_HTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_HTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_HTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_HTX_GRX_N0: CC1.1 CPU1.B6
PEG_HTX_GRX_N1: CC2.1 CPU1.C5
PEG_HTX_GRX_N2: CC3.1 CPU1.E6
PEG_HTX_GRX_N3: CC4.1 CPU1.D4
PEG_HTX_GRX_N4: CC5.1 CPU1.G4
PEG_HTX_GRX_N5: CC6.1 CPU1.E3
PEG_HTX_GRX_N6: CC7.1 CPU1.J5
PEG_HTX_GRX_N7: CC8.1 CPU1.G3
PEG_HTX_GRX_N8: CC9.1 CPU1.J3
PEG_HTX_GRX_N9: CC10.1 CPU1.J2
PEG_HTX_GRX_N10: CC11.1 CPU1.T6
PEG_HTX_GRX_N11: CC12.1 CPU1.R6
PEG_HTX_GRX_P0: CC13.1 CPU1.C6
PEG_HTX_GRX_P1: CC14.1 CPU1.B5
PEG_HTX_GRX_P2: CC15.1 CPU1.D6
PEG_HTX_GRX_P3: CC16.1 CPU1.E4
PEG_HTX_GRX_P4: CC17.1 CPU1.G5
PEG_HTX_GRX_P5: CC18.1 CPU1.E2
PEG_HTX_GRX_P6: CC19.1 CPU1.J6
PEG_HTX_GRX_P7: CC20.1 CPU1.G2
PEG_HTX_GRX_P8: CC21.1 CPU1.J4
PEG_HTX_GRX_P9: CC22.1 CPU1.J1
PEG_HTX_GRX_P10: CC23.1 CPU1.T5
PEG_HTX_GRX_P11: CC24.1 CPU1.R5
PEX_TERMP: RV57.2 UV1.BJ38
PEX_TSTCLK_OUT: RV54.2 UV1.BH38
PEX_TSTCLK_OUT#: RV54.1 UV1.BG38
PHASE1: PC542.2 PC543.1 PL503.4 PQ501.7 PQ502.7 PU500.20
PHASE2: PC522.2 PC524.1 PL502.4 PQ503.7 PQ504.7 PU500.25
PHASE3: PC501.2 PC508.1 PL501.4 PQ505.7 PQ506.7 PU501.8
PLIMIT: CA99.1 RA112.1 RA113.2 UA4.1
PLT_RST#: CE34.1 RH43.2 RH51.1 RM33.2 UE5.13 UH3.4 UL1.2 UR1.1 UT2.16
PLT_RST#_R: JWLAN1.44 RM33.1
PM_APWROK_R: RH50.2 UH1.AB7
PM_CLKRUN#: RH33.2 RH67.2 UH1.AN7
PM_DRAM_PWRGD: RC31.1 RH52.1
PM_DRAM_PWRGD_R: RH52.2 UH1.H3
PM_SLP_S3#: CE41.1 QE1.2 T76.1(TP-1) UE5.6 UH1.H1
PM_SLP_S4#: T75.1(TP-1) UE5.84 UH1.C6
PM_SLP_S5#: CE45.1 QE3.2 T74.1(TP-1) UE5.14 UH1.Y7
PM_SLP_SUS#: T77.1(TP-1) UE5.38 UH1.F1
PM_SYS_PWRGD_BUF: CPU1.AP48 RC26.2 RC30.1 RC31.2 UC1.4
POK: PR14.1 PR17.1 PU100.7
POWER_LED: QE8.2 QE9.1 RE28.2
PS_ID: PR3.1 PR4.2 UE5.16
PSID: PJPDC1.10 PL2.2
PSID-1: PQ2.2 PR6.1 PR9.2
PSID-2: PQ2.1 PQ7.2 PR8.2
PSID-3: PQ7.3 PR4.1
PWM3: PR523.2 PU500.22 PU501.3
PWR_B_7313#: JPWR1.19 UE3.17
PWR_G_7313#: JPWR1.18 UE3.16
PWR_LED#: QE9.2 UE5.92
PWR_R_7313#: JPWR1.17 UE3.15
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWRSHARE_EN_EC#: JIO.4 UE5.119
RATE: RM69.2 RM71.2 UM8.21
REGN_CHG: PC710.1 PR714.1 PU700.24
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 U2407.3
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 U2407.5
RF_+1.05VSP: PR306.1 PU300.5
RF_+1.35VS_VGAP: PR311.1 PU301.5
RING2: JIO.37 UA3.7 UA3.14
RJ45_CT: CL30.2 RL9.2 RL10.2 RL11.2 RL12.2
RJ45_CT0: RL12.1 TL1.15
RJ45_CT1: RL11.1 TL1.18
RJ45_CT2: RL10.1 TL1.21
RJ45_CT3: RL9.1 TL1.24
RJ45_MDI0+: JLAN.1 TL1.13
RJ45_MDI0-: JLAN.2 TL1.14
RJ45_MDI1+: JLAN.3 TL1.16
RJ45_MDI1-: JLAN.6 TL1.17
RJ45_MDI2+: JLAN.4 TL1.19
RJ45_MDI2-: JLAN.5 TL1.20
RJ45_MDI3+: JLAN.7 TL1.22
RJ45_MDI3-: JLAN.8 TL1.23
ROM_CS: RV167.2 UV1.BA3 UV10.1
ROM_SCLK: RV169.2 RV226.2 RV233.1 UV1.BA2
ROM_SCLK_R: RV169.1 UV10.6
ROM_SI: RV170.2 RV215.2 RV229.1 UV1.BA5
ROM_SI_R: RV170.1 UV10.5
ROM_SO: RV168.1 RV223.2 RV231.1 UV1.BA4
ROM_SO_R: RV168.2 UV10.2
RREF: RR2.2 UR1.9
RST#: CE55.2 RE91.2 UE6.3
RTRON_LED_B_DRV#: JTRONF.5 UE8.14
RTRON_LED_G_DRV#: JTRONF.4 UE8.11
RTRON_LED_R_DRV#: JTRONF.3 UE8.10
RXDET: RM73.1 RM77.1 UM8.22
SATA_COMP: RH28.1 UH1.AY5
SATA_IREF: RH22.2 UH1.BD4
SATA_LED_ACT: QE12.5 QE12.6 QE13.2 QE13.5 QE14.1 RE39.2
SATA_PRX_DTX_N0: CN12.1 UH1.BC8
SATA_PRX_DTX_N0_C: CN12.2 UN1.4
SATA_PRX_DTX_N0_R: CN16.2 JHDD1.5
SATA_PRX_DTX_N0_RC: CN16.1 UN1.12
SATA_PRX_DTX_N1: CN29.1 UH1.BC10
SATA_PRX_DTX_N1_C: CN29.2 JSSD1.35
SATA_PRX_DTX_N3: CN45.1 UH1.BC12
SATA_PRX_DTX_N3_C: CN45.2 JSSD4.35
SATA_PRX_DTX_N4: CN46.1 UH1.BD13
SATA_PRX_DTX_N4_C: CN46.2 JSSD3.35
SATA_PRX_DTX_N5: CN30.1 UH1.BC14
SATA_PRX_DTX_N5_C: CN30.2 JSSD2.35
SATA_PRX_DTX_P0: CN11.1 UH1.BE8
SATA_PRX_DTX_P0_C: CN11.2 UN1.5
SATA_PRX_DTX_P0_R: CN15.2 JHDD1.6
SATA_PRX_DTX_P0_RC: CN15.1 UN1.11
SATA_PRX_DTX_P1: CN27.1 UH1.BE10
SATA_PRX_DTX_P1_C: CN27.2 JSSD1.33
SATA_PRX_DTX_P3: CN43.1 UH1.BE12
SATA_PRX_DTX_P3_C: CN43.2 JSSD4.33
SATA_PRX_DTX_P4: CN44.1 UH1.BB13
SATA_PRX_DTX_P4_C: CN44.2 JSSD3.33
SATA_PRX_DTX_P5: CN28.1 UH1.BE14
SATA_PRX_DTX_P5_C: CN28.2 JSSD2.33
SATA_PTX_DRX_N0: CN10.1 UH1.AW8
SATA_PTX_DRX_N0_C: CN10.2 UN1.2
SATA_PTX_DRX_N0_R: CN14.2 JHDD1.3
SATA_PTX_DRX_N0_RC: CN14.1 UN1.14
SATA_PTX_DRX_N1: CN31.1 UH1.AV10
SATA_PTX_DRX_N1_C: CN31.2 JSSD1.39
SATA_PTX_DRX_N3: CN47.1 UH1.AR13
SATA_PTX_DRX_N3_C: CN47.2 JSSD4.39
SATA_PTX_DRX_N4: CN48.1 UH1.AV15
SATA_PTX_DRX_N4_C: CN48.2 JSSD3.39
SATA_PTX_DRX_N5: CN32.1 UH1.AP15
SATA_PTX_DRX_N5_C: CN32.2 JSSD2.39
SATA_PTX_DRX_P0: CN9.1 UH1.AY8
SATA_PTX_DRX_P0_C: CN9.2 UN1.1
SATA_PTX_DRX_P0_R: CN13.2 JHDD1.2
SATA_PTX_DRX_P0_RC: CN13.1 UN1.15
SATA_PTX_DRX_P1: CN33.1 UH1.AW10
SATA_PTX_DRX_P1_C: CN33.2 JSSD1.41
SATA_PTX_DRX_P3: CN49.1 UH1.AT13
SATA_PTX_DRX_P3_C: CN49.2 JSSD4.41
SATA_PTX_DRX_P4: CN50.1 UH1.AW15
SATA_PTX_DRX_P4_C: CN50.2 JSSD3.41
SATA_PTX_DRX_P5: CN34.1 UH1.AR15
SATA_PTX_DRX_P5_C: CN34.2 JSSD2.41
SCLK: PR504.1 PR508.2 PU500.1
SD_CD#: JCR.20 UR1.30
SD_CLK MS_D0: RR1.2 UR1.17
SD_CLK MS_D0_R: JCR.12 JCR.14 RR1.1 RR9.2
SD_CMD MS_D2: RR5.1 UR1.19
SD_CMD MS_D2_R: JCR.6 JCR.10 RR5.2
SD_D0 MS_D1: RR8.1 UR1.16
SD_D0 MS_D1_R: JCR.13 JCR.18 RR8.2
SD_D1: RR7.1 UR1.15
SD_D1_R: JCR.19 RR7.2
SD_D2 MS_CLK: RR3.2 UR1.21
SD_D2 MS_CLK_R: JCR.1 JCR.5 RR3.1 RR10.2
SD_D3 MS_D3: RR6.1 UR1.20
SD_D3 MS_D3_R: JCR.3 JCR.7 RR6.2
SD_WP MS_BS: JCR.15 JCR.22 UR1.29
SDA: PR500.1 PR505.2 PU500.31
SENSE A#: RA46.2 RA47.2 RA48.2 RA49.2 UA1.47
SENSOR_DIODE_N1: CF2.2 CF3.2 QF2.3 U2410.3
SENSOR_DIODE_P1: CF2.1 CF3.1 QF2.1 QF2.2 U2410.2
SERIRQ: RH98.2 UE5.3 UH1.AL11
SIO_PWRBTN#_R: RH56.2 UH1.K1
SLP_S3: QE1.1 RE15.2 UE1.26
SLP_S5: QE3.1 RE16.2 UE1.21
SM_RCOMP0: CPU1.BB51 RC21.1
SM_RCOMP1: CPU1.BB53 RC22.1
SM_RCOMP2: CPU1.BB52 RC23.1
SML0CLK: RM36.1 RPH4.4 UH1.U8
SML0DATA: RM37.1 RPH4.3 UH1.R7
SML1CLK: QH3.6 RPH4.2 UH1.K6
SML1DATA: QH3.3 RPH4.1 UH1.N11
SNB_CPU_P1: PC543.2 PR554.1
SNB_CPU_P2: PC524.2 PR541.1
SNB_CPU_P3: PC508.2 PR513.1
SNUB_+1.05V_GPUP: PC662.1 PR674.2
SNUB_CHG: PC715.1 PR713.2
SPI_MOCLK: RE3.1 UE1.2
SPI_MOCLK_R: CE57.1 RE3.2 RE11.2
SPI_MOCS#: RE12.2 UE1.31 UE2.1
SPI_MOSI: RE9.2 UE1.32
SPI_MOSO: RE10.2 UE1.1
SPI_PCH_DO2_R: RH106.2 RPH5.4 UH4.3
SPI_PCH_DO3_R: RH105.2 RPH5.3 UH4.7
SPK_L1-_CONN: CA33.1 JSPK.3 LA5.2
SPK_L2+_CONN: CA29.1 JSPK.4 LA6.2
SPK_MUTE: QA2.1 RA43.1 UA4.7
SPK_MUTE#: DA15.1 DE3.1 JIO.29 RA41.1 RA137.2 UA4.29 UA4.30
SPK_MUTE#_R: CA113.1 DE3.2 QA2.2 RA137.1
SPK_R1-_CONN: CA32.1 JSPK.1 LA3.2
SPK_R2+_CONN: CA31.1 JSPK.2 LA4.2
SPKL+: CA83.1 CA107.2 LA6.1 UA4.16
SPKL-: CA84.1 CA108.2 LA5.1 UA4.18
SPKR+: CA85.1 CA109.2 LA4.1 UA4.25
SPKR-: CA86.1 CA110.2 LA3.1 UA4.23
SRTCRST#: CH3.2 RH15.2 UH1.B9
SSID_GPIO34: RH117.1 RH161.1 UH1.AN6
SSID_GPIO52: RH68.1 RH69.1 UH1.B13
STRAP0: RV228.2 RV230.1 UV1.BA6
STRAP1: RV216.2 RV218.1 UV1.AW8
STRAP2: RV217.1 RV232.2 UV1.BA7
STRAP3: RV214.1 RV221.2 UV1.BA8
STRAP4: RV219.1 RV224.2 UV1.BB6
SUS_STAT#: RH30.2 T73.1(TP-1) UH1.U7
SUSACK#: R178.1 UE5.97
SUSACK#_R: R178.2 RH34.2 UH1.R6
SUSCLK: RM32.2 UH1.Y6
SUSCLK_R: JWLAN1.42 RM32.1
SUSP: Q40.1 Q41.2 R175.2
SUSP#: PR209.1 PR300.1 Q40.2 R174.1 R176.1 R182.1 UE5.116
SW_1.35V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU200.16
SW_+1.05VSP: PC305.2 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PR305.1 PU300.8
SW_+1.35VS_VGAP: PC315.2 PL301.1 PQ302.5 PQ303.1 PQ303.2 PQ303.3 PR314.1 PU301.8
SYS_PEX_RST_MON#: DV8.2 QV13.2 QV13.5 QV89.2 QV89.5 QV91.2 QV91.5 RV64.1 RV187.1 RV208.1 UV1.AW2 UV14.4
SYS_PWROK: CE46.1 RC53.1 RC57.1 RH47.1 UE5.86 UH2.4
SYS_PWROK_R: RH47.2 UH1.AD7
SYS_RESET#: RH32.2 UH1.AM1
SYSON: CE42.1 PR208.1 PR304.1 PR315.1 UE5.95
TB_STAT#_CHG: PQ705.2 PR718.1 PU700.16
TMDS_L_TX0N: JHDMI1.9 LV4.2 RV22.2
TMDS_L_TX0P: JHDMI1.7 LV4.3 RV24.2
TMDS_L_TX1N: JHDMI1.6 LV5.2 RV26.2
TMDS_L_TX1P: JHDMI1.4 LV5.3 RV28.2
TMDS_L_TX2N: JHDMI1.3 LV6.2 RV30.2
TMDS_L_TX2P: JHDMI1.1 LV6.3 RV29.2
TMDS_L_TXCN: JHDMI1.12 LV3.2 RV19.2
TMDS_L_TXCP: JHDMI1.10 LV3.3 RV21.2
TMDS_TX0N: LV4.1 RV22.1 UV4.24
TMDS_TX0N_C: CV43.1 UV4.7
TMDS_TX0P: LV4.4 RV24.1 UV4.25
TMDS_TX0P_C: CV42.1 UV4.6
TMDS_TX1N: LV5.1 RV26.1 UV4.26
TMDS_TX1N_C: CV41.1 UV4.5
TMDS_TX1P: LV5.4 RV28.1 UV4.27
TMDS_TX1P_C: CV39.1 UV4.4
TMDS_TX2N: LV6.1 RV30.1 UV4.29
TMDS_TX2N_C: CV38.1 UV4.2
TMDS_TX2P: LV6.4 RV29.1 UV4.30
TMDS_TX2P_C: CV37.1 UV4.1
TMDS_TXCN: LV3.1 RV19.1 UV4.21
TMDS_TXCN_C: CV45.1 UV4.10
TMDS_TXCP: LV3.4 RV21.1 UV4.22
TMDS_TXCP_C: CV44.1 UV4.9
TON_1.35V: PR206.2 PU200.9
TP_CLK: JPWR1.21 RE100.2 UE5.87
TP_DATA: JPWR1.22 RE101.2 UE5.88
TP_EN: UE6.14 UT1.4
TP_LED_B#: JPWR1.10 UE8.5
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#: JPWR1.9 UE8.4
TP_LED_R#: JPWR1.8 UE8.3
TPM_PIRQ#: RH154.2 UH1.C14 UT2.20
TRIP_+1.05VSP: PR303.2 PU300.2
TRIP_+1.35VS_VGAP: PR312.2 PU301.2
TS_EN: JEDP1.27 UE5.73 UV2.4
U2_BOOT1: PR601.1 PU600.1
U2_BOOT2: PR617.1 PU600.18
U2_BOOT3: PR633.1 PU601.4
U2_LGATE1: PQ605.6 PQ606.6 PR649.2 PU600.23
U2_LGATE2: PQ607.6 PQ608.6 PU600.20
U2_LGATE3: PQ609.6 PQ611.6 PU601.7
U2_PHASE1: PC612.2 PL601.2 PQ605.7 PQ606.7 PR608.1 PR648.1 PU600.24
U2_PHASE2: PC619.2 PL602.2 PQ607.7 PQ608.7 PR626.1 PR646.1 PU600.19
U2_PHASE3: PC625.2 PL603.2 PQ609.7 PQ611.7 PR638.1 PR640.1 PU601.2
U2_PWM3: PR642.1 PU600.22
U2_UGATE1: PQ605.1 PQ606.1 PU600.2
U2_UGATE2: PQ607.1 PQ608.1 PU600.17
U2_UGATE3: PQ609.1 PQ611.1 PU601.3
UG_3V: PQ100.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1.05VSP: PQ300.4 PU300.9
UG_+1.35VS_VGAP: PQ303.4 PU301.9
UGATE1: PQ501.1 PQ502.1 PU500.19
UGATE2: PQ503.1 PQ504.1 PU500.26
UGATE3: PQ505.1 PQ506.1 PU501.1
USB3RN1: LI2.3 RI5.1 UH1.AR26
USB3RN1_R: DI3.1 DI3.9 JUSB1.5 LI2.4 RI5.2
USB3RN2: LI6.3 RI62.1 UH1.AW26
USB3RN2_R: DI5.1 DI5.9 JUSB2.5 LI6.4 RI62.2
USB3RN3: LI11.2 RI71.1 UH1.AW31
USB3RN3_R: JIO.10 LI11.1 RI71.2
USB3RN5: CI38.1 UH1.AW29
USB3RN5_L: CI38.2 LI13.3 RI76.1
USB3RN5_R: JCDRA.36 LI13.4 RI76.2
USB3RN6: LI8.2 RI65.1 UH1.AR29
USB3RN6_R: JIO.19 LI8.1 RI65.2
USB3RP1: LI2.2 RI8.1 UH1.AP26
USB3RP1_R: DI3.2 DI3.8 JUSB1.6 LI2.1 RI8.2
USB3RP2: LI6.2 RI61.1 UH1.AV26
USB3RP2_R: DI5.2 DI5.8 JUSB2.6 LI6.1 RI61.2
USB3RP3: LI11.3 RI72.1 UH1.AY31
USB3RP3_R: JIO.9 LI11.4 RI72.2
USB3RP5: CI39.1 UH1.AV29
USB3RP5_L: CI39.2 LI13.2 RI75.1
USB3RP5_R: JCDRA.37 LI13.1 RI75.2
USB3RP6: LI8.3 RI66.1 UH1.AP29
USB3RP6_R: JIO.18 LI8.4 RI66.2
USB3TN1: CI30.1 UH1.BE24
USB3TN1_L: CI30.2 LI3.3 RI11.1
USB3TN1_R: DI3.4 DI3.7 JUSB1.8 LI3.4 RI11.2
USB3TN2: CI32.1 UH1.BD25
USB3TN2_L: CI32.2 LI5.3 RI60.1
USB3TN2_R: DI5.4 DI5.7 JUSB2.8 LI5.4 RI60.2
USB3TN3: CI36.1 UH1.BE32
USB3TN3_L: CI36.2 LI12.2 RI73.1
USB3TN3_R: JIO.7 LI12.1 RI73.2
USB3TN5: LI14.3 RI78.1 UH1.BE26
USB3TN5_R: JCDRA.42 LI14.4 RI78.2
USB3TN6: CI34.1 UH1.BD27
USB3TN6_L: CI34.2 LI9.2 RI67.1
USB3TN6_R: JIO.16 LI9.1 RI67.2
USB3TP1: CI31.1 UH1.BD23
USB3TP1_L: CI31.2 LI3.2 RI13.1
USB3TP1_R: DI3.5 DI3.6 JUSB1.9 LI3.1 RI13.2
USB3TP2: CI33.1 UH1.BC24
USB3TP2_L: CI33.2 LI5.2 RI59.1
USB3TP2_R: DI5.5 DI5.6 JUSB2.9 LI5.1 RI59.2
USB3TP3: CI37.1 UH1.BC32
USB3TP3_L: CI37.2 LI12.3 RI74.1
USB3TP3_R: JIO.6 LI12.4 RI74.2
USB3TP5: LI14.2 RI77.1 UH1.BC26
USB3TP5_R: JCDRA.43 LI14.1 RI77.2
USB3TP6: CI35.1 UH1.BE28
USB3TP6_L: CI35.2 LI9.3 RI68.1
USB3TP6_R: JIO.15 LI9.4 RI68.2
USB20_CAM_N6_R: JEDP1.24 LV2.2 RV7.2
USB20_CAM_P6_R: JEDP1.23 LV2.3 RV6.2
USB20_N0: LI1.4 RI1.1 UH1.B37
USB20_N0_CONN: DI2.3 JUSB1.2 LI1.3 RI1.2
USB20_N1: LI7.4 RI63.1 UH1.A38
USB20_N1_CONN: JIO.22 LI7.3 RI63.2
USB20_N2: LM1.1 UH1.A36
USB20_N2_CONN: JCDRA.40 LM1.2
USB20_N3: UE1.5 UH1.A34
USB20_N4: JWLAN1.5 UH1.B33
USB20_N5: DV2.3 JEDP1.34 UH1.F31
USB20_N6: LV2.1 RV7.1 UH1.K31
USB20_N7: LI4.1 RI58.1 UH1.G29
USB20_N7_CONN: DI4.3 JUSB2.2 LI4.2 RI58.2
USB20_N8: LI10.4 RI69.1 UH1.A32
USB20_N8_CONN: JIO.13 LI10.3 RI69.2
USB20_P0: LI1.1 RI4.1 UH1.D37
USB20_P0_CONN: DI2.2 JUSB1.3 LI1.2 RI4.2
USB20_P1: LI7.1 RI64.1 UH1.C38
USB20_P1_CONN: JIO.21 LI7.2 RI64.2
USB20_P2: LM1.4 UH1.C36
USB20_P2_CONN: JCDRA.39 LM1.3
USB20_P3: UE1.4 UH1.C34
USB20_P4: JWLAN1.3 UH1.D33
USB20_P5: DV2.2 JEDP1.35 UH1.G31
USB20_P6: LV2.4 RV6.1 UH1.L31
USB20_P7: LI4.4 RI56.1 UH1.H29
USB20_P7_CONN: DI4.2 JUSB2.3 LI4.3 RI56.2
USB20_P8: LI10.1 RI70.1 UH1.C32
USB20_P8_CONN: JIO.12 LI10.2 RI70.2
USB_OC0#: CI5.1 RPH7.4 UH1.P3 UI2.3
USB_OC1#: CI29.1 RPH7.3 UH1.V1 UI3.3
USB_OC2#: JIO.5 RH72.2 RPH7.2 UH1.U2
USB_OC3#: RPH6.1 UH1.P1
USB_OC4#: RH72.1 RPH6.4 UH1.M3
USB_OC5#: RPH7.1 UH1.T1
USB_OC6#: RPH6.2 UH1.N2
USB_OC7#: RPH6.3 UH1.M1
USB_PWR_EN#: CI4.1 CI28.1 JIO.3 UE5.117 UI2.4 UI3.4
USBCHG_DET#: CU27.2 CU28.1 DU9.2 JIO.2 RU4.2
USBCHG_DET_D: PD100.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU9.1 RU6.2 UE5.75
USBRBIAS: RH109.1 UH1.K24 UH1.K26
VCIN0_PH: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_PH: PC13.2 PR23.1 PR26.2 UE5.102
VCORE_VDDP: PC509.2 PR520.1 PR523.1 PU500.23
VCOUT0_PH#: PR114.1 UE5.104
VCOUT1_PH: RE82.2 RE85.2 UE5.103
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK2: QV13.4 RV191.1 UV1.BF3
VGA_SMB_DA2: QV13.1 RV192.1 UV1.BE3
VID_PLLVDD: CV76.1 CV80.1 CV397.2 CV398.1 LV15.1 UV1.AW27 UV1.AW28
VIDALERT_N: PR506.1 RC47.2 RC48.1
VIDSCLK: CPU1.J52 PR508.1
VIDSOUT: CPU1.J50 PR505.1 RC49.1
VL: PC111.1 PU100.13
VR_HOT#: PC510.1 PR524.1 PR527.2 RE78.2
VR_HOT#1: PR524.2 PU500.5
VR_ON: PR511.2 PU500.2
VSB_N_001: PC10.2 PQ3.3 PR12.2 PR13.2
VSB_N_002: PC12.1 PQ4.2 PR17.2
VSB_N_003: PQ4.1 PR13.1
VTTREF_1.35V: PC210.1 PU200.4
WAKE#: RH36.2 RH48.1 UH1.K3
WAKE_PCH#: RH156.1 UE5.74 UH1.R11
WL_OFF#: QN2.3 RH61.2 UH1.A10
WL_OFF#_R: JWLAN1.48 QN2.1 RN5.2
WLAN_LED#: JWLAN1.16 QN5.3 RN26.2
WLAN_WAKE#: JWLAN1.47 RE92.1 UE5.1
WLANCLK_REQ#: JWLAN1.45 RH78.2 UH1.T3
WLES ON/OFF LED#: JPWR1.29 QN4.1 QN5.1 RN27.2
XDP_BPM#0_R: CPU1.R51 T127.1(TP-1)
XDP_BPM#1_R: CPU1.R50 T128.1(TP-1)
XDP_BPM#2: CPU1.P49 T4.1(TP-1)
XDP_BPM#3: CPU1.N50 T5.1(TP-1)
XDP_BPM#4: CPU1.R49 T6.1(TP-1)
XDP_BPM#5: CPU1.P53 T7.1(TP-1)
XDP_BPM#6: CPU1.U51 T8.1(TP-1)
XDP_BPM#7: CPU1.P51 T9.1(TP-1)
XDP_DBRESET#: RC17.2 RH32.1
XDP_DBRESET#_R: CPU1.F53 RC17.1 RC27.2
XDP_PRDY#: CPU1.N53 T93.1(TP-1)
XDP_PREQ#: CPU1.N52 T94.1(TP-1)
XDP_TCLK: CPU1.N54 T124.1(TP-1)
XDP_TDI_R: CPU1.N49 T125.1(TP-1)
XDP_TDO_R: CPU1.M49 T126.1(TP-1)
XDP_TMS: CPU1.M51 T2.1(TP-1)
XDP_TRST#: CPU1.M53 T3.1(TP-1)
XTAL25_IN: CH9.2 RH84.2 UH1.AL44 YH2.1
XTAL25_OUT: CH8.2 RH84.1 UH1.AM43 YH2.3
XTAL_OUT: CV73.2 RV52.2 UV1.BA1 YV1.3
XTALIN: CV74.2 RV52.1 UV1.BB2 YV1.1
XTALOUT: RV51.1 UV1.BB1
XTALSSIN: RV49.1 UV1.BB3
XTLI: CL8.2 UL1.8 YL1.1
XTLO: CL9.2 UL1.7 YL1.3
N3691692: PC305.1 PR302.2
N3691782: PC309.1 PR305.2
N4123408: PC105.2 PR108.1
N4123550: PC109.1 PR110.2
N4123582: PC110.1 PR111.2
N4124695: PC106.1 PR109.2
N14137547: PR107.1 PU100.19
N16767833: PC112.1 PR100.2 PR112.2 PR113.2 PR114.2 PR115.2 PR116.1
N16767857: PD101.1 PR115.1
N16768121: PD100.1 PR113.1
N16788038: PC701.2 PC722.2 PC723.2 PQ702.4 PR705.1 PR725.2 PR726.2
N16788064: PQ700.2 PR700.2 PR701.1
N17238594: PD2.2 PR18.1 PR19.2
N17244731: PD1.2 PL2.1 PQ7.1 PR6.2
N17272701: PR642.2 PU601.5
N17272705: PC635.2 PR627.2 PR629.2 PU600.11
N17272706: PC635.1 PR622.2 PR624.2 PU600.10
N17407779: CE36.1 RE89.1
N17434554: RE74.2 UE5.107
N18016661: RE25.2 UE3.24
N18017204: RE31.1 UE3.30
N18168284: PC207.2 PR204.2 PU200.12
N18410136: PC315.1 PR309.2
N18410161: PR316.2 PR317.1 PR319.2
N18410178: PC317.1 PR314.2
N18456729: PR722.1 PU700.20
N18456733: PR723.1 PU700.19
N18456739: PQ705.3 PR709.1 PR711.1 PU700.21
N18456772: PC711.2 PR707.2 PU700.28
N18456789: PD700.1 PR707.1
N18456799: PR724.2 PU700.10
N18456859: PC702.2 PR708.1
N18456884: PC718.2 PR717.2 PU700.7
N18456888: PC720.2 PU700.8
N18456944: PQ705.1 PR710.2
N18456952: PR720.2 PU700.11
N18456954: PR721.2 PU700.12
N18473450: PC612.1 PR601.2
N18474067: PC619.1 PR617.2
N18474286: PC625.1 PR633.2
N18854923: JDIMM2.201 RD15.2
N18898834: PD2.3 PR20.1 PR21.2
N18903973: PD3.2 PR15.1 PR22.2
N19248975: C9.2 RD10.1
N19249013: CD21.2 RD4.1
N20194225: PC617.1 PR606.2 PR611.2 PR613.1
N20340292: PR616.1 PR618.1
N20620737: PC622.1 PR625.1 PU600.21
N21560268: CD38.2 RD14.1
N23562769: QV2.1 RV12.2
N23567023: JHDMI1.13 RV20.2
N26316553: PC502.1 PR501.1 PU501.6 PU501.7
N26987587: RL2.2 UL1.5
N26987818: QL3.1 RL13.2 RL14.2
N26987825: CL31.1 JLAN.12 LL1.2
N27543768: CE6.1 CE7.1 CE60.1 RE4.2 RE5.2 UE1.8
N27591408: DN1.1 QN3.1
N27863565: RN15.2 RN16.2 UN1.18
N27863791: RN12.2 UN1.7
N27863843: RN8.2 UN1.10
N27864293: RE14.2 UE2.3
N27864303: CE20.1 RE11.1 UE2.6
N27864309: RE9.1 UE2.5
N27864330: RE13.2 UE2.7
N27864389: CE8.1 UE1.20
N27864390: CE9.1 UE1.19
N27864395: CE18.1 UE1.11
N27864397: CE17.1 UE1.12
N27864399: CE16.1 UE1.13
N27864402: CE15.1 UE1.14
N27864404: CE14.1 UE1.15
N27864406: CE13.1 UE1.16
N27864434: RE10.1 UE2.2
N27869543: DF1.1 JFAN1.3 RF3.1
N27869598: DF2.1 JFAN2.3 RF6.1
N28433555: CPU1.BE4 T12.1(TP-1)
N28433558: CPU1.BD3 T14.1(TP-1)
N28433585: CPU1.F6 T16.1(TP-1)
N28433588: CPU1.G6 T17.1(TP-1)
N28433591: CPU1.G21 T18.1(TP-1)
N28433594: CPU1.G24 T19.1(TP-1)
N28433839: CPU1.L52 T25.1(TP-1)
N28433842: CPU1.L53 T27.1(TP-1)
N28433845: CPU1.L51 T30.1(TP-1)
N28433848: CPU1.F24 T32.1(TP-1)
N28433851: CPU1.F25 T33.1(TP-1)
N28434861: CPU1.L50 T37.1(TP-1)
N28434864: CPU1.L49 T39.1(TP-1)
N28434867: CPU1.E5 T40.1(TP-1)
N28434944: CPU1.F1 T10.1(TP-1)
N28434947: CPU1.E1 T11.1(TP-1)
N28434950: CPU1.A5 T13.1(TP-1)
N28434953: CPU1.A6 T15.1(TP-1)
N28435099: CPU1.B50 T20.1(TP-1)
N28435102: CPU1.AH49 T21.1(TP-1)
N28435105: CPU1.AM48 T22.1(TP-1)
N28435108: CPU1.AU27 T23.1(TP-1)
N28435111: CPU1.AU26 T24.1(TP-1)
N28435114: CPU1.BD4 T26.1(TP-1)
N28435129: CPU1.BC4 T28.1(TP-1)
N28435132: CPU1.AL6 T29.1(TP-1)
N28435135: CPU1.F8 T31.1(TP-1)
N28435138: CPU1.F16 T34.1(TP-1)
N28435141: CPU1.G12 T35.1(TP-1)
N28435144: CPU1.G10 T36.1(TP-1)
N28435213: CPU1.H50 T38.1(TP-1)
N28435361: CPU1.BF51 T42.1(TP-1)
N28435397: CPU1.D1 T44.1(TP-1)
N28435400: CPU1.D54 T45.1(TP-1)
N28435463: CPU1.A4 T41.1(TP-1)
N28435472: CPU1.A51 T43.1(TP-1)
N28435499: CPU1.BC1 T46.1(TP-1)
N28435502: CPU1.BC54 T47.1(TP-1)
N28435508: CPU1.BF4 T48.1(TP-1)
N28443132: CPU1.J17 T49.1(TP-1)
N28443135: CPU1.J21 T50.1(TP-1)
N28443138: CPU1.J26 T51.1(TP-1)
N28443141: CPU1.J31 T52.1(TP-1)
N28445068: CPU1.AN31 T53.1(TP-1)
N28446375: CPU1.AN22 T54.1(TP-1)
N28446378: CPU1.AN18 T55.1(TP-1)
N28446558: CPU1.AH9 T56.1(TP-1)
N28450396: CPU1.AN33 T57.1(TP-1)
N28450399: CPU1.W9 T58.1(TP-1)
N28450402: CPU1.AR49 T59.1(TP-1)
N28453832: CPU1.V49 T60.1(TP-1)
N28453835: CPU1.U49 T61.1(TP-1)
N28733040: JDIMM1.197 RD7.2
N28733045: JDIMM1.201 RD8.2
N28734882: JDIMM2.197 RD16.2
N28780624: RH73.2 UH1.AB1
N28780661: RH75.2 UH1.AF1
N29026996: JLAN.9 RL8.1
N29187218: RV45.1 UV17.3
N29355924: RM34.2 UM1.3
N29359451: CU27.1 DU8.2 RU5.2 UU5.2
N29389682: RE32.2 UE4.24
N29389707: RE37.1 UE4.30
N29566756: R181.2 U2407.7
N29973818: RV66.1 UV1.BB7
N29977942: RE45.2 UE8.24
N29977967: RE41.1 UE8.30
N30011846: RV131.1 UV9.J1
N30011856: RV135.1 UV9.J13
N30011880: RV133.1 UV9.J10
N30012034: RV132.1 UV8.J1
N30012053: RV136.1 UV8.J13
N30012101: RV134.1 UV8.J10
N30014501: QV24.1 RV199.1 RV200.1
N30019834: RV161.1 UV13.J1
N30019838: RV156.1 UV13.J13
N30050086: QV12.2 RV56.1
N30057546: CV368.1 UV11.12
N30057549: CV369.1 UV11.10
N30064270: RV117.1 UV7.J1
N30064272: RV121.1 UV7.J13
N30064285: RV119.1 UV7.J10
N30064415: RV116.1 UV6.J1
N30064432: RV120.1 UV6.J13
N30064451: RV118.1 UV6.J10
N30064642: QV23.1 RV193.1 RV194.1
N30070817: RV165.1 UV12.J1
N30070819: RV160.1 UV12.J13
N30070830: RV140.1 UV12.J10
N30070921: RV159.1 UV13.J10
N30071304: QV21.1 RV144.1 RV164.1
N30074378: RV172.1 UV16.J1
N30074380: RV166.1 UV16.J13
N30074391: RV188.1 UV16.J10
N30074450: RV204.1 UV15.J1
N30074452: RV171.1 UV15.J13
