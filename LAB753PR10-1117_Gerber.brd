# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D38: length 48.5
  IN6 w0.089: v3(122.3,73.22) 122.09,73.22 121.54,72.67 121.54,70.89 121.99,70.45 121.99,69.94
  IN6 w0.099: 121.99,69.94 121.99,69.77 123.39,68.38 123.39,55.45 124.53,54.32 124.53,37.22 124.96,36.78 124.96,33.89 124.84,33.76 124.4,33.76 124.27,33.64 124.27,33.3 124.4,33.17 124.84,33.17 124.97,33.05 124.97,32.67 124.84,32.54 123.68,32.54 v3(123.68,32.54)
  BOTTOM w0.089: v3(122.3,73.22) 122.05,73.22 121.85,73.18 CPU1.BD11
  BOTTOM w0.127: v3(123.68,32.54) 122.74,31.78 JDIMM1.140
DDR_A_D39: length 48.8
  IN6 w0.089: v3(120.8,71.06) 120.8,70.62 121.1,70.32 121.1,69.94
  IN6 w0.099: 121.1,69.94 121.1,67.8 122.5,66.4 122.5,51.07 123.63,49.93 123.63,47.26 123.53,47.16 123.28,47.16 123.15,47.04 123.15,46.78 123.28,46.66 123.53,46.66 123.63,46.56 123.63,46.25 123.53,46.15 123.25,46.15 123.13,46.02 123.13,45.77 123.25,45.65 123.53,45.65 123.63,45.55 123.63,45.24 123.53,45.14 123.25,45.14 123.13,45.01 123.13,44.76 123.25,44.64 123.53,44.64 123.63,44.54 123.63,44.23 123.53,44.13 123.25,44.13 123.13,44 123.13,43.75 123.25,43.62 123.53,43.62 123.63,43.53 123.63,43.22 123.53,43.12 123.25,43.12 123.13,42.99 123.13,42.74 123.25,42.61 123.53,42.61 123.63,42.51 123.63,42.21 123.53,42.11 123.25,42.11 123.13,41.98 123.13,41.73 123.25,41.6 123.53,41.6 123.63,41.5 123.63,40.46 123.27,40.1 123.27,35.99 v3(123.68,35.58)
  BOTTOM w0.089: CPU1.BE11 121.48,71.84 121.48,71.34 121.2,71.06 v3(120.8,71.06)
  BOTTOM w0.127: v3(123.68,35.58) 124.34,34.75 124.34,32.48 123.34,31.49 JDIMM1.142
DDR_A_D40: length 47.5
  IN6 w0.089: v3(122.3,73.91) 122.59,73.91 122.75,73.75 122.75,71.82 122.91,71.67 122.91,70.67 123.09,70.49 123.09,70.23 123.38,69.94
  IN6 w0.099: 123.38,69.94 124.6,68.72 124.6,67.5 124.72,67.37 124.97,67.37 125.1,67.24 125.1,66.99 124.97,66.86 124.72,66.86 124.6,66.74 124.6,66.49 124.72,66.36 125.44,66.36 125.56,66.23 125.56,65.31 125.44,65.18 124.72,65.18 124.6,65.05 124.6,59.55 125.56,58.58 125.56,55.6 125.63,55.54 125.63,37.77 126.39,37.01 126.39,35.73 v3(125.98,35.32)
  BOTTOM w0.089: CPU1.BC9 122.66,73.58 v3(122.3,73.91)
  BOTTOM w0.127: v3(125.98,35.32) 124.84,36.46 JDIMM1.147
DDR_A_D41: length 46.5
  IN6 w0.089: 122.96,69.94 122.79,70.11 122.79,70.42 122.68,70.52 122.68,71.48 v3(122.3,71.86)
  IN6 w0.099: 122.96,69.94 124.3,68.6 124.3,66.16 124.4,66.06 125.07,66.06 125.2,65.93 125.2,65.68 125.07,65.56 124.4,65.56 124.3,65.46 124.3,58.71 124.43,58.58 125.14,58.58 125.27,58.46 125.27,58.21 125.14,58.08 124.43,58.08 124.3,57.95 124.3,57.67 124.4,57.57 125.14,57.57 125.27,57.45 125.27,57.2 125.14,57.07 124.43,57.07 124.3,56.94 124.3,56.69 124.43,56.56 125.14,56.56 125.27,56.44 125.27,56.18 125.14,56.06 124.43,56.06 124.3,55.93 124.3,55.68 124.43,55.55 125.2,55.55 125.33,55.43 125.33,37.55 125.98,36.9 v3(125.98,36.85)
  BOTTOM w0.089: v3(122.3,71.86) 122.29,71.86 122.64,72.18 CPU1.BE9
  BOTTOM w0.127: JDIMM1.149 125.44,37.38 125.44,36.92 125.52,36.85 v3(125.98,36.85)
DDR_A_D42: length 45.3
  IN6 w0.099: v3(128.56,35.32) 128.97,35.73 128.97,37.01 128.16,37.82 128.16,45.36 128.03,45.49 127.74,45.49 127.61,45.62 127.61,45.88 127.74,46 128.03,46 128.16,46.13 128.16,46.38 128.03,46.51 127.74,46.51 127.61,46.64 127.61,47.62 127.71,47.72 128.03,47.72 128.16,47.85 128.16,48.1 128.03,48.22 127.71,48.22 127.61,48.32 127.61,48.63 127.71,48.73 128.03,48.73 128.16,48.86 128.16,49.11 128.03,49.24 127.71,49.24 127.61,49.33 127.61,56.63 127.38,56.87 127.38,69.32 v3(124.9,71.8)
  BOTTOM w0.089: CPU1.BE6 124.52,72.18 v3(124.9,71.8)
  BOTTOM w0.127: JDIMM1.157 127.84,36.04 v3(128.56,35.32)
DDR_A_D43: length 46.8
  IN6 w0.099: v3(124.79,73.26) 124.79,73.22 124.41,72.83 124.41,71.04 127.08,68.36 127.08,56.74 127.32,56.51 127.32,45.32 127.44,45.19 127.76,45.19 127.86,45.09 127.86,44.79 127.76,44.69 127.44,44.69 127.32,44.56 127.32,44.31 127.44,44.18 127.76,44.18 127.86,44.08 127.86,43.78 127.76,43.68 127.44,43.68 127.32,43.55 127.32,43.3 127.44,43.17 127.76,43.17 127.86,43.07 127.86,42.77 127.76,42.67 127.44,42.67 127.32,42.54 127.32,42.29 127.44,42.16 127.76,42.16 127.86,42.06 127.86,41.75 127.76,41.66 127.44,41.66 127.32,41.53 127.32,41.28 127.44,41.15 127.76,41.15 127.86,41.05 127.86,40.74 127.76,40.64 127.44,40.64 127.32,40.52 127.32,40.27 127.44,40.14 127.76,40.14 127.86,40.04 127.86,39.73 127.76,39.63 127.44,39.63 127.32,39.51 127.32,39.25 127.44,39.13 127.76,39.13 127.86,39.03 127.86,38.72 127.76,38.62 127.44,38.62 127.32,38.5 127.32,38.24 127.44,38.12 127.74,38.12 127.86,37.99 127.86,37.69 128.56,36.99 v3(128.56,36.85)
  BOTTOM w0.089: CPU1.BC6 124.5,73.58 124.83,73.26 124.82,73.26 v3(124.79,73.26)
  BOTTOM w0.127: JDIMM1.159 128.44,36.96 v3(128.56,36.85)
DDR_A_D44: length 46.3
  IN6 w0.089: 122.54,69.94 122.49,69.98 122.49,70.39 121.77,71.11 121.77,72.45 121.86,72.54 v3(122.31,72.54)
  IN6 w0.099: 122.54,69.94 124,68.48 124,55.56 125.03,54.53 125.03,37.43 125.47,36.99 125.47,33.5 125.58,33.39 125.79,33.39 125.98,33.58 v3(125.98,33.8)
  BOTTOM w0.089: v3(122.31,72.54) 122.66,72.88 CPU1.BD9
  BOTTOM w0.127: JDIMM1.146 124.55,31.49 125.48,32.43 125.48,33.29 v3(125.98,33.8)
DDR_A_D45: length 44.9
  IN6 w0.089: v3(123.29,71.02) 123.39,70.92 123.39,70.35 123.8,69.94
  IN6 w0.099: 123.8,69.94 124.89,68.85 124.89,67.79 125.02,67.66 125.74,67.66 125.86,67.54 125.86,64.99 125.74,64.86 125.02,64.86 124.89,64.73 124.89,59.67 125.86,58.7 125.86,55.73 125.92,55.67 125.92,37.9 126.68,37.14 126.68,32.98 v3(125.98,32.27)
  BOTTOM w0.089: v3(123.29,71.02) 122.82,71.48 CPU1.BF9
  BOTTOM w0.127: JDIMM1.148 125.14,31.44 v3(125.98,32.27)
DDR_A_D46: length 44.9
  IN6 w0.099: v3(128.56,33.8) 129.29,34.52 129.29,37.11 128.46,37.94 128.46,49.44 128.33,49.57 128.04,49.57 127.91,49.7 127.91,49.95 128.04,50.07 128.33,50.07 128.46,50.2 128.46,50.45 128.33,50.58 128.04,50.58 127.91,50.71 127.91,56.75 127.68,56.99 127.68,69.88 v3(125.65,71.91)
  BOTTOM w0.089: CPU1.BE5 125.37,72.18 v3(125.65,71.91)
  BOTTOM w0.127: JDIMM1.158 128.15,31.78 128.02,31.9 128.02,33.25 v3(128.56,33.8)
DDR_A_D47: length 46.4
  IN6 w0.099: v3(124.83,72.53) 125.55,72.53 127.97,70.1 127.97,57.11 128.21,56.88 128.21,51.14 128.75,50.6 128.75,38.07 129.59,37.24 129.59,33.74 129.49,33.64 129.35,33.64 129.22,33.51 129.22,33.26 129.35,33.13 129.49,33.13 129.59,33.03 129.59,32.41 129.45,32.27 v3(128.56,32.27)
  BOTTOM w0.089: v3(124.83,72.53) 124.83,72.57 124.51,72.88 CPU1.BD6
  BOTTOM w0.127: JDIMM1.160 128.74,32.09 v3(128.56,32.27)
DDR_A_D48: length 53
  IN6 w0.089: 128.48,69.94 128.48,72.85 127.64,73.69 126.88,73.69 v3(126.46,74.11)
  IN6 w0.099: v3(131.01,35.61) 130.91,35.71 130.72,35.71 130.6,35.59 130.6,34.2 130.47,34.07 130.22,34.07 130.09,34.2 130.09,38.06 129.96,38.19 129.39,38.19 129.26,38.32 129.26,38.57 129.39,38.7 129.94,38.7 130.04,38.8 130.04,39.1 129.94,39.2 129.39,39.2 129.26,39.33 129.26,39.58 129.39,39.71 129.94,39.71 130.04,39.81 130.04,40.11 129.94,40.21 129.39,40.21 129.26,40.34 129.26,40.59 129.39,40.72 129.94,40.72 130.04,40.82 130.04,41.12 129.94,41.22 129.39,41.22 129.26,41.35 129.26,50.81 128.71,51.35 128.71,57.09 128.48,57.32 128.48,69.94
  BOTTOM w0.089: v3(126.46,74.11) 126.46,74.3 CPU1.BB4
  BOTTOM w0.127: v3(131.01,35.61) 129.64,36.98 JDIMM1.163
DDR_A_D49: length 51.3
  IN6 w0.089: v3(128.67,73.19) 128.77,73.08 128.77,69.94
  IN6 w0.099: v3(131.01,37.14) 131.01,36.95 130.76,36.71 130.51,36.71 130.39,36.82 130.39,37.8 130.49,37.9 131.06,37.9 131.19,38.03 131.19,38.28 131.06,38.41 130.49,38.41 130.34,38.56 130.34,41.56 130.24,41.66 129.66,41.66 129.56,41.76 129.56,42.06 129.66,42.16 130.24,42.16 130.34,42.26 130.34,42.57 130.24,42.67 129.66,42.67 129.56,42.77 129.56,43.08 129.66,43.17 130.24,43.17 130.34,43.27 130.34,43.58 130.24,43.68 129.66,43.68 129.56,43.78 129.56,44.09 129.66,44.19 130.24,44.19 130.34,44.28 130.34,44.59 130.24,44.69 129.66,44.69 129.56,44.79 129.56,45.1 129.66,45.2 130.24,45.2 130.34,45.3 130.34,45.6 130.24,45.7 129.66,45.7 129.56,45.8 129.56,46.11 129.66,46.21 130.24,46.21 130.34,46.31 130.34,46.61 130.24,46.71 129.66,46.71 129.56,46.81 129.56,47.12 129.66,47.22 130.24,47.22 130.34,47.32 130.34,47.63 130.24,47.72 129.66,47.72 129.56,47.82 129.56,50.93 129.01,51.48 129.01,57.21 128.77,57.45 128.77,69.94
  BOTTOM w0.089: v3(128.67,73.19) 128.21,73.29 128.08,73.29 128.07,73.3 CPU1.BC2
  BOTTOM w0.127: v3(131.01,37.14) 130.98,37.11 130.49,37.11 130.24,37.36 130.24,37.48 JDIMM1.165
DDR_A_D50: length 53.4
  IN6 w0.089: 129.8,75.4 129.58,75.4 129.35,75.63 128.76,76.22 126.82,76.22 v3(126.45,75.86)
  IN6 w0.099: 129.8,75.4 130.06,75.4 131.17,74.29 131.17,58.55 133.04,56.68 133.04,39.9 134.94,38 134.94,34.98 v3(134.05,34.09)
  BOTTOM w0.089: v3(126.45,75.86) 126.82,76.23 CPU1.AW3
  BOTTOM w0.127: v3(134.05,34.09) 133.54,34.59 133.54,36.92 133.24,37.22 133.24,37.45 JDIMM1.175
DDR_A_D51: length 52.3
  IN6 w0.089: v3(127.16,75.85) 127.54,75.47 128.71,75.47 129.46,74.72 129.8,74.72
  IN6 w0.099: 129.8,74.72 129.86,74.72 130.58,74.01 130.58,58.3 130.87,58.01 130.87,55 131,54.87 131.83,54.87 131.96,54.74 131.96,54.49 131.83,54.36 131,54.36 130.87,54.24 130.87,53.99 131,53.86 132.34,53.86 132.44,53.76 132.44,53.45 132.34,53.35 131.98,53.35 131.86,53.23 131.86,52.98 131.98,52.85 132.34,52.85 132.44,52.75 132.44,39.66 133.03,39.07 133.03,38.33 133.16,38.21 133.89,38.21 134.02,38.08 134.02,37.83 133.89,37.7 133.16,37.7 133.03,37.57 133.03,36.33 133.16,36.2 133.42,36.2 133.54,36.33 133.54,37.08 133.6,37.14 v3(134.05,37.14)
  BOTTOM w0.089: v3(127.16,75.85) 127.52,76.21 CPU1.AW2
  BOTTOM w0.127: JDIMM1.177 133.84,37.34 v3(134.05,37.14)
DDR_A_D52: length 52.6
  IN6 w0.089: v3(127.16,74.11) 128.31,74.11 128.53,74.32 128.78,74.32 129.37,73.74 129.37,69.94
  IN6 w0.099: v3(131.01,32.57) 131.41,32.57 131.78,32.94 131.78,38.61 130.93,39.46 130.93,41.38 131.23,41.67 131.23,50.44 131.13,50.54 130.66,50.54 130.54,50.67 130.54,50.92 130.66,51.04 131.13,51.04 131.23,51.14 131.23,51.45 131.13,51.55 129.78,51.55 129.65,51.68 129.65,51.93 129.78,52.05 130.56,52.05 130.69,52.18 130.69,52.43 130.56,52.56 129.73,52.56 129.6,52.69 129.6,57.46 129.37,57.69 129.37,69.94
  BOTTOM w0.089: v3(127.16,74.11) 127.16,74.16 126.82,74.5 CPU1.BB3
  BOTTOM w0.127: v3(131.01,32.57) 130.58,32.57 129.95,31.93 JDIMM1.164
DDR_A_D53: length 52.6
  IN6 w0.089: v3(128.66,73.94) 129.07,73.52 129.07,69.94
  IN6 w0.099: 129.07,69.94 129.07,57.57 129.31,57.33 129.31,51.6 129.75,51.15 130.11,51.15 130.24,51.03 130.24,50.77 130.11,50.65 129.98,50.65 129.85,50.52 129.85,50.27 129.98,50.14 130.83,50.14 130.93,50.04 130.93,49.74 130.83,49.64 129.98,49.64 129.85,49.51 129.85,49.26 129.98,49.13 130.83,49.13 130.93,49.03 130.93,48.72 130.83,48.63 129.98,48.63 129.85,48.5 129.85,48.25 129.98,48.12 130.83,48.12 130.93,48.02 130.93,41.79 130.64,41.5 130.64,39.34 131.49,38.49 131.49,34.42 131.13,34.06 v3(130.98,34.06)
  BOTTOM w0.089: CPU1.BB2 128,74.21 128.21,74.13 128.65,73.94 v3(128.66,73.94)
  BOTTOM w0.127: v3(130.98,34.06) 131.32,34.06 131.64,33.75 131.64,32.22 131.38,31.97 130.75,31.97 130.55,31.76 JDIMM1.166
DDR_A_D54: length 53.4
  IN6 w0.089: 129.8,75.7 129.75,75.7 129.61,75.85 129.44,75.85 128.87,76.42 126.73,76.42 v3(126.47,76.67)
  IN6 w0.099: v3(134.05,32.57) 134.97,32.57 135.26,32.86 135.26,38.1 133.34,40.03 133.34,56.81 131.47,58.67 131.47,74.41 130.18,75.7 129.8,75.7
  BOTTOM w0.089: v3(126.47,76.67) 126.12,76.32 CPU1.AW4
  BOTTOM w0.127: v3(134.05,32.57) 132.94,31.46 JDIMM1.174
DDR_A_D55: length 52
  IN6 w0.089: 129.8,75.02 129.54,75.02 128.73,75.83 v3(128.63,75.83)
  IN6 w0.099: 129.8,75.02 129.99,75.02 130.87,74.13 130.87,58.43 131.17,58.13 131.17,55.63 131.3,55.5 132.64,55.5 132.74,55.4 132.74,55.09 132.64,54.99 132.37,54.99 132.27,54.9 132.27,54.59 132.37,54.49 132.64,54.49 132.74,54.39 132.74,39.78 134.62,37.9 134.62,35.34 134.54,35.26 134.13,35.26 134.05,35.34 v3(134.05,35.61)
  BOTTOM w0.089: CPU1.AW1 128.25,76.21 v3(128.63,75.83)
  BOTTOM w0.127: v3(134.05,35.61) 134.56,35.1 134.56,32.41 134.03,31.89 133.94,31.89 133.54,31.49 JDIMM1.176
DDR_A_D56: length 58.5
  IN6 w0.089: 129.8,76.5 129.52,76.5 129.23,76.8 128.99,76.8 127.64,76.8 127.49,76.94 127.49,77.69 127.32,77.87 126.87,77.87 v3(126.49,77.48)
  IN6 w0.099: 129.8,76.5 130.62,76.5 132.27,74.85 132.27,59.01 134.16,57.12 134.16,40.9 134.28,40.77 136.21,40.77 136.34,40.65 136.34,40.39 136.21,40.27 134.75,40.27 134.62,40.14 134.62,39.89 134.75,39.76 136.29,39.76 136.42,39.63 136.42,39.33 136.29,39.21 136.19,39.21 136.06,39.08 136.06,37.45 136.34,37.17 136.34,35.56 136.46,35.43 136.74,35.43 136.93,35.62 v3(136.93,35.83)
  BOTTOM w0.089: v3(126.49,77.48) 126.82,77.82 CPU1.AU3
  BOTTOM w0.127: JDIMM1.181 135.04,37.72 v3(136.93,35.83)
DDR_A_D57: length 57.2
  IN6 w0.089: 129.8,76.8 129.49,76.8 129.3,76.99 129.24,76.99 128.7,76.99 128.57,77.12 v3(128.57,77.48)
  IN6 w0.099: 129.8,76.8 130.74,76.8 132.57,74.97 132.57,59.13 134.45,57.24 134.45,43.22 134.58,43.09 135.59,43.09 135.72,42.96 135.72,42.71 135.59,42.59 134.58,42.59 134.45,42.46 134.45,42.21 134.58,42.08 136.51,42.08 136.63,41.95 136.63,41.7 136.51,41.58 134.58,41.58 134.45,41.45 134.45,41.2 134.58,41.07 136.51,41.07 136.63,40.94 136.63,40.12 136.78,39.97 136.99,39.97 137.12,39.84 137.12,39.56 136.99,39.44 136.84,39.44 136.72,39.31 136.72,39.06 136.84,38.93 136.99,38.93 137.12,38.8 137.12,38.55 136.99,38.42 136.49,38.42 136.36,38.3 136.36,38.05 136.49,37.92 136.99,37.92 137.12,37.79 137.12,37.48 136.99,37.36 v3(136.93,37.36)
  BOTTOM w0.089: v3(128.57,77.48) 128.22,77.83 CPU1.AU1
  BOTTOM w0.127: JDIMM1.183 135.64,37.74 136.03,37.36 v3(136.93,37.36)
DDR_A_D58: length 57.9
  IN6 w0.089: 129.8,78.98 129.55,78.98 129.22,79.31 129.22,79.78 128.97,80.04 127.96,80.04 v3(127.88,79.96)
  IN6 w0.099: 129.8,78.98 131.57,78.98 134.7,75.85 134.7,60 136.55,58.14 136.55,49.07 136.68,48.95 137.34,48.95 137.44,48.85 137.44,48.54 137.34,48.44 136.68,48.44 136.55,48.31 136.55,48.06 136.68,47.94 137.34,47.94 137.44,47.84 137.44,44.96 140.45,41.95 140.45,36.24 v3(140.04,35.83)
  BOTTOM w0.089: CPU1.AR1 128.22,79.61 127.88,79.96 v3(127.88,79.96)
  BOTTOM w0.127: JDIMM1.191 138.04,37.5 139.71,35.83 v3(140.04,35.83)
DDR_A_D59: length 59.6
  IN6 w0.089: 129.8,78.68 129.58,78.68 128.99,79.28 128.53,79.28 128.27,79.53 126.84,79.53 v3(126.42,79.11)
  IN6 w0.099: v3(140.04,37.36) 140.04,39.27 139.91,39.4 139.69,39.4 139.56,39.52 139.56,39.79 139.69,39.92 139.91,39.92 140.04,40.05 140.04,40.36 139.91,40.49 139.22,40.49 139.1,40.62 139.1,41.3 139.22,41.43 139.94,41.43 140.07,41.56 140.07,41.85 139.94,41.98 139.22,41.98 139.1,42.1 139.1,42.85 137.14,44.81 137.14,45.39 137.01,45.52 136.38,45.52 136.25,45.64 136.25,45.9 136.38,46.02 137.01,46.02 137.14,46.15 137.14,46.4 137.01,46.53 136.38,46.53 136.25,46.66 136.25,46.91 136.38,47.03 137.01,47.03 137.14,47.16 137.14,47.41 137.01,47.54 136.38,47.54 136.25,47.67 136.25,57.99 134.38,59.86 134.38,75.75 131.44,78.68 129.8,78.68
  BOTTOM w0.089: CPU1.AR4 126.12,79.41 v3(126.42,79.11)
  BOTTOM w0.127: JDIMM1.193 138.64,37.78 139.06,37.36 v3(140.04,37.36)
DDR_A_D60: length 57.8
  IN6 w0.089: 129.8,77.1 129.47,77.1 128.72,77.85 128.23,77.85 v3(127.87,77.48)
  IN6 w0.099: 129.8,77.1 130.86,77.1 132.86,75.1 132.86,59.25 134.75,57.37 134.75,43.52 134.88,43.39 135.89,43.39 136.01,43.26 136.01,42.51 136.14,42.38 136.39,42.38 136.52,42.51 136.52,42.75 136.64,42.87 136.9,42.87 137.02,42.75 137.02,41.92 137.12,41.82 137.32,41.82 137.42,41.72 137.42,41.42 137.32,41.32 137.12,41.32 137.02,41.22 137.02,40.36 137.42,39.97 137.42,34 137.32,33.91 137.13,33.91 136.93,34.1 v3(136.93,34.31)
  BOTTOM w0.089: CPU1.AU2 127.52,77.83 v3(127.87,77.48)
  BOTTOM w0.127: JDIMM1.180 134.74,31.79 135.56,32.6 135.56,33.16 136.71,34.31 v3(136.93,34.31)
DDR_A_D61: length 59.4
  IN6 w0.089: 129.8,76.2 129.37,76.2 128.97,76.61 127.05,76.61 126.62,77.03 126.17,77.03 v3(125.72,77.49)
  IN6 w0.099: 129.8,76.2 130.39,76.2 131.97,74.62 131.97,58.88 133.86,57 133.86,40.71 134.32,40.24 134.32,39.75 134.68,39.4 135.64,39.4 135.77,39.27 135.77,37.14 135.86,37.04 135.94,37.04 136.04,36.94 136.04,36.64 135.94,36.54 135.86,36.54 135.77,36.44 135.77,36.13 135.86,36.03 135.94,36.03 136.04,35.93 136.04,35.62 135.94,35.53 135.86,35.53 135.77,35.43 135.77,34.93 135.89,34.81 136.42,34.81 136.54,34.68 136.54,34.43 136.42,34.3 135.89,34.3 135.76,34.18 135.76,33.92 135.89,33.8 136.42,33.8 136.51,33.71 136.51,33.38 136.42,33.29 135.89,33.29 135.77,33.16 135.77,32.86 135.84,32.79 v3(136.93,32.79)
  BOTTOM w0.089: CPU1.AU4 126.12,77.89 v3(125.72,77.49)
  BOTTOM w0.127: JDIMM1.182 135.34,31.74 136.39,32.79 v3(136.93,32.79)
DDR_A_D62: length 58.7
  IN6 w0.089: v3(127.88,79.13) 127.92,79.08 128.91,79.08 129.61,78.39 129.8,78.39
  IN6 w0.099: 129.8,78.39 131.32,78.39 134.07,75.64 134.07,59.75 135.96,57.87 135.96,45.52 138.8,42.68 138.8,40.22 138.9,40.12 139.07,40.12 139.19,40 139.19,39.74 139.07,39.62 138.9,39.62 138.8,39.52 138.8,39.21 138.9,39.11 139.54,39.11 139.64,39.01 139.64,38.71 139.54,38.61 138.9,38.61 138.8,38.51 138.8,38.2 138.9,38.1 139.54,38.1 139.64,38 139.64,34.71 v3(140.04,34.31)
  BOTTOM w0.089: v3(127.88,79.13) 127.52,79.48 CPU1.AR2
  BOTTOM w0.127: JDIMM1.192 138.34,31.69 139.51,32.86 139.51,33.78 v3(140.04,34.31)
DDR_A_D63: length 60
  IN6 w0.089: 129.8,79.28 129.54,79.28 129.42,79.39 129.42,79.86 128.96,80.32 126.8,80.32 v3(126.41,79.93)
  IN6 w0.099: v3(140.04,32.79) 140.85,33.59 140.85,42 137.73,45.11 137.73,48.97 136.87,49.84 136.87,58.27 135.02,60.13 135.02,75.95 131.69,79.28 129.8,79.28
  BOTTOM w0.089: CPU1.AR3 126.82,79.52 v3(126.41,79.93)
  BOTTOM w0.127: v3(140.04,32.79) 138.94,31.69 138.94,31.53 JDIMM1.194
DDR_A_DQS0: length 67.9
  IN6 w0.089: 90.81,84.11 90.82,84.11 90.83,84.1 90.89,84.1 90.89,84.1 91.12,84.1 91.62,83.6 93.34,83.6 v3(93.41,83.53)
  IN6 w0.099: v3(80.46,34.66) 80.46,34.47 80.55,34.39 80.76,34.39 80.96,34.59 80.96,37.77 81.72,38.53 81.72,43.48 81.93,43.69 82.57,43.69 82.67,43.79 82.67,44.1 82.57,44.2 81.93,44.2 81.72,44.41 81.72,44.88 81.93,45.09 82.36,45.09 82.49,45.22 82.49,45.47 82.36,45.6 81.93,45.6 81.72,45.81 81.72,61.27 85.53,65.08 85.53,73.99 83.79,75.74 83.79,78.69 89.2,84.11 90.81,84.11
  BOTTOM w0.089: CPU1.AJ53 93.41,83.46 v3(93.41,83.53)
  BOTTOM w0.127: v3(80.46,34.66) 80.54,34.58 81.13,34.58 81.55,34.16 81.55,32.45 81.7,32.3 81.7,31.86 81.94,31.61 JDIMM1.12
DDR_A_DQS1: length 59.5
  IN6 w0.089: 90.81,80.03 90.82,80.03 90.83,80.04 92.22,80.04 92.67,79.59 93.48,79.59 93.76,79.87 93.76,80.16 93.88,80.28 v3(94.12,80.28)
  IN6 w0.099: 90.81,80.03 90.57,80.03 89.22,78.68 89.22,65.66 89.32,65.57 89.59,65.57 89.83,65.32 89.83,64.91 89.59,64.67 89.32,64.67 89.22,64.57 89.22,64.26 89.32,64.16 89.59,64.16 89.83,63.92 89.83,62.91 89.54,62.62 89.54,61.47 90.4,60.61 90.4,47.96 87.99,45.55 87.99,40.14 85.41,37.56 85.41,35.48 85.56,35.33 85.73,35.33 85.87,35.47 v3(85.87,35.71)
  BOTTOM w0.089: CPU1.AP52 93.77,80.14 93.9,80.28 v3(94.12,80.28)
  BOTTOM w0.127: v3(85.87,35.71) 85.87,35.59 85.74,35.46 85.47,35.46 85.38,35.55 85.38,36.64 85.68,36.93 86.25,36.93 87.05,37.73 JDIMM1.29
DDR_A_DQS2: length 52.7
  IN6 w0.089: 93.79,69.94 93.79,69.95 93.8,69.96 93.8,72 92.15,73.66 92.15,76.49 92.45,76.79 92.64,76.79 92.72,76.88 v3(92.72,76.97)
  IN6 w0.099: 93.79,69.94 93.79,69.54 94.22,69.12 94.22,65.9 94.12,65.8 93.66,65.8 93.44,65.59 93.44,65.12 93.66,64.91 94.12,64.91 94.22,64.81 94.22,64.5 94.12,64.4 93.66,64.4 93.44,64.19 93.44,63.72 93.66,63.5 94.12,63.5 94.22,63.4 94.22,43.64 93,42.42 93,40.3 90.23,37.54 90.23,35.46 90.54,35.16 90.7,35.16 v3(90.89,34.97)
  BOTTOM w0.089: v3(92.72,76.97) 93.07,76.63 CPU1.AW53
  BOTTOM w0.127: v3(90.89,34.97) 91.06,35.14 91.38,35.14 91.63,35.4 91.63,36.98 92.44,37.8 JDIMM1.47
DDR_A_DQS3: length 51.7
  IN6 w0.089: v3(98.57,74.72) 98.57,74.75 98.36,74.95 98.24,74.95 98.17,74.89 98.17,74.58 98.57,74.18 98.57,70.64 98.76,70.45 98.76,69.96 98.77,69.96 98.77,69.94
  IN6 w0.099: v3(96.67,33.94) 96.67,33.68 96.56,33.57 96.34,33.57 96.23,33.68 96.23,35.02 96.33,35.12 96.81,35.12 97.05,35.37 97.05,35.78 96.81,36.02 96.36,36.02 96.23,36.15 96.23,36.47 96.36,36.6 96.81,36.6 97.05,36.84 97.05,38.15 97.91,39 97.91,59.49 98.77,60.35 98.77,63.77 98.56,63.98 98.03,63.98 97.91,64.11 97.91,64.36 98.03,64.49 98.56,64.49 98.77,64.7 98.77,65.17 98.56,65.39 98.36,65.39 98.24,65.51 98.24,65.76 98.36,65.89 98.56,65.89 98.77,66.1 98.77,69.94
  BOTTOM w0.089: CPU1.BA46 98.31,74.98 v3(98.57,74.72)
  BOTTOM w0.127: v3(96.67,33.94) 96.91,33.7 97.09,33.7 97.36,33.43 97.36,31.71 97.54,31.53 JDIMM1.64
DDR_A_DQS4: length 48.3
  IN6 w0.089: 120.59,69.94 120.59,70.38 120.4,70.57 120.4,72.77 120.53,72.89 120.68,72.89 120.79,72.78 v3(120.79,72.53)
  IN6 w0.099: v3(121.98,33.68) 122.16,33.86 122.5,33.86 122.94,34.3 122.94,35.26 122.62,35.59 122.62,47.22 123,47.6 123,49.81 121.99,50.82 121.99,66.19 120.59,67.59 120.59,69.94
  BOTTOM w0.089: CPU1.BE12 120.45,72.18 v3(120.79,72.53)
  BOTTOM w0.127: v3(121.98,33.68) 122.09,33.79 122.41,33.79 122.66,34.04 122.66,36.34 121.85,37.16 JDIMM1.137
DDR_A_DQS5: length 46
  IN6 w0.099: v3(127.29,34.94) 127.5,35.15 127.65,35.15 127.89,35.39 127.89,36.94 126.81,38.02 126.81,56.3 126.58,56.53 126.58,68.16 124.09,70.64 124.09,72.03 123.76,72.36 123.41,72.36 v3(123.24,72.53)
  BOTTOM w0.089: v3(123.24,72.53) 123.24,72.55 CPU1.BD7
  BOTTOM w0.127: v3(127.29,34.94) 127.29,35.19 127.22,35.26 127,35.26 126.81,35.06 126.81,31.98 126.73,31.9 126.73,31.7 126.94,31.48 JDIMM1.154
DDR_A_DQS6: length 52.2
  IN6 w0.099: v3(132.31,33.71) 132.49,33.89 132.67,33.89 133.01,34.23 133.01,35.64 132.53,36.12 132.53,38.86 131.94,39.45 131.94,52.18 130.37,53.75 130.37,57.69 130.07,57.98 130.07,73.75 128.99,74.83 128.34,74.83 128.02,74.51 127.7,74.51 127.54,74.67 127.1,74.67 127,74.77 127,74.9 v3(127.17,75.06)
  BOTTOM w0.089: CPU1.BA2 127.17,75.1 v3(127.17,75.06)
  BOTTOM w0.127: JDIMM1.171 132.04,37.14 133.01,36.18 133.01,34.1 132.72,33.81 132.41,33.81 v3(132.31,33.71)
DDR_A_DQS7: length 58.4
  IN6 w0.089: v3(127.15,79.13) 127.52,78.76 128.73,78.76 129.68,77.81 129.77,77.81 129.78,77.82 129.8,77.82
  IN6 w0.099: v3(138.2,33.93) 138.41,34.14 138.82,34.14 139.01,34.32 139.01,36.05 138.79,36.26 138.24,36.26 138.12,36.39 138.12,36.64 138.24,36.77 138.45,36.77 138.69,37.01 138.69,37.57 138.45,37.82 138.26,37.82 138.12,37.96 138.12,42.65 135.45,45.31 135.45,57.66 133.57,59.54 133.57,75.39 131.13,77.82 129.8,77.82
  BOTTOM w0.089: CPU1.AT3 127.15,79.03 v3(127.15,79.13)
  BOTTOM w0.127: JDIMM1.188 137.14,31.88 137.67,32.4 137.67,34.06 137.82,34.21 138.09,34.21 138.2,34.1 v3(138.2,33.93)
DDR_A_DQS#0: length 67.9
  IN6 w0.089: 90.81,83.91 91.05,83.91 91.54,83.41 93,83.41 93.09,83.32 93.1,83.32 93.43,83 v3(93.43,82.76)
  IN6 w0.099: 90.81,83.91 89.28,83.91 83.98,78.61 83.98,75.82 85.72,74.07 85.72,65 81.91,61.19 81.91,45.89 82.01,45.79 82.44,45.79 82.68,45.55 82.68,45.14 82.44,44.9 82.01,44.9 81.91,44.8 81.91,44.49 82.01,44.39 82.66,44.39 82.87,44.18 82.87,43.71 82.66,43.5 82.01,43.5 81.91,43.4 81.91,38.44 81.16,37.69 81.16,34.51 80.84,34.19 80.75,34.19 v3(80.46,33.9)
  BOTTOM w0.089: v3(93.43,82.76) 93.43,82.78 CPU1.AJ52
  BOTTOM w0.127: v3(80.46,33.9) 80.46,34.03 80.75,34.32 81.02,34.32 81.29,34.05 81.29,32.34 81.43,32.19 81.43,31.78 81.35,31.69 JDIMM1.10
DDR_A_DQS#1: length 59.5
  IN6 w0.089: 90.81,80.23 90.83,80.23 90.83,80.22 92.29,80.22 92.74,79.77 93.4,79.77 93.58,79.95 93.58,80.12 v3(93.42,80.28)
  IN6 w0.099: 90.81,80.23 90.49,80.23 89.02,78.76 89.02,65.58 89.24,65.37 89.51,65.37 89.64,65.24 89.64,64.99 89.51,64.86 89.24,64.86 89.02,64.65 89.02,64.18 89.24,63.97 89.51,63.97 89.64,63.84 89.64,62.99 89.35,62.7 89.35,61.39 90.21,60.53 90.21,48.05 87.79,45.63 87.79,40.22 85.21,37.64 85.21,35.4 85.48,35.14 85.68,35.14 v3(85.87,34.95)
  BOTTOM w0.089: v3(93.42,80.28) 93.42,80.22 CPU1.AP53
  BOTTOM w0.127: JDIMM1.27 86.45,37.51 86.14,37.2 85.56,37.2 85.12,36.75 85.12,35.44 85.36,35.19 85.62,35.19 v3(85.87,34.95)
DDR_A_DQS#2: length 52.7
  IN6 w0.089: v3(93.38,76.99) 93.28,76.99 92.9,76.61 92.52,76.61 92.33,76.41 92.33,73.73 93.98,72.08 93.98,69.96 93.99,69.96 93.99,69.94
  IN6 w0.099: v3(90.89,35.73) 90.89,35.48 90.76,35.36 90.62,35.36 90.43,35.54 90.43,37.46 93.19,40.22 93.19,42.34 94.41,43.56 94.41,63.49 94.2,63.7 93.74,63.7 93.64,63.8 93.64,64.11 93.74,64.2 94.2,64.2 94.41,64.42 94.41,64.89 94.2,65.1 93.74,65.1 93.64,65.2 93.64,65.51 93.74,65.61 94.2,65.61 94.41,65.82 94.41,69.2 93.99,69.62 93.99,69.94
  BOTTOM w0.089: v3(93.38,76.99) 93.75,76.62 CPU1.AW52
  BOTTOM w0.127: v3(90.89,35.73) 90.89,35.58 91.06,35.41 91.27,35.41 91.37,35.51 91.37,37.1 91.93,37.66 91.93,37.75 91.85,37.83 JDIMM1.45
DDR_A_DQS#3: length 51.8
  IN6 w0.089: v3(98.57,75.31) 98.4,75.14 98.16,75.14 97.99,74.96 97.99,74.5 98.38,74.1 98.38,70.56 98.58,70.37 98.58,69.96 98.57,69.96 98.57,69.94
  IN6 w0.099: v3(96.67,33.18) 96.48,33.37 96.26,33.37 96.04,33.59 96.04,35.11 96.25,35.32 96.73,35.32 96.86,35.45 96.86,35.7 96.73,35.82 96.28,35.82 96.04,36.07 96.04,36.55 96.28,36.79 96.73,36.79 96.86,36.92 96.86,38.23 97.71,39.08 97.71,59.57 98.57,60.43 98.57,63.69 98.47,63.79 97.95,63.79 97.71,64.03 97.71,64.44 97.95,64.68 98.47,64.68 98.57,64.78 98.57,65.09 98.47,65.19 98.28,65.19 98.04,65.43 98.04,65.84 98.28,66.09 98.47,66.09 98.57,66.19 98.57,69.94
  BOTTOM w0.089: v3(98.57,75.31) 98.19,75.68 CPU1.AY46
  BOTTOM w0.127: JDIMM1.62 96.94,31.57 97.09,31.71 97.09,33.32 96.98,33.43 96.78,33.43 96.67,33.33 v3(96.67,33.18)
DDR_A_DQS#4: length 48.3
  IN6 w0.089: v3(120.79,73.23) 120.63,73.07 120.45,73.07 120.22,72.84 120.22,70.49 120.41,70.31 120.41,70.02 120.4,70.02 120.4,69.96 120.4,69.95 120.4,69.94
  IN6 w0.099: v3(121.98,34.44) 121.98,34.21 122.12,34.06 122.42,34.06 122.75,34.38 122.75,35.18 122.43,35.51 122.43,47.3 122.81,47.68 122.81,49.73 121.8,50.74 121.8,66.11 120.4,67.51 120.4,69.94
  BOTTOM w0.089: CPU1.BD12 120.44,72.88 v3(120.79,73.23)
  BOTTOM w0.127: v3(121.98,34.44) 121.98,34.24 122.15,34.06 122.3,34.06 122.39,34.15 122.39,36.23 121.58,37.05 121.58,37.43 121.5,37.5 121.36,37.5 121.25,37.62 JDIMM1.135
DDR_A_DQS#5: length 46
  IN6 w0.099: v3(123.22,71.85) 123.22,71.97 123.41,72.16 123.68,72.16 123.89,71.95 123.89,70.56 126.38,68.07 126.38,56.45 126.61,56.22 126.61,37.94 127.69,36.86 127.69,35.47 127.57,35.35 127.38,35.35 127.26,35.47 127.26,35.67 v3(127.29,35.7)
  BOTTOM w0.089: v3(123.22,71.85) 123.23,71.85 CPU1.BE7
  BOTTOM w0.127: JDIMM1.152 126.34,31.69 126.46,31.81 126.46,32.01 126.54,32.09 126.54,35.17 126.89,35.52 127.15,35.52 127.29,35.66 v3(127.29,35.7)
DDR_A_DQS#6: length 52.2
  IN6 w0.099: v3(132.31,34.47) 132.31,34.23 132.45,34.09 132.59,34.09 132.81,34.31 132.81,35.55 132.33,36.04 132.33,38.78 131.74,39.37 131.74,52.1 130.17,53.67 130.17,57.6 129.87,57.9 129.87,73.66 128.9,74.63 128.42,74.63 128.1,74.32 127.62,74.32 127.46,74.48 127.02,74.48 126.81,74.69 126.81,74.77 126.51,75.07 v3(126.45,75.07)
  BOTTOM w0.089: v3(126.45,75.07) 126.45,75.08 CPU1.BA3
  BOTTOM w0.127: v3(132.31,34.47) 132.31,34.27 132.5,34.08 132.61,34.08 132.74,34.21 132.74,36.07 131.78,37.03 131.78,37.48 131.44,37.81 JDIMM1.169
DDR_A_DQS#7: length 58.5
  IN6 w0.089: 129.8,77.62 129.78,77.62 129.77,77.63 129.6,77.63 128.65,78.58 127.32,78.58 127.18,78.44 v3(127.18,78.25)
  IN6 w0.099: 129.8,77.62 131.05,77.62 133.37,75.31 133.37,59.46 135.26,57.58 135.26,45.23 137.92,42.56 137.92,37.88 138.18,37.62 138.37,37.62 138.5,37.49 138.5,37.09 138.37,36.97 138.16,36.97 137.92,36.72 137.92,36.31 138.16,36.07 138.71,36.07 138.81,35.97 138.81,34.4 138.74,34.33 138.26,34.33 138.2,34.39 v3(138.2,34.69)
  BOTTOM w0.089: CPU1.AT2 127.18,78.36 v3(127.18,78.25)
  BOTTOM w0.127: JDIMM1.186 136.54,31.6 136.88,31.94 136.88,31.99 137.03,32.14 137.4,32.51 137.4,34.17 137.71,34.48 137.99,34.48 v3(138.2,34.69)
DDR_A_MA0: length 46.6
  IN6 w0.089: v3(110.11,72.51) 110.51,72.11 110.51,69.33 109.85,68.67 109.85,68.1
  IN6 w0.155: 109.85,68.1 109.85,54.71 109.72,54.58 109.06,54.58 108.93,54.45 108.93,54.09 109.06,53.96 109.72,53.96 109.85,53.83 109.85,53.47 109.72,53.34 109.06,53.34 108.93,53.21 108.93,38.23 109.22,37.94 109.22,35.9 109.35,35.78 109.63,35.78 v3(109.69,35.84)
  BOTTOM w0.089: v3(110.11,72.51) 109.75,72.87 CPU1.BD28
  BOTTOM w0.206: JDIMM1.98 110.14,31.44 110.14,32.07 110.87,32.79 110.87,34.25 110.15,34.98 110.15,35.37 v3(109.69,35.84)
DDR_A_MA1: length 52.4
  IN6 w0.089: 110.31,68.1 110.31,68.55 110.81,69.05 110.81,73.14 110.68,73.27 v3(110.15,73.27)
  IN6 w0.155: v3(109.69,37.36) 110,37.05 110.3,37.05 110.42,37.17 110.42,38.28 110.3,38.4 109.52,38.4 109.4,38.53 109.4,39.06 109.66,39.33 109.66,39.79 109.4,40.05 109.4,45.31 109.52,45.44 110.94,45.44 111.07,45.56 111.07,45.93 110.94,46.06 109.52,46.06 109.4,46.18 109.4,46.55 109.52,46.68 110.18,46.68 110.31,46.8 110.31,47.17 110.18,47.3 109.52,47.3 109.4,47.42 109.4,47.79 109.52,47.92 110.18,47.92 110.31,48.04 110.31,48.41 110.18,48.54 109.52,48.54 109.4,48.66 109.4,49.03 109.52,49.16 110.18,49.16 110.31,49.28 110.31,49.65 110.18,49.78 109.52,49.78 109.4,49.9 109.4,50.27 109.52,50.4 110.18,50.4 110.31,50.52 110.31,50.89 110.18,51.02 109.52,51.02 109.4,51.14 109.4,51.51 109.52,51.64 110.18,51.64 110.31,51.76 110.31,52.13 110.18,52.25 109.52,52.25 109.4,52.38 109.4,52.75 109.52,52.87 110.18,52.87 110.31,53 110.31,68.1
  BOTTOM w0.089: CPU1.BD27 110.53,72.88 v3(110.15,73.27)
  BOTTOM w0.206: JDIMM1.97 109.84,37.52 v3(109.69,37.36)
DDR_A_MA2: length 50.2
  IN6 w0.089: 109.38,68.1 109.38,68.77 110.11,69.5 110.11,70.61 109.59,71.14 v3(109.39,71.14)
  IN6 w0.155: 109.38,68.1 109.38,60.13 109.25,60 108.62,60 108.47,59.85 108.47,59.54 108.62,59.38 109.25,59.38 109.38,59.26 109.38,58.89 109.25,58.76 108.62,58.76 108.47,58.61 108.47,58.3 108.62,58.14 109.25,58.14 109.38,58.02 109.38,57.65 109.25,57.52 108.59,57.52 108.47,57.4 108.47,57.03 108.59,56.9 109.23,56.9 109.38,56.75 109.38,56.44 109.23,56.28 108.59,56.28 108.47,56.16 108.47,55.79 108.59,55.66 109.23,55.66 109.38,55.51 109.38,55.17 109.25,55.04 108.59,55.04 108.47,54.92 108.47,38.04 108.76,37.75 108.76,35.71 109.02,35.45 109.02,35.13 108.76,34.87 108.76,34.62 108.88,34.49 109.51,34.49 v3(109.69,34.31)
  BOTTOM w0.089: v3(109.39,71.14) 109.39,71.14 109.4,71.14 CPU1.BF28
  BOTTOM w0.206: v3(109.69,34.31) 110.33,33.67 110.33,32.76 109.54,31.97 109.54,31.63 JDIMM1.96
DDR_A_MA3: length 51.5
  IN6 w0.089: v3(109.33,71.79) 109.23,71.79 108.78,71.34 108.78,70.26 108.86,70.18 109.68,70.18 109.79,70.07 109.79,69.69 108.9,68.8 108.9,68.11 108.92,68.1
  IN6 w0.155: 108.92,68.1 108.92,60.59 108.79,60.47 108.13,60.47 108,60.34 108,37.85 108.29,37.56 108.29,34.16 108.42,34.03 109.13,34.03 109.25,33.9 109.25,33.54 109.13,33.41 108.42,33.41 108.29,33.28 108.29,32.92 108.42,32.79 v3(109.69,32.79)
  BOTTOM w0.089: CPU1.BE28 109.72,72.18 v3(109.33,71.79)
  BOTTOM w0.206: JDIMM1.95 109.24,37.64 108.78,37.18 108.78,35.15 109.14,34.79 109.14,33.34 v3(109.69,32.79)
DDR_A_MA4: length 50.4
  IN6 w0.089: 106.96,68.1 106.96,68.25 107.61,68.9 v3(107.71,68.9)
  IN6 w0.155: 106.96,68.1 106.96,68.08 106.14,67.26 106.14,51.89 106.02,51.76 104.77,51.76 104.64,51.64 104.64,51.27 104.77,51.14 105.33,51.14 105.46,51.02 105.46,50.65 105.33,50.52 104.77,50.52 104.64,50.4 104.64,46.42 105.04,46.02 105.04,41.14 105.17,41.01 106.02,41.01 106.14,40.89 106.14,35.85 106.65,35.34 106.65,33.3 v3(107.11,32.83)
  BOTTOM w0.089: CPU1.BF32 107.31,69.3 v3(107.71,68.9)
  BOTTOM w0.206: v3(107.11,32.83) 107.69,33.41 107.69,34.53 107.87,34.71 108.14,34.71 108.34,34.51 JDIMM1.92
DDR_A_MA5: length 47.5
  IN6 w0.089: v3(110.15,73.98) 109.69,73.52 109.69,73.08 108.13,71.51 108.13,68.81 107.86,68.54 107.63,68.54 107.42,68.33 107.42,68.1
  IN6 w0.155: v3(107.11,35.88) 106.77,35.88 106.61,36.04 106.61,41.35 106.48,41.48 105.63,41.48 105.51,41.61 105.51,46.21 105.1,46.62 105.1,49.93 105.23,50.06 106.48,50.06 106.61,50.19 106.61,50.55 106.48,50.68 106.05,50.68 105.92,50.81 105.92,51.17 106.05,51.3 106.48,51.3 106.61,51.43 106.61,67.07 107.42,67.88 107.42,68.1
  BOTTOM w0.089: CPU1.BC27 110.54,73.58 v3(110.15,73.98)
  BOTTOM w0.206: v3(107.11,35.88) 108.04,36.81 JDIMM1.91
DDR_A_MA6: length 50.4
  IN6 w0.089: 108.4,68.29 108.4,68.42 108.59,68.61 108.59,69.66 108.71,69.79 v3(109.28,69.79)
  IN6 w0.155: 108.4,68.29 108.4,66.66 108.27,66.54 107.6,66.54 107.54,66.48 107.54,66.04 107.66,65.92 108.34,65.92 108.4,65.86 108.4,65.42 108.27,65.3 107.6,65.3 107.54,65.24 107.54,64.81 107.66,64.68 108.39,64.68 108.45,64.62 108.45,64.18 108.32,64.05 107.91,64.05 107.78,63.92 107.78,63.56 107.91,63.43 108.27,63.43 108.4,63.3 108.4,62.3 108.27,62.17 107.66,62.17 107.54,62.04 107.54,61.68 107.66,61.55 108.32,61.55 108.45,61.42 108.45,61.06 108.32,60.93 107.66,60.93 107.54,60.8 107.54,37.65 107.83,37.37 107.83,36.95 107.58,36.71 107.58,36.33 107.83,36.09 107.83,35.71 107.58,35.47 107.58,35.09 107.83,34.85 107.83,34.51 107.67,34.36 v3(107.11,34.36)
  BOTTOM w0.089: v3(109.28,69.79) 109.44,69.79 110.56,70.92 CPU1.BF27
  BOTTOM w0.206: JDIMM1.90 107.74,31.47 106.56,32.66 106.56,33.8 v3(107.11,34.36)
DDR_A_MA7: length 49.7
  IN6 w0.089: v3(109.31,73.26) 108.81,73.26 108.67,73.12 108.67,72.46 106.77,70.56 106.77,69.2 106.17,68.61
  IN6 w0.155: v3(105.04,36.7) 105.21,36.87 105.21,39.65 103.71,41.15 103.71,43.93 103.84,44.06 103.98,44.06 104.11,44.18 104.11,44.52 103.99,44.64 103.86,44.64 103.71,44.79 103.71,52.57 103.84,52.69 105.09,52.69 105.21,52.82 105.21,53.19 105.09,53.31 104.52,53.31 104.4,53.44 104.4,53.81 104.52,53.93 105.09,53.93 105.21,54.06 105.21,67.65 106.17,68.61
  BOTTOM w0.089: CPU1.BC28 109.43,73.26 v3(109.31,73.26)
  BOTTOM w0.206: v3(105.04,36.7) 106.05,35.69 106.05,32.35 106.54,31.85 106.54,31.77 JDIMM1.86
DDR_A_MA8: length 50.6
  IN6 w0.089: v3(110.15,71.78) 110.15,71.87 109.67,72.35 109.29,72.35 108.37,71.44 108.37,68.78 107.93,68.34 107.93,68.1
  IN6 w0.155: 107.93,68.1 107.93,67.13 107.8,67 107.2,67 107.07,66.88 107.07,49.75 106.92,49.6 105.7,49.6 105.57,49.47 105.57,49.1 105.7,48.98 106.92,48.98 107.07,48.82 107.07,48.51 106.92,48.36 105.7,48.36 105.57,48.23 105.57,47.86 105.7,47.74 106.92,47.74 107.07,47.58 107.07,47.27 106.92,47.12 105.88,47.12 105.75,46.99 105.75,46.62 105.88,46.5 106.95,46.5 107.07,46.37 107.07,45.85 106.95,45.73 106.7,45.73 106.54,45.57 106.54,45.26 106.7,45.11 106.95,45.11 107.07,44.98 107.07,44.33 106.92,44.18 106.12,44.18 105.97,44.03 105.97,43.72 106.12,43.56 106.92,43.56 107.07,43.41 107.07,42.95 106.95,42.82 106.61,42.82 106.48,42.7 106.48,42.33 106.61,42.2 106.95,42.2 107.07,42.08 107.07,37.45 v3(107.11,37.4)
  BOTTOM w0.089: CPU1.BE27 110.55,72.18 v3(110.15,71.78)
  BOTTOM w0.206: JDIMM1.89 107.44,37.73 v3(107.11,37.4)
DDR_A_MA9: length 48.9
  IN6 w0.089: 106.17,69.27 106.54,69.63 106.54,70.61 108.29,72.35 108.29,73.89 107.88,74.3 107.3,74.3 v3(106.92,73.91)
  IN6 w0.155: v3(105.04,35.17) 104.57,35.64 104.57,39.63 103.25,40.96 103.25,53.31 104.75,54.82 104.75,67.84 106.17,69.27
  BOTTOM w0.089: v3(106.92,73.91) 107.24,73.58 CPU1.BC32
  BOTTOM w0.206: v3(105.04,35.17) 104.52,35.69 104.52,36.82 104.85,37.15 105.83,37.15 106.24,37.57 JDIMM1.85
DDR_A_MA10: length 52.9
  IN6 w0.089: v3(115.09,73.21) 114.53,73.77 114.53,74.08 114.32,74.3 113.26,74.3 112.73,73.77 112.73,68.1
  IN6 w0.155: v3(113.67,32.79) 112.59,33.87 112.59,36.83 112.14,37.28 112.14,39.4 112.65,39.91 112.65,40.45 113,40.79 113,42.1 113.92,43.03 113.92,51.91 112.73,53.11 112.73,68.1
  BOTTOM w0.089: v3(115.09,73.21) 115.09,73.17 115.37,72.88 CPU1.BD20
  BOTTOM w0.206: v3(113.67,32.79) 113.16,33.3 113.16,36.54 112.84,36.85 JDIMM1.107
DDR_A_MA11: length 49
  IN6 w0.089: 106.32,68.1 107.32,69.09 107.32,69.66 v3(107.73,70.08)
  IN6 w0.155: 106.32,68.1 105.68,67.45 105.68,52.36 105.55,52.23 104.3,52.23 104.18,52.1 104.18,46.23 104.58,45.83 104.58,40.94 105.68,39.84 105.68,36.36 105.47,36.15 105.47,35.43 105.6,35.31 106.03,35.31 106.18,35.15 106.18,34.84 106.03,34.69 105.6,34.69 105.47,34.56 105.47,34.19 105.6,34.07 106.03,34.07 106.18,33.91 106.18,33.6 106.03,33.45 105.6,33.45 105.47,33.32 105.47,32.92 105.6,32.8 106.36,32.8 106.47,32.69 106.47,32.25 106.34,32.12 v3(105.04,32.12)
  BOTTOM w0.089: CPU1.BF31 108.13,70.47 v3(107.73,70.08)
  BOTTOM w0.206: JDIMM1.84 105.94,31.69 105.51,32.12 v3(105.04,32.12)
DDR_A_MA12: length 50.7
  IN6 w0.089: v3(107.73,73.94) 108.1,73.57 108.1,72.43 106.3,70.64 106.3,70.13 106.11,69.94
  IN6 w0.155: 106.11,69.94 104.28,68.11 104.28,55.01 102.78,53.51 102.78,40.76 104.11,39.44 104.11,34.58 v3(105.04,33.65)
  BOTTOM w0.089: CPU1.BC31 108.08,73.58 v3(107.73,73.94)
  BOTTOM w0.206: v3(105.04,33.65) 104.53,34.15 104.52,34.15 104.33,35.1 104.02,35.42 104.02,36.79 104.71,37.49 105.41,37.49 105.64,37.73 JDIMM1.83
DDR_A_MA13: length 52
  IN6 w0.089: v3(115.04,71.78) 115.76,71.78 115.89,71.66 115.89,69.94
  IN6 w0.155: 115.89,69.94 115.89,69.71 116.07,69.53 116.07,55.28 116.2,55.15 116.42,55.15 116.55,55.02 116.55,54.66 116.42,54.53 116.2,54.53 116.07,54.4 116.07,54.04 116.2,53.91 117.42,53.91 117.55,53.78 117.55,42.27 117.12,41.83 117.12,34.24 116.99,34.11 116.34,34.11 116.22,33.98 116.22,33.62 116.34,33.49 116.99,33.49 117.12,33.36 117.12,32.86 116.99,32.73 115.91,32.73 115.78,32.86 v3(115.78,33.05)
  BOTTOM w0.089: CPU1.BE20 115.44,72.18 v3(115.04,71.78)
  BOTTOM w0.206: v3(115.78,33.05) 116.29,33.56 116.29,34.26 116.91,34.88 116.91,37.37 116.44,37.83 JDIMM1.119
DDR_A_MA14: length 49.7
  IN6 w0.089: 105.45,69.94 106.07,70.56 106.07,71 v3(106.91,71.83)
  IN6 w0.155: 105.45,69.94 103.82,68.31 103.82,55.2 102.32,53.7 102.32,39.63 102.44,39.5 103.39,39.5 103.51,39.37 103.51,39.01 103.39,38.88 102.76,38.88 102.64,38.75 102.64,38.39 102.76,38.26 103.52,38.26 103.64,38.13 103.64,37.77 103.52,37.64 102.76,37.64 102.64,37.51 102.64,37.15 102.76,37.02 103.52,37.02 103.64,36.89 103.64,35.71 103.52,35.59 103.17,35.59 103.04,35.71 v3(103.04,35.83)
  BOTTOM w0.089: CPU1.BE32 107.26,72.18 v3(106.91,71.83)
  BOTTOM w0.206: v3(103.04,35.83) 103.51,35.36 103.51,35.03 104.08,34.46 104.08,32.35 104.74,31.68 104.74,31.5 JDIMM1.80
DDR_A_MA15: length 50.2
  IN6 w0.089: v3(107.72,72.57) 107.35,72.2 106.76,72.2 106.3,71.74 106.3,71.53 105.79,71.02 105.79,70.94 104.79,69.94
  IN6 w0.155: v3(103.04,34.3) 102.3,34.3 102.17,34.43 102.17,34.79 102.33,34.94 102.48,34.94 102.61,35.07 102.61,35.44 102.48,35.56 102.33,35.56 102.17,35.72 102.17,39 101.85,39.32 101.85,54.98 101.98,55.1 103.06,55.1 103.19,55.23 103.19,55.6 103.06,55.72 102.05,55.72 101.92,55.85 101.92,56.22 102.05,56.34 103.23,56.34 103.35,56.47 103.35,68.5 104.79,69.94
  BOTTOM w0.089: CPU1.BE31 108.1,72.18 v3(107.72,72.57)
  BOTTOM w0.206: v3(103.04,34.3) 103.57,33.77 103.57,32.16 104.14,31.58 104.14,31.38 JDIMM1.78
DDR_A_RAS#: length 51.9
  IN6 w0.089: 114.67,68.1 114.67,68.7 v3(114.96,68.99)
  IN6 w0.155: v3(113.67,35.84) 114.01,35.84 114.13,35.71 114.13,35.35 114.26,35.22 114.53,35.22 114.68,35.07 114.68,34.76 114.53,34.6 114.26,34.6 114.13,34.47 114.13,34.11 114.26,33.98 114.53,33.98 114.68,33.83 114.68,33.52 114.53,33.36 114.26,33.36 114.13,33.23 114.13,32.86 114.26,32.73 115.19,32.73 115.32,32.86 115.32,35.66 114.89,36.09 114.89,37.23 115.32,37.67 115.32,52.56 114.67,53.21 114.67,68.1
  BOTTOM w0.089: CPU1.BF20 115.52,71.4 115.52,69.95 115.38,69.81 115.38,69.41 114.96,68.99 v3(114.96,68.99)
  BOTTOM w0.206: JDIMM1.110 113.74,31.51 114.68,32.45 114.68,34.35 114.19,34.84 114.19,35.31 v3(113.67,35.84)
DDR_A_WE#: length 51.6
  IN6 w0.089: v3(115.01,69.75) 115.01,69.49 115.32,69.17 115.32,68.84 115.14,68.65 115.14,68.1
  IN6 w0.155: 115.14,68.1 115.14,53.4 115.78,52.76 115.78,50.63 115.91,50.5 116.5,50.5 116.62,50.37 116.62,50.01 116.5,49.88 115.91,49.88 115.78,49.75 115.78,49.39 115.91,49.26 116.5,49.26 116.62,49.13 116.62,48.77 116.5,48.64 115.91,48.64 115.78,48.51 115.78,48.15 115.91,48.02 116.5,48.02 116.62,47.89 116.62,47.53 116.5,47.4 115.91,47.4 115.78,47.27 115.78,46.94 115.94,46.78 116.5,46.78 116.62,46.66 116.62,46.29 116.5,46.16 115.94,46.16 115.78,46.01 115.78,45.7 115.94,45.54 116.5,45.54 116.62,45.42 116.62,45.05 116.5,44.92 115.94,44.92 115.78,44.77 115.78,44.46 115.94,44.3 116.5,44.3 116.62,44.18 116.62,43.81 116.5,43.68 115.94,43.68 115.78,43.53 115.78,43.22 115.94,43.06 116.41,43.06 116.54,42.94 116.54,42.57 116.41,42.44 115.94,42.44 115.78,42.29 115.78,41.91 115.94,41.75 116.06,41.75 116.19,41.62 116.19,41.26 116.06,41.13 115.94,41.13 115.78,40.98 115.78,40.67 115.94,40.51 116.06,40.51 116.19,40.38 116.19,40.02 116.06,39.89 115.94,39.89 115.78,39.74 115.78,39.43 115.94,39.27 116.06,39.27 116.19,39.14 116.19,38.78 116.06,38.65 115.91,38.65 115.78,38.52 115.78,38.16 115.91,38.03 116.06,38.03 116.19,37.9 116.19,37.54 116.06,37.41 115.72,37.41 115.35,37.04 115.35,36.29 115.54,36.1 v3(115.78,36.1)
  BOTTOM w0.089: v3(115.01,69.75) 115.33,70.08 115.33,71.15 115.15,71.34 114.78,71.34 CPU1.BF21
  BOTTOM w0.206: v3(115.78,36.1) 114.64,37.24 JDIMM1.113
DDR_B_BS0: length 67.8
  IN1 w0.089: v3(112.71,75.4) 112.64,75.32 112.64,68.82 113.01,68.46 113.01,68.1
  IN1 w0.155: v3(113.73,24.28) 114.11,24.28 114.23,24.17 114.23,21.55 114.35,21.43 114.72,21.43 114.85,21.55 114.85,28.92 115.03,29.1 115.03,30.59 115.19,30.75 115.62,30.75 115.75,30.87 115.75,31.24 115.62,31.37 115.19,31.37 115.03,31.52 115.03,31.83 115.19,31.99 115.62,31.99 115.75,32.11 115.75,32.48 115.62,32.61 115.19,32.61 115.03,32.76 115.03,37.17 115.16,37.3 115.62,37.3 115.75,37.43 115.75,37.79 115.62,37.92 115.16,37.92 115.03,38.05 115.03,38.41 115.16,38.54 115.62,38.54 115.75,38.67 115.75,39.03 115.62,39.16 115.16,39.16 115.03,39.29 115.03,39.65 115.16,39.78 115.62,39.78 115.75,39.91 115.75,40.27 115.62,40.4 115.16,40.4 115.03,40.53 115.03,40.89 115.16,41.02 115.62,41.02 115.75,41.15 115.75,41.51 115.62,41.64 115.16,41.64 115.03,41.77 115.03,46.09 113.01,48.12 113.01,68.1
  BOTTOM w0.089: v3(112.71,75.4) 113,75.68 CPU1.AY23
  BOTTOM w0.206: v3(113.73,24.28) 113.45,24.56 JDIMM2.109
DDR_B_BS1: length 68
  IN1 w0.089: 113.51,68.1 113.51,68.32 112.83,69 112.83,71.22 112.83,71.23 112.83,74.69 v3(113.47,75.34)
  IN1 w0.155: v3(113.73,20.47) 113.73,20.7 113.86,20.82 114.37,20.82 114.49,20.7 114.49,20.4 114.62,20.27 115.18,20.27 115.31,20.4 115.31,24.54 115.47,24.69 115.96,24.69 116.08,24.82 116.08,25.19 115.96,25.31 115.47,25.31 115.31,25.47 115.31,25.78 115.47,25.93 115.96,25.93 116.08,26.06 116.08,26.42 115.96,26.55 115.47,26.55 115.31,26.71 115.31,27.44 115.44,27.57 115.97,27.57 116.08,27.68 116.08,28.06 115.96,28.19 115.44,28.19 115.31,28.32 115.31,28.68 115.44,28.81 115.97,28.81 116.08,28.92 116.08,29.3 115.96,29.43 115.61,29.43 115.5,29.54 115.5,30.04 115.62,30.17 116.09,30.17 116.22,30.3 116.22,41.81 115.5,42.53 115.5,46.29 113.51,48.27 113.51,68.1
  BOTTOM w0.089: CPU1.BA23 113.12,75.11 113.35,75.34 v3(113.47,75.34)
  BOTTOM w0.206: JDIMM2.108 113.15,19.89 v3(113.73,20.47)
DDR_B_BS2: length 64.9
  IN1 w0.089: v3(104.21,75.4) 102.97,74.15 102.97,70.46 102.9,70.39 102.9,69.94
  IN1 w0.155: 102.9,69.94 102.9,66.04 102.47,65.61 102.47,50.76 102.35,50.63 101.45,50.63 101.32,50.51 101.32,50.14 101.45,50.01 102.35,50.01 102.47,49.89 102.47,49.52 102.35,49.39 101.45,49.39 101.32,49.27 101.32,38.57 101.22,38.47 101.22,26.79 103.13,24.88 103.13,21.68 v3(103.59,21.22)
  BOTTOM w0.089: v3(104.21,75.4) 104.63,74.98 CPU1.BA36
  BOTTOM w0.206: JDIMM2.79 104.45,24.78 103.06,23.4 103.06,21.75 v3(103.59,21.22)
DDR_B_CAS#: length 70.4
  IN1 w0.089: v3(114.58,76.78) 114.11,76.31 114.11,74.51 113.77,74.17 113.77,71.31 114.08,71 114.08,68.79 114.49,68.38 114.49,68.1
  IN1 w0.155: v3(115.78,21.59) 116.5,21.59 117.01,22.11 117.01,29.21 117.14,29.34 117.4,29.34 117.53,29.46 117.53,29.83 117.4,29.96 117.27,29.96 117.15,30.08 117.15,30.45 117.27,30.58 117.59,30.58 117.71,30.7 117.71,31.07 117.59,31.2 117.27,31.2 117.15,31.32 117.15,31.69 117.27,31.82 117.59,31.82 117.71,31.94 117.71,32.31 117.59,32.43 117.27,32.43 117.15,32.56 117.15,37.69 117.27,37.81 117.59,37.81 117.71,37.94 117.71,38.32 117.59,38.44 117.27,38.44 117.15,38.57 117.15,38.95 117.27,39.08 117.59,39.08 117.71,39.21 117.71,39.63 117.59,39.76 117.27,39.76 117.15,39.89 117.15,42.2 116.42,42.92 116.42,48.9 116.24,49.08 114.62,49.08 114.49,49.2 114.49,49.57 114.62,49.7 115.51,49.7 115.64,49.82 115.64,50.19 115.51,50.31 114.62,50.31 114.49,50.44 114.49,68.1
  BOTTOM w0.089: v3(114.58,76.78) 114.89,77.08 CPU1.AV20
  BOTTOM w0.206: JDIMM2.115 115.25,24.59 115.47,24.37 115.91,24.37 116.3,23.98 116.3,22.11 v3(115.78,21.59)
DDR_B_D0: length 82.9
  IN1 w0.089: 90.81,87.28 90.97,87.44 v3(91.94,87.44)
  IN1 w0.099: v3(78.69,23.8) 77.09,25.4 77.09,31.01 75.44,32.66 75.44,38.02 75.57,38.14 76,38.14 76.12,38.27 76.12,38.52 76,38.65 75.54,38.65 75.44,38.75 75.44,39.03 75.57,39.15 76.8,39.15 76.9,39.25 76.9,39.53 76.77,39.66 75.54,39.66 75.44,39.76 75.44,40.04 75.57,40.16 76.8,40.16 76.9,40.26 76.9,40.54 76.77,40.67 75.57,40.67 75.44,40.8 75.44,41.05 75.57,41.18 76.69,41.18 76.82,41.3 76.82,43.32 80.48,46.98 80.48,61.23 84.53,65.28 84.53,67.49 86.32,69.27 86.32,71.56 88.47,73.72 88.47,84.94 90.81,87.28
  BOTTOM w0.089: v3(91.94,87.44) 92.2,87.19 CPU1.AC54
  BOTTOM w0.127: JDIMM2.5 79.85,24.14 79.51,23.8 v3(78.69,23.8)
DDR_B_D1: length 84.6
  IN1 w0.089: 90.81,86.73 91.07,87 92.37,87 92.57,87.2 93.67,87.2 v3(94.08,87.61)
  IN1 w0.099: v3(78.69,22.28) 79.1,22.68 79.1,25.01 77.47,26.63 77.47,31.78 75.76,33.49 75.76,37.48 77.53,39.26 77.53,43.61 78.38,44.46 78.52,44.46 78.93,44.04 79.07,44.04 79.29,44.26 79.29,44.4 78.88,44.81 78.88,44.95 79.09,45.17 79.23,45.17 79.65,44.76 79.79,44.76 80,44.98 80,45.12 79.59,45.53 79.59,45.67 79.81,45.89 79.95,45.89 80.36,45.48 80.5,45.48 80.72,45.69 80.72,45.83 80.31,46.25 80.31,46.39 80.77,46.85 80.77,61.1 84.85,65.18 84.85,67.38 86.61,69.15 86.61,71.44 88.8,73.63 88.8,84.72 90.81,86.73
  BOTTOM w0.089: CPU1.AC52 93.77,87.3 v3(94.08,87.61)
  BOTTOM w0.127: JDIMM2.7 80.45,24.24 80.01,23.8 80.01,23.6 v3(78.69,22.28)
DDR_B_D2: length 85.5
  IN1 w0.089: v3(94.16,86) 94.16,86.26 94.04,86.39 93.41,86.39 93.28,86.26 93.28,86 92.84,85.56 92.59,85.56 91.98,84.96 91.74,84.96 90.94,84.15 90.94,84.04 90.81,83.91
  IN1 w0.099: 90.81,83.91 90.34,83.44 90.34,72.98 88.12,70.76 88.12,68.52 86.48,66.88 86.48,64.12 82.28,59.93 82.28,45.01 81.09,43.83 81.09,42.77 81.19,42.67 81.68,42.67 81.81,42.54 81.81,42.29 81.68,42.16 81.22,42.16 81.09,42.03 81.09,41.78 81.22,41.66 81.51,41.66 81.61,41.56 81.61,40.19 81.14,39.72 81,39.72 80.28,40.44 80.1,40.44 79.92,40.26 79.92,40.08 80.64,39.36 80.64,39.22 80.47,39.05 80.33,39.05 79.9,39.48 79.72,39.48 79.54,39.31 79.54,39.13 79.97,38.69 79.97,38.55 79.42,38 79.42,28.11 79.79,27.74 79.79,27.67 79.42,27.3 79.42,27.12 79.6,26.94 79.78,26.94 80.16,27.32 80.34,27.32 80.52,27.14 80.52,26.96 80.02,26.45 80.02,26.31 80.23,26.09 80.37,26.09 80.87,26.59 81.01,26.59 81.23,26.37 81.23,26.23 80.73,25.74 80.73,25.6 80.95,25.38 81.09,25.38 81.58,25.87 81.73,25.87 81.94,25.66 81.94,25.52 81.45,25.02 81.45,24.88 82,24.33 v3(82,23.86)
  BOTTOM w0.089: CPU1.AE51 94.17,85.86 94.17,85.99 v3(94.16,86)
  BOTTOM w0.127: JDIMM2.15 82.85,24.52 83.07,24.31 83.07,23.35 82.91,23.2 82.67,23.2 v3(82,23.86)
DDR_B_D3: length 84
  IN1 w0.089: 90.81,84.66 91.47,85.32 91.47,85.6 91.83,85.96 v3(92.07,85.96)
  IN1 w0.099: 90.81,84.66 90.03,83.89 90.03,73.12 87.82,70.9 87.82,68.65 86.06,66.89 86.06,64.17 81.98,60.09 81.98,45.14 80.69,43.84 80.69,43 80.59,42.9 79.75,42.9 79.62,42.78 79.62,42.52 79.75,42.4 80.67,42.4 80.79,42.27 80.79,42.02 80.67,41.89 79.21,41.89 79.08,41.77 79.08,41.51 79.21,41.39 81.06,41.39 81.19,41.26 81.19,41.01 81.06,40.88 79.37,40.88 79.24,40.75 79.24,40.21 79.14,40.11 78.84,40.11 78.74,40.01 78.74,39.7 78.84,39.6 79.14,39.6 79.24,39.5 79.24,38.5 79.13,38.38 79.13,26.69 81.59,24.23 81.59,22.75 v3(82,22.34)
  BOTTOM w0.089: v3(92.07,85.96) 92.08,85.95 92.37,85.66 CPU1.AE54
  BOTTOM w0.127: v3(82,22.34) 82.67,21.67 83.24,21.67 83.45,21.88 JDIMM2.17
DDR_B_D4: length 84.4
  IN1 w0.089: 90.81,87.67 90.95,87.67 91.08,87.8 92.51,87.8 v3(92.72,87.59)
  IN1 w0.099: 90.81,87.67 90.72,87.67 88.15,85.1 88.15,73.92 86.02,71.78 86.02,69.39 84.24,67.61 84.24,65.41 80.18,61.35 80.18,47.1 76.52,43.44 76.52,42.61 76.42,42.51 75.59,42.51 75.47,42.39 75.47,42.14 75.59,42.01 76.33,42.01 76.46,41.88 76.46,41.62 76.33,41.49 75.22,41.49 75.12,41.39 75.12,32.56 76.52,31.16 76.52,24.16 78.29,22.39 78.29,21.16 v3(78.69,20.75)
  BOTTOM w0.089: v3(92.72,87.59) 93.07,87.24 CPU1.AC53
  BOTTOM w0.127: v3(78.69,20.75) 78.23,20.3 78.23,18.95 78.41,18.77 79.3,18.77 79.55,18.52 79.55,18.37 JDIMM2.4
DDR_B_D5: length 85.8
  IN1 w0.089: 90.81,87.99 94.41,87.99 94.78,87.62 v3(94.78,87.6)
  IN1 w0.099: v3(78.69,19.23) 77.78,20.14 76.76,20.14 75.57,21.34 75.57,26.11 76.22,26.76 76.22,31.04 74.83,32.44 74.83,42.16 79.88,47.22 79.88,61.47 83.94,65.53 83.94,67.73 85.72,69.52 85.72,71.95 87.82,74.05 87.82,85.36 90.46,87.99 90.81,87.99
  BOTTOM w0.089: CPU1.AC51 94.47,87.29 v3(94.78,87.6)
  BOTTOM w0.127: v3(78.69,19.23) 79.64,19.23 80.15,18.72 JDIMM2.6
DDR_B_D6: length 84.8
  IN1 w0.089: v3(94.17,85.18) 92.94,83.95 92.94,83.95 92.27,83.28 92.27,81.6 92.38,81.49 92.38,80.81 92.33,80.76 92.33,80.15 90.96,78.78 90.96,72.61 90.81,72.46
  IN1 w0.099: v3(82,19.29) 82.93,20.22 82.93,20.66 83.06,20.78 83.82,20.78 83.95,20.91 83.95,21.16 83.82,21.29 83.01,21.29 82.88,21.42 82.88,21.67 83.01,21.8 84.07,21.8 84.19,21.92 84.19,22.17 84.07,22.3 83.01,22.3 82.88,22.43 82.88,22.68 83.01,22.81 83.7,22.81 83.82,22.93 83.82,23.18 83.7,23.31 83.01,23.31 82.88,23.44 82.88,23.69 83.01,23.82 83.7,23.82 83.82,23.94 83.82,24.2 83.7,24.32 83.06,24.32 82.93,24.45 82.93,25.42 82.92,25.43 82.92,25.61 81.6,26.93 81.6,29.68 80.06,31.22 80.06,37.43 82.52,39.89 82.52,41.6 82.93,42.01 82.93,56.34 82.87,56.4 82.87,59.6 87.44,64.17 87.44,67.01 88.71,68.28 88.71,70.37 90.81,72.46
  BOTTOM w0.089: v3(94.17,85.18) 93.79,85.56 CPU1.AE52
  BOTTOM w0.127: JDIMM2.16 83.15,19.63 82.94,19.84 82.75,19.84 82.19,19.29 v3(82,19.29)
DDR_B_D7: length 84.4
  IN1 w0.089: 90.81,83.35 91.59,84.14 91.59,84.43 91.9,84.74 92.3,84.74 v3(92.74,85.18)
  IN1 w0.099: 90.81,83.35 90.64,83.19 90.64,72.81 88.41,70.58 88.41,68.4 86.9,66.88 86.9,64.07 82.58,59.75 82.58,44.89 82.11,44.42 82.11,44.04 82.01,43.94 81.7,43.94 81.6,43.85 81.6,43.54 81.7,43.44 82.01,43.44 82.11,43.34 82.11,39.97 79.72,37.58 79.72,30.76 79.82,30.66 80.2,30.66 80.33,30.53 80.33,30.28 80.2,30.15 79.82,30.15 79.72,30.05 79.72,29.75 79.82,29.65 81.18,29.65 81.3,29.52 81.3,29.26 81.18,29.14 79.85,29.14 79.72,29.01 79.72,28.76 79.85,28.63 81.18,28.63 81.3,28.5 81.3,28.24 81.18,28.12 80.4,28.12 80.28,27.99 80.28,27.74 80.4,27.61 81.18,27.61 81.3,27.48 81.3,26.81 82.59,25.53 82.59,21.4 v3(82,20.81)
  BOTTOM w0.089: CPU1.AE53 93.07,85.5 v3(92.74,85.18)
  BOTTOM w0.127: JDIMM2.18 83.75,20.55 83.49,20.81 83.22,20.81 82.71,20.3 82.51,20.3 v3(82,20.81)
