# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D8: length 72.7
  IN1 w0.089: v3(96.74,78.19) 96.74,78.19 96.25,78.68 96.25,78.86 95.98,79.13 92.86,79.13 92.85,79.14 91.78,79.14 91.23,78.59 91.23,72.17 90.81,71.75
  IN1 w0.099: 90.81,71.75 89.24,70.18 89.24,68.09 87.95,66.8 87.95,63.96 83.38,59.39 83.38,56.6 83.44,56.55 83.44,41.8 83.02,41.39 83.02,39.68 81.09,37.74 81.09,30.92 82.75,29.26 82.75,26.49 84.33,24.92 84.33,22.75 v3(84.75,22.34)
  BOTTOM w0.089: CPU1.AU47 97.14,77.79 v3(96.74,78.19)
  BOTTOM w0.127: JDIMM2.21 84.65,24.63 84.2,24.18 84.2,22.88 v3(84.75,22.34)
DDR_B_D9: length 71.7
  IN1 w0.089: 90.81,71.33 91.42,71.94 91.42,78.11 91.69,78.38 92.41,78.38 92.53,78.26 95.64,78.26 v3(95.73,78.17)
  IN1 w0.099: 90.81,71.33 89.54,70.06 89.54,67.97 88.25,66.68 88.25,59.89 88.93,59.21 88.93,57.2 84.31,52.58 84.31,48.24 84.21,48.15 84.14,48.15 84.01,48.02 84.01,47.77 84.14,47.64 84.21,47.64 84.31,47.54 84.31,47.18 84.21,47.08 83.86,47.08 83.76,46.98 83.76,46.67 83.86,46.57 84.21,46.57 84.31,46.48 84.31,46.17 84.21,46.07 83.86,46.07 83.76,45.97 83.76,45.66 83.86,45.56 84.21,45.56 84.31,45.46 84.31,45.16 84.21,45.06 83.86,45.06 83.76,44.96 83.76,44.65 83.86,44.55 84.21,44.55 84.31,44.45 84.31,44.15 84.21,44.05 83.86,44.05 83.76,43.95 83.76,43.64 83.86,43.54 84.21,43.54 84.31,43.44 84.31,43.14 84.21,43.04 83.86,43.04 83.76,42.94 83.76,41.7 83.42,41.36 83.42,39.65 81.38,37.62 81.38,31.05 83.05,29.38 83.05,26.62 84.75,24.92 v3(84.75,23.86)
  BOTTOM w0.089: v3(95.73,78.17) 95.82,78.17 CPU1.AU49
  BOTTOM w0.127: JDIMM2.23 85.25,24.36 v3(84.75,23.86)
DDR_B_D10: length 74.9
  IN1 w0.089: v3(99.53,77.46) 99.13,77.06 98.43,77.06 98.15,76.78 97.07,76.78 97.01,76.71 97.01,76.71 96.8,76.5 96.8,76.5 96.78,76.48 96.38,76.48 96.08,76.18 96.08,76.02 96.08,75.74 95.83,75.48 95.46,75.48 94.05,74.07 94.05,72.73 93.22,71.91 93.22,71.18 91.97,69.94
  IN1 w0.099: 91.97,69.94 91.39,69.36 91.39,65.86 90.15,64.61 90.15,60.66 90.73,60.08 90.73,56.18 87.63,53.09 87.63,52.61 87.53,52.51 87.12,52.51 87,52.39 87,52.14 87.12,52.01 87.53,52.01 87.63,51.91 87.63,51.6 87.53,51.5 87.12,51.5 87,51.38 87,51.12 87.12,51 87.53,51 87.63,50.9 87.63,50.59 87.53,50.49 87.03,50.49 86.93,50.39 86.93,50.09 87.03,49.99 87.53,49.99 87.63,49.89 87.63,49.58 87.53,49.48 87.03,49.48 86.93,49.38 86.93,49.08 87.03,48.98 87.53,48.98 87.63,48.88 87.63,48.57 87.53,48.47 87.03,48.47 86.93,48.37 86.93,48.06 87.03,47.97 87.53,47.97 87.63,47.87 87.63,47.56 87.53,47.46 87.03,47.46 86.93,47.36 86.93,47.05 87.03,46.95 87.53,46.95 87.63,46.86 87.63,46.55 87.53,46.45 87.03,46.45 86.93,46.35 86.93,41.14 86.7,40.91 86.7,40.1 83.76,37.15 83.76,31.22 85.6,29.38 85.6,26.64 88.08,24.17 88.08,23.65 87.95,23.52 87.57,23.52 87.44,23.65 v3(87.44,23.86)
  BOTTOM w0.089: v3(99.53,77.46) 99.91,77.08 CPU1.AV43
  BOTTOM w0.127: v3(87.44,23.86) 88.25,24.67 JDIMM2.33
DDR_B_D11: length 73.6
  IN1 w0.089: 92.39,69.94 93.45,70.99 93.45,71.65 94.88,73.08 94.88,74.52 95.58,75.23 95.91,75.23 96.27,75.59 96.27,76.1 96.46,76.29 96.9,76.29 97.2,76.59 98.51,76.59 v3(98.58,76.66)
  IN1 w0.099: v3(87.44,22.34) 88.52,23.41 88.52,24.15 86.49,26.18 86.49,29.27 84.85,30.9 84.85,37.34 87.7,40.18 87.7,41.23 87.61,41.31 87.47,41.31 87.38,41.4 87.38,41.82 87.51,41.95 87.89,41.95 88.01,42.07 88.01,42.38 87.89,42.5 87.35,42.5 87.25,42.6 87.25,42.91 87.35,43.01 87.85,43.01 87.95,43.11 87.95,43.41 87.85,43.51 87.35,43.51 87.25,43.61 87.25,43.92 87.35,44.02 87.85,44.02 87.95,44.12 87.95,44.43 87.85,44.52 87.35,44.52 87.25,44.62 87.25,44.93 87.35,45.03 87.85,45.03 87.95,45.13 87.95,45.44 87.85,45.54 87.35,45.54 87.25,45.63 87.25,45.94 87.35,46.04 87.85,46.04 87.95,46.14 87.95,52.98 91.03,56.06 91.03,60.2 90.45,60.79 90.45,64.49 91.69,65.74 91.69,69.24 92.39,69.94
  BOTTOM w0.089: v3(98.58,76.66) 98.58,76.64 CPU1.AV45
  BOTTOM w0.127: JDIMM2.35 88.85,24.61 88.08,23.84 88.08,22.97 v3(87.44,22.34)
DDR_B_D12: length 73.9
  IN1 w0.089: v3(99.54,78.17) 99.16,77.79 98.35,77.79 98.17,77.97 97.39,77.97 97.04,77.62 95.38,77.62 95.14,77.38 95.14,76.72 94.23,75.8 93.34,75.8 93.1,75.56 93.1,75.02 92.44,74.36 92.44,71.66 91.27,70.48 90.81,70.48
  IN1 w0.099: 90.81,70.48 90.13,69.81 90.13,67.72 88.9,66.49 88.9,60.2 89.52,59.58 89.52,56.68 85.71,52.87 85.71,52.86 85.01,52.16 85.01,49.41 85.11,49.31 85.22,49.31 85.35,49.19 85.35,48.93 85.22,48.81 85.11,48.81 85.01,48.71 85.01,40.18 82.55,37.72 82.55,30.72 83.64,29.63 83.64,26.89 85.66,24.88 85.66,20.2 v3(84.75,19.29)
  BOTTOM w0.089: v3(99.54,78.17) 99.93,77.78 CPU1.AU43
  BOTTOM w0.127: v3(84.75,19.29) 84.95,19.08 JDIMM2.22
DDR_B_D13: length 75.1
  IN1 w0.089: v3(98.55,78.16) 97.32,78.16 96.96,77.81 95.3,77.81 94.97,77.48 94.04,77.48 93.93,77.36 92.47,77.36 92.25,77.14 92.25,72.34 90.81,70.9
  IN1 w0.099: v3(84.75,20.81) 85.15,21.22 85.15,24.97 83.35,26.77 83.35,29.5 81.68,31.17 81.68,37.5 82.45,38.27 82.67,38.27 84.33,39.92 84.33,40.53 84.14,40.73 84.14,41.03 84.24,41.13 84.58,41.13 84.71,41.26 84.71,41.51 84.58,41.64 84.24,41.64 84.14,41.74 84.14,42.04 84.24,42.14 84.54,42.14 84.61,42.21 84.61,52.19 89.23,56.81 89.23,59.46 88.55,60.14 88.55,66.55 89.84,67.84 89.84,69.93 90.81,70.9
  BOTTOM w0.089: v3(98.55,78.16) 98.93,77.78 CPU1.AU45
  BOTTOM w0.127: v3(84.75,20.81) 85.55,20.01 JDIMM2.24
DDR_B_D14: length 71.8
  IN1 w0.089: 93.6,69.94 93.6,70.13 93.98,70.51 93.98,71.53 96.03,73.58 97.43,73.58 97.6,73.75 97.6,74.19 98.05,74.64 98.05,75.78 v3(97.6,76.22)
  IN1 w0.099: 93.6,69.94 93.6,69.56 92.29,68.24 92.29,65.49 91.04,64.24 91.04,61.07 91.62,60.49 91.62,55.81 89.47,53.67 89.47,50.99 89.37,50.9 88.75,50.9 88.65,50.8 88.65,50.49 88.75,50.39 89.37,50.39 89.47,50.29 89.47,49.98 89.37,49.88 88.75,49.88 88.65,49.79 88.65,45.62 89.47,44.79 89.47,41.79 88.29,40.61 88.29,39.94 85.46,37.11 85.46,31.14 87.1,29.49 87.1,26.44 89.19,24.35 89.19,21.04 v3(87.44,19.29)
  BOTTOM w0.089: v3(97.6,76.22) 97.6,76.62 CPU1.AV47
  BOTTOM w0.127: v3(87.44,19.29) 87.7,19.29 88.55,18.43 JDIMM2.34
DDR_B_D15: length 70.9
  IN1 w0.089: v3(96.71,75.91) 96.71,75.91 96.71,75.91 97.03,75.59 97.03,75.14 96.22,74.34 95.95,74.34 95.63,74.02 95.63,73.56 93.64,71.57 93.64,70.76 92.81,69.94
  IN1 w0.099: v3(87.44,20.81) 88.81,22.19 88.81,24.27 86.81,26.28 86.81,29.37 85.16,31.01 85.16,37.23 87.99,40.06 87.99,40.73 89.09,41.83 89.09,44.6 88.33,45.36 88.33,51.11 88.43,51.21 88.84,51.21 88.97,51.34 88.97,51.59 88.84,51.72 88.43,51.72 88.33,51.82 88.33,52.13 88.43,52.23 88.97,52.23 89.09,52.35 89.09,52.61 88.97,52.73 88.71,52.73 88.58,52.86 88.58,53.11 88.71,53.24 88.99,53.24 89.09,53.34 89.09,53.7 91.33,55.94 91.33,60.33 90.74,60.91 90.74,64.37 91.99,65.61 91.99,69.11 92.81,69.94
  BOTTOM w0.089: CPU1.AV49 96.2,76.79 96.28,76.71 96.29,76.71 96.31,76.68 96.33,76.68 96.5,76.51 96.5,76.5 96.53,76.5 96.71,76.32 96.71,75.91 v3(96.71,75.91)
  BOTTOM w0.127: JDIMM2.36 89.15,19.1 v3(87.44,20.81)
DDR_B_D16: length 68.2
  IN1 w0.089: v3(96.31,73.19) 95.86,72.74 95.46,72.74 94.17,71.45 94.17,69.94
  IN1 w0.099: 94.17,69.94 94.17,69.42 92.79,68.03 92.79,65.28 92.13,64.62 92.13,55.58 89.98,53.43 89.98,49.62 89.15,48.79 89.15,45.88 89.98,45.05 89.98,41.58 89.98,41.58 89.98,41.57 88.8,40.4 88.8,39.73 86.45,37.38 86.45,30.86 87.61,29.7 87.61,26.65 89.7,24.56 89.7,19.69 v3(90.1,19.29)
  BOTTOM w0.089: v3(96.31,73.19) 95.92,73.58 CPU1.BC49
  BOTTOM w0.127: v3(90.1,19.29) 89.73,19.85 89.22,21.3 89.22,24.22 89.63,24.63 89.81,24.63 90.05,24.87 JDIMM2.39
DDR_B_D17: length 64.7
  IN1 w0.099: v3(90.1,20.81) 90.86,21.57 90.86,24.66 89.19,26.33 89.19,29.55 87.86,30.88 87.86,37.43 90.25,39.82 90.25,40.27 91.44,41.47 91.44,47.5 91.54,47.6 92.23,47.6 92.33,47.7 92.33,48.01 92.23,48.11 91.54,48.11 91.44,48.21 91.44,48.51 91.54,48.61 91.82,48.61 91.95,48.74 91.95,48.99 91.82,49.12 91.54,49.12 91.44,49.22 91.44,52.59 93.02,54.17 93.02,64.25 93.68,64.91 93.68,67.66 95.06,69.05 95.06,70.19 95.75,70.87 95.75,71.32 v3(96.32,71.89)
  BOTTOM w0.089: CPU1.BE49 96.02,72.18 v3(96.32,71.89)
  BOTTOM w0.127: v3(90.1,20.81) 89.6,21.32 89.6,24.09 89.79,24.28 89.95,24.28 90.65,24.98 JDIMM2.41
DDR_B_D18: length 68.3
  IN1 w0.089: 96.58,69.94 96.58,70.35 96.81,70.58 97.28,70.58 97.57,70.88 97.57,73.18 97.67,73.27 v3(97.97,73.27)
  IN1 w0.099: v3(93.08,23.86) 93.09,23.88 93.09,24.64 90.72,27.01 90.72,27.91 90.82,28.01 91.53,28.01 91.63,28.11 91.63,28.42 91.53,28.52 90.82,28.52 90.72,28.62 90.72,28.92 90.82,29.02 91.53,29.02 91.63,29.12 91.63,29.43 91.53,29.53 90.82,29.53 90.72,29.63 90.72,29.94 90.82,30.03 91.53,30.03 91.63,30.13 91.63,30.44 91.53,30.54 90.82,30.54 89.85,31.51 89.85,37.3 92,39.45 92.14,39.45 92.41,39.18 92.55,39.18 92.77,39.39 92.77,39.53 92.5,39.81 92.5,39.95 92.72,40.16 92.86,40.16 93.13,39.89 93.27,39.89 93.49,40.11 93.49,40.25 93.21,40.52 93.21,40.66 93.43,40.88 93.57,40.88 93.84,40.61 93.98,40.61 94.2,40.82 94.2,40.96 93.93,41.24 93.93,41.38 94.09,41.54 94.09,42.39 94.19,42.49 94.52,42.49 94.62,42.59 94.62,42.9 94.52,43 94.19,43 94.09,43.1 94.09,43.4 94.19,43.5 94.52,43.5 94.62,43.6 94.62,43.91 94.52,44.01 94.19,44.01 94.09,44.11 94.09,44.41 94.19,44.51 94.52,44.51 94.62,44.61 94.62,44.92 94.52,45.02 94.19,45.02 94.09,45.12 94.09,45.43 94.19,45.52 94.52,45.52 94.62,45.62 94.62,45.93 94.52,46.03 94.19,46.03 94.09,46.13 94.09,46.44 94.19,46.54 94.52,46.54 94.66,46.68 94.66,63.76 95.19,64.29 95.19,66.91 96.58,68.3 96.58,69.94
  BOTTOM w0.089: v3(97.97,73.27) 97.58,72.88 CPU1.BD47
  BOTTOM w0.127: v3(93.08,23.86) 93.65,24.43 JDIMM2.51
DDR_B_D19: length 69.3
  IN1 w0.089: v3(97.97,73.92) 98.33,73.56 98.33,71.1 97.25,70.01 97.25,69.94
  IN1 w0.099: 97.25,69.94 97.25,68.13 95.78,66.66 95.78,64.04 95.25,63.51 95.25,40.67 91.82,37.24 91.82,31.91 91.72,31.81 90.97,31.81 90.87,31.71 90.87,31.4 90.97,31.31 91.72,31.31 92.9,30.13 92.9,28.69 92.78,28.56 92.37,28.56 92.27,28.46 92.27,28.15 92.37,28.05 93.18,28.05 93.28,27.95 93.28,26.6 93.18,26.5 92.81,26.5 92.71,26.4 92.71,26.1 92.81,26 93.18,26 94.44,24.74 94.44,24.48 94.34,24.38 93.95,24.38 93.86,24.28 93.86,23.97 93.95,23.87 94.34,23.87 94.44,23.77 94.44,23.47 94.34,23.37 93.95,23.37 93.86,23.27 93.86,22.96 93.95,22.86 94.34,22.86 94.44,22.76 94.44,22.17 v3(93.08,20.81)
  BOTTOM w0.089: CPU1.BC47 97.56,73.61 97.87,73.92 v3(97.97,73.92)
  BOTTOM w0.127: v3(93.08,20.81) 94.25,21.99 JDIMM2.53
DDR_B_D20: length 67.1
  IN1 w0.099: v3(90.1,22.34) 90.57,22.8 90.57,24.54 88.89,26.21 88.89,29.42 87.56,30.76 87.56,37.55 89.95,39.94 89.95,40.4 90.58,41.02 90.58,44.15 90.67,44.25 91,44.25 91.12,44.38 91.12,44.63 91,44.75 90.67,44.75 90.58,44.85 90.58,45.16 90.67,45.26 91,45.26 91.12,45.39 91.12,45.64 91,45.77 90.67,45.77 90.58,45.86 90.58,46.39 90.67,46.49 91.03,46.49 91.12,46.59 91.12,46.89 91.03,46.99 90.67,46.99 90.58,47.09 90.58,47.4 90.67,47.5 91.03,47.5 91.12,47.6 91.12,47.91 91.03,48 90.67,48 90.58,48.1 90.58,48.41 90.67,48.51 91.03,48.51 91.12,48.61 91.12,48.92 91.03,49.02 90.67,49.02 90.58,49.11 90.58,49.42 90.67,49.52 91.03,49.52 91.12,49.62 91.12,49.93 91.03,50.03 90.67,50.03 90.58,50.13 90.58,50.43 90.67,50.53 91.03,50.53 91.12,50.63 91.12,50.94 91.03,51.04 90.67,51.04 90.58,51.14 90.58,51.44 90.67,51.54 91.03,51.54 91.12,51.64 91.12,52.7 92.72,54.29 92.72,64.37 93.39,65.03 93.39,67.79 94.77,69.17 94.77,70.93 95.28,71.44 95.28,71.45 95.85,72.02 95.85,72.04 v3(96.33,72.52)
  BOTTOM w0.089: CPU1.BD49 95.97,72.88 v3(96.33,72.52)
  BOTTOM w0.127: JDIMM2.40 90.35,18.87 90.6,19.13 90.6,21.84 v3(90.1,22.34)
DDR_B_D21: length 65.7
  IN1 w0.089: v3(95.27,72.03) 95.03,72.03 94.47,71.48 94.47,69.94
  IN1 w0.099: v3(90.1,23.86) 90.1,24.58 88.6,26.09 88.6,29.3 86.75,31.15 86.75,37.16 89.65,40.07 89.65,40.52 90.28,41.15 90.28,45.61 90.18,45.71 89.79,45.71 89.66,45.84 89.66,46.09 89.79,46.22 90.18,46.22 90.28,46.31 90.28,46.62 90.18,46.72 89.6,46.72 89.47,46.85 89.47,47.1 89.6,47.23 90.18,47.23 90.28,47.33 90.28,47.63 90.18,47.73 89.66,47.73 89.54,47.86 89.54,48.11 89.66,48.24 90.18,48.24 90.28,48.34 90.28,52.27 90.48,52.47 90.48,52.61 90.32,52.77 90.32,52.95 90.5,53.12 90.68,53.12 90.84,52.97 90.98,52.97 91.19,53.19 91.19,53.33 90.85,53.67 90.85,53.85 91.03,54.03 91.21,54.03 91.55,53.68 91.69,53.68 92.43,54.42 92.43,64.49 93.09,65.16 93.09,67.91 94.47,69.29 94.47,69.94
  BOTTOM w0.089: v3(95.27,72.03) 95.27,72.03 95.24,72.06 95.24,72.51 CPU1.BD50
  BOTTOM w0.127: JDIMM2.42 90.95,22.27 90.69,22.53 90.69,23.28 v3(90.1,23.86)
DDR_B_D22: length 68.1
  IN1 w0.089: v3(97.97,71.83) 97.97,71 97.32,70.35 97.06,70.35 96.9,70.19 96.9,69.94
  IN1 w0.099: v3(93.08,22.34) 93.24,22.34 93.54,22.63 93.54,24.67 91.95,26.25 91.95,26.94 91.85,27.04 91.16,27.04 91.06,27.14 91.06,27.44 91.16,27.54 91.85,27.54 91.95,27.64 91.95,30.57 91.63,30.89 90.93,30.89 90.43,31.4 90.43,32.16 90.53,32.26 91.25,32.26 91.38,32.38 91.38,32.64 91.25,32.76 90.46,32.76 90.36,32.86 90.36,33.17 90.46,33.27 91.25,33.27 91.38,33.4 91.38,33.65 91.25,33.77 90.46,33.77 90.36,33.87 90.36,36.54 90.64,36.82 90.64,36.96 90.4,37.2 90.4,37.34 90.62,37.56 90.76,37.56 91,37.32 91.14,37.32 91.36,37.53 91.36,37.67 91.12,37.92 91.12,38.06 91.33,38.27 91.47,38.27 91.71,38.03 91.85,38.03 92.07,38.25 92.07,38.39 91.91,38.55 91.91,38.73 92.09,38.9 92.27,38.9 92.43,38.75 92.57,38.75 94.95,41.13 94.95,63.63 95.48,64.16 95.48,66.79 96.9,68.21 96.9,69.94
  BOTTOM w0.089: CPU1.BE47 97.62,72.18 v3(97.97,71.83)
  BOTTOM w0.127: v3(93.08,22.34) 93.08,22.17 92.46,21.55 92.46,19.25 93.35,18.36 JDIMM2.50
DDR_B_D23: length 67
  IN1 w0.099: v3(93.08,19.29) 92.61,19.75 92.61,24.7 90.43,26.89 90.43,30.52 89.43,31.52 89.43,37.29 93.35,41.22 93.35,42.1 93.25,42.2 92.82,42.2 92.69,42.32 92.69,42.58 92.82,42.7 93.66,42.7 93.79,42.83 93.79,43.08 93.66,43.21 92.82,43.21 92.69,43.33 92.69,43.59 92.82,43.71 93.66,43.71 93.79,43.84 93.79,44.09 93.66,44.22 92.84,44.22 92.71,44.35 92.71,44.6 92.84,44.72 93.6,44.72 93.73,44.85 93.73,45.1 93.6,45.23 92.82,45.23 92.69,45.36 92.69,45.61 92.82,45.74 93.54,45.74 93.66,45.86 93.66,46.11 93.54,46.24 93.08,46.24 92.96,46.37 92.96,46.62 93.08,46.75 93.25,46.75 93.35,46.85 93.35,47.01 94.24,47.9 94.24,63.76 94.89,64.41 94.89,67.11 96.27,68.49 96.27,70.32 96.92,70.97 v3(97.15,70.97)
  BOTTOM w0.089: v3(97.15,70.97) 97.56,71.38 CPU1.BF47
  BOTTOM w0.127: v3(93.08,19.29) 93.95,18.41 JDIMM2.52
DDR_B_D24: length 59.3
  IN1 w0.089: 98.47,69.94 98.47,70.34 98.9,70.76 98.9,71.11 98.99,71.2 99.16,71.2 99.25,71.29 99.25,71.61 99.16,71.7 98.99,71.7 98.9,71.78 98.9,72.13 99,72.23 99.4,72.23 99.59,72.04 v3(99.59,71.85)
  IN1 w0.099: 98.47,69.94 98.47,67.78 96.88,66.19 96.88,63.58 96.37,63.07 96.37,39.84 94.6,38.06 94.24,38.06 94.05,37.88 94.05,37.74 94.07,37.72 94.07,37.58 93.86,37.37 93.72,37.37 93.7,37.38 93.56,37.38 93.24,37.07 93.24,36.93 93.34,36.83 93.57,36.83 93.66,36.73 93.66,36.42 93.57,36.32 93.34,36.32 93.24,36.22 93.24,35.91 93.34,35.82 93.57,35.82 93.66,35.72 93.66,35.41 93.57,35.31 93.34,35.31 93.24,35.21 93.24,34.9 93.34,34.8 93.57,34.8 93.66,34.71 93.66,34.4 93.57,34.3 93.34,34.3 93.24,34.2 93.24,33.89 93.34,33.79 93.57,33.79 93.66,33.69 93.66,33.39 93.57,33.29 93.34,33.29 93.24,33.19 93.24,32.88 93.34,32.78 93.57,32.78 93.66,32.68 93.66,32.38 93.57,32.28 93.34,32.28 93.24,32.18 93.24,31.46 93.24,31.34 94.38,30.2 94.38,26.35 95.89,24.85 95.89,24.05 v3(95.69,23.86)
  BOTTOM w0.089: v3(99.59,71.85) 99.26,72.18 CPU1.BE44
  BOTTOM w0.127: v3(95.69,23.86) 95.45,24.1 JDIMM2.57
DDR_B_D25: length 60.5
  IN1 w0.089: 98.18,69.94 98.18,70.31 98.71,70.84 98.71,72.95 98.81,73.05 99.25,73.05 99.38,72.93 99.38,72.66 99.51,72.53 v3(99.59,72.53)
  IN1 w0.099: 98.18,69.94 98.18,67.9 96.58,66.31 96.58,63.71 96.07,63.2 96.07,39.96 95.96,39.84 95.82,39.84 95.76,39.89 95.62,39.89 95.4,39.68 95.4,39.54 95.46,39.48 95.46,39.34 95.24,39.13 95.1,39.13 95.05,39.18 94.91,39.18 94.69,38.96 94.69,38.82 94.74,38.77 94.74,38.63 94.53,38.41 94.38,38.41 94.33,38.46 94.19,38.46 92.94,37.22 92.94,31.22 94.08,30.08 94.08,26.23 95.29,25.03 95.29,22.74 v3(95.69,22.34)
  BOTTOM w0.089: v3(99.59,72.53) 99.24,72.88 CPU1.BD44
  BOTTOM w0.127: v3(95.69,22.34) 96.13,22.78 96.13,24.61 96.05,24.69 JDIMM2.59
DDR_B_D26: length 63
  IN1 w0.089: 100.87,69.94 100.87,70.19 101.6,70.91 101.6,74.28 101.49,74.39 101.28,74.39 101.22,74.32 v3(101.22,73.92)
  IN1 w0.099: v3(98.61,22.34) 98.61,22.1 98.77,21.95 99.52,21.95 99.57,22 99.57,22.61 99.47,22.71 99.12,22.71 99.02,22.81 99.02,23.12 99.12,23.22 99.47,23.22 99.57,23.32 99.57,23.63 99.47,23.72 99.15,23.72 99.02,23.85 99.02,24.1 99.15,24.23 99.47,24.23 99.57,24.33 99.57,24.86 97.46,26.97 97.46,27.87 97.56,27.97 97.56,37.56 99.28,39.28 99.28,65.2 99.4,65.32 100.87,66.79 100.87,69.94
  BOTTOM w0.089: v3(101.22,73.92) 101.15,73.92 CPU1.BC42
  BOTTOM w0.127: v3(98.61,22.34) 98.18,22.77 98.18,24.53 98.45,24.8 JDIMM2.67
DDR_B_D27: length 60.8
  IN1 w0.089: v3(101.21,71.85) 100.84,71.47 100.84,70.47 100.57,70.2 100.57,69.94
  IN1 w0.099: 100.57,69.94 100.57,66.91 98.98,65.32 98.98,52.82 98.84,52.67 98.57,52.67 98.47,52.57 98.47,52.27 98.57,52.17 98.84,52.17 98.94,52.07 98.94,51.76 98.84,51.66 98.57,51.66 98.47,51.56 98.47,51.26 98.57,51.16 98.84,51.16 98.94,51.06 98.94,50.75 98.84,50.65 98.57,50.65 98.47,50.55 98.47,50.25 98.57,50.15 98.84,50.15 98.94,50.05 98.94,49.74 98.84,49.64 98.57,49.64 98.47,49.54 98.47,49.23 98.57,49.14 98.84,49.14 98.94,49.04 98.94,48.73 98.84,48.63 98.57,48.63 98.47,48.53 98.47,48.22 98.57,48.12 98.84,48.12 98.94,48.03 98.94,47.72 98.84,47.62 98.57,47.62 98.47,47.52 98.47,47.21 98.57,47.11 98.84,47.11 98.94,47.01 98.94,46.71 98.84,46.61 98.57,46.61 98.47,46.51 98.47,46.2 98.57,46.1 98.84,46.1 98.94,46 98.94,45.7 98.84,45.6 98.57,45.6 98.47,45.5 98.47,45.19 98.57,45.09 98.84,45.09 98.94,44.99 98.94,44.69 98.84,44.59 98.57,44.59 98.47,44.49 98.47,44.18 98.57,44.08 98.84,44.08 98.94,43.98 98.94,43.67 98.84,43.58 98.57,43.58 98.47,43.48 98.47,43.17 98.57,43.07 98.84,43.07 98.94,42.97 98.94,42.66 98.84,42.56 98.57,42.56 98.47,42.47 98.47,42.16 98.57,42.06 98.84,42.06 98.94,41.96 98.94,41.65 98.84,41.55 98.57,41.55 98.47,41.45 98.47,38.89 97.26,37.69 97.26,28.19 97.16,28.09 97.16,26.54 98.61,25.09 v3(98.61,23.86)
  BOTTOM w0.089: v3(101.21,71.85) 100.85,71.48 CPU1.BF42
  BOTTOM w0.127: JDIMM2.69 99.05,24.3 v3(98.61,23.86)
DDR_B_D28: length 59.2
  IN1 w0.089: 98.77,69.94 98.77,70.36 99.45,71.04 v3(99.55,71.04)
  IN1 w0.099: 98.77,69.94 98.77,67.66 97.18,66.07 97.18,63.46 96.67,62.95 96.67,61.67 96.77,61.57 96.99,61.57 97.09,61.47 97.09,61.16 96.99,61.06 96.77,61.06 96.67,60.96 96.67,60.66 96.77,60.56 96.99,60.56 97.09,60.46 97.09,60.15 96.99,60.05 96.77,60.05 96.67,59.95 96.67,39.71 94.02,37.07 94.02,30.98 94.68,30.33 94.68,26.48 96.21,24.95 96.21,19.8 v3(95.69,19.29)
  BOTTOM w0.089: CPU1.BF44 99.19,71.41 v3(99.55,71.04)
  BOTTOM w0.127: JDIMM2.56 95.15,19.16 95.28,19.29 v3(95.69,19.29)
DDR_B_D29: length 61.9
  IN1 w0.089: v3(99.59,73.23) 99.52,73.31 98.74,73.31 98.52,73.08 98.52,71.02 97.88,70.38 97.88,69.94
  IN1 w0.099: 97.88,69.94 97.75,69.81 97.75,67.92 96.29,66.45 96.29,63.83 95.78,63.32 95.78,40.48 92.65,37.35 92.65,31.1 93.79,29.96 93.79,26.11 94.94,24.95 94.94,20.78 95.06,20.66 95.55,20.66 v3(95.69,20.81)
  BOTTOM w0.089: v3(99.59,73.23) 99.24,73.58 CPU1.BC44
  BOTTOM w0.127: JDIMM2.58 95.75,18.49 96.2,18.95 96.2,20.3 v3(95.69,20.81)
DDR_B_D30: length 61.5
  IN1 w0.089: 99.98,69.94 99.98,70.33 100.42,70.77 100.42,71.99 100.81,72.38 100.81,72.81 101.22,73.22 v3(101.22,73.22)
  IN1 w0.099: v3(98.61,19.29) 97.91,19.99 97.91,24.95 95.97,26.89 95.97,37.24 97.87,39.14 97.87,56.19 97.97,56.29 98.2,56.29 98.3,56.39 98.3,56.7 98.2,56.8 97.97,56.8 97.87,56.9 97.87,57.2 97.97,57.3 98.2,57.3 98.3,57.4 98.3,57.71 98.2,57.81 97.97,57.81 97.87,57.91 97.87,58.22 97.97,58.31 98.2,58.31 98.3,58.41 98.3,58.72 98.2,58.82 97.97,58.82 97.87,58.92 97.87,59.23 97.97,59.33 98.2,59.33 98.38,59.51 98.38,65.57 99.98,67.16 99.98,69.94
  BOTTOM w0.089: v3(101.22,73.22) 100.88,72.88 CPU1.BD42
  BOTTOM w0.127: v3(98.61,19.29) 98.75,19.15 JDIMM2.68
DDR_B_D31: length 61.4
  IN1 w0.089: 100.28,69.94 100.28,70.29 100.62,70.64 100.62,71.79 101.2,72.37 v3(101.2,72.58)
  IN1 w0.099: v3(98.61,20.81) 98.21,21.22 98.21,25.07 96.27,27.01 96.27,37.11 98.17,39.02 98.17,52.87 98.27,52.97 98.58,52.97 98.68,53.07 98.68,53.38 98.58,53.48 98.27,53.48 98.17,53.58 98.17,53.88 98.27,53.98 98.58,53.98 98.68,54.08 98.68,54.39 98.58,54.49 98.27,54.49 98.17,54.59 98.17,54.89 98.27,54.99 98.58,54.99 98.68,55.09 98.68,55.4 98.58,55.5 98.27,55.5 98.17,55.6 98.17,55.9 98.27,56 98.58,56 98.68,56.1 98.68,65.44 100.28,67.04 100.28,69.94
  BOTTOM w0.089: CPU1.BE42 100.81,72.19 v3(101.2,72.58)
  BOTTOM w0.127: JDIMM2.70 99.35,20.08 v3(98.61,20.81)
DDR_B_D32: length 66
  IN1 w0.089: 117.65,69.94 117.54,70.04 117.54,70.73 117.87,71.06 117.87,74.79 v3(117.29,75.38)
  IN1 w0.099: v3(120.46,22.54) 120.88,22.96 120.88,26.54 121.67,27.33 121.67,27.85 121.77,27.95 122.29,27.95 122.42,28.08 122.42,28.33 122.29,28.46 121.77,28.46 121.67,28.56 121.67,28.86 121.8,28.99 122.55,28.99 122.68,29.12 122.68,36.15 122.58,36.25 122.04,36.25 121.91,36.38 121.91,36.63 122.04,36.76 122.55,36.76 122.68,36.88 122.68,37.11 122.55,37.24 122.04,37.24 121.91,37.37 121.91,37.68 122.04,37.8 122.55,37.8 122.68,37.93 122.68,38.18 122.55,38.31 121.58,38.31 121.32,38.57 121.32,44.4 120.21,45.51 120.21,55.2 118.17,57.25 118.17,69.42 117.65,69.94
  BOTTOM w0.089: CPU1.BA16 117.68,74.98 v3(117.29,75.38)
  BOTTOM w0.127: v3(120.46,22.54) 120.23,22.31 119.97,22.31 119.45,22.83 JDIMM2.129
DDR_B_D33: length 66
  IN1 w0.089: v3(117.39,78.13) 117.39,77.74 116.84,77.19 116.84,74.83 117.06,74.61 117.06,70.07 117.19,69.94
  IN1 w0.099: v3(120.46,24.07) 120.46,26.54 121.37,27.46 121.37,29.2 121.46,29.29 122.25,29.29 122.38,29.41 122.38,29.66 122.25,29.79 121.15,29.79 121.02,29.92 121.02,30.17 121.15,30.3 122.28,30.3 122.38,30.4 122.38,30.7 122.28,30.8 121.73,30.8 121.61,30.93 121.61,31.18 121.73,31.31 122.28,31.31 122.38,31.41 122.38,31.71 122.28,31.81 121.71,31.81 121.61,31.91 121.61,32.22 121.71,32.32 122.28,32.32 122.38,32.42 122.38,35.37 121.61,36.14 121.61,37.85 121.02,38.44 121.02,44.28 119.92,45.39 119.92,55.07 117.87,57.11 117.87,69.25 117.19,69.94 117.19,69.94
  BOTTOM w0.089: v3(117.39,78.13) 117.74,77.78 CPU1.AU16
  BOTTOM w0.127: JDIMM2.131 120.05,24.69 119.93,24.57 119.93,23.96 120.03,23.87 120.26,23.87 v3(120.46,24.07)
DDR_B_D34: length 65.1
  IN1 w0.089: v3(119.21,75.3) 118.94,75.02 118.94,71.14 120.14,69.94
  IN1 w0.099: 120.14,69.94 120.14,57.88 122.01,56.01 122.01,50.38 122.73,49.66 122.73,45.64 123.12,45.25 123.12,43.28 123.25,43.16 124.01,43.16 124.11,43.05 124.11,42.75 124.01,42.65 123.22,42.65 123.12,42.55 123.12,42.25 123.22,42.14 124.01,42.14 124.11,42.04 124.11,41.74 124.01,41.64 123.5,41.64 123.39,41.54 123.39,41.24 123.5,41.13 124.01,41.13 124.11,41.03 124.11,40.73 124.01,40.63 123.53,40.63 123.43,40.53 123.43,40.22 123.53,40.12 124.01,40.12 124.11,40.02 124.11,39.3 125.16,38.25 125.16,31.19 125.06,31.09 124.58,31.09 124.48,30.99 124.48,30.69 124.58,30.59 125.06,30.59 125.16,30.48 125.16,30.18 125.06,30.08 124.58,30.08 124.48,29.98 124.48,29.68 124.58,29.57 125.06,29.57 125.16,29.47 125.16,29.17 125.06,29.07 124.64,29.07 124.54,28.97 124.54,28.66 124.64,28.56 125.06,28.56 125.16,28.46 125.16,27.03 123.82,25.69 123.82,24.07 123.72,23.96 123.56,23.96 v3(123.46,24.07)
  BOTTOM w0.089: CPU1.BA15 118.9,74.98 v3(119.21,75.3)
  BOTTOM w0.127: v3(123.46,24.07) 123.46,24.21 123.05,24.62 123.05,24.73 JDIMM2.141
DDR_B_D35: length 65.9
  IN1 w0.089: 120.44,69.94 120.44,70.02 119.13,71.33 119.13,74.64 119.66,75.17 119.66,75.71 118.81,76.56 118.81,77.02 v3(119.23,77.43)
  IN1 w0.099: v3(123.46,22.54) 123.71,22.54 124.12,22.95 124.12,25.57 125.46,26.91 125.46,38.37 124.4,39.42 124.4,43.33 124.28,43.45 123.55,43.45 123.42,43.58 123.42,43.84 123.55,43.97 124.08,43.97 124.21,44.1 124.21,44.39 124.08,44.51 123.55,44.51 123.42,44.64 123.42,45.37 123.03,45.76 123.03,49.78 122.31,50.51 122.31,56.13 120.44,58 120.44,69.94
  BOTTOM w0.089: CPU1.AV15 118.88,77.08 v3(119.23,77.43)
  BOTTOM w0.127: v3(123.46,22.54) 123.66,22.33 124.01,22.33 124.19,22.51 124.19,24.16 123.65,24.7 JDIMM2.143
DDR_B_D36: length 65.7
  IN1 w0.089: 118.64,69.94 118.26,70.32 118.26,75.26 v3(118.18,75.34)
  IN1 w0.099: v3(120.46,19.49) 122.49,19.49 122.62,19.62 122.62,19.88 122.49,20.01 122.17,20.01 122.04,20.13 122.04,20.39 122.17,20.51 122.75,20.51 122.87,20.64 122.87,20.89 122.77,20.99 121.78,20.99 121.63,21.15 121.63,26.45 123.27,28.09 123.27,38.43 121.91,39.79 121.91,44.71 120.81,45.82 120.81,55.51 118.89,57.43 118.89,69.69 118.64,69.94
  BOTTOM w0.089: CPU1.AY16 117.82,75.63 118.12,75.34 v3(118.18,75.34)
  BOTTOM w0.127: v3(120.46,19.49) 119.75,18.78 JDIMM2.130
DDR_B_D37: length 66.5
  IN1 w0.089: v3(117.39,76.8) 117.77,76.42 117.77,75.19 118.07,74.89 118.07,69.99 118.12,69.94
  IN1 w0.099: 118.12,69.94 118.56,69.5 118.56,57.29 120.51,55.34 120.51,45.64 121.62,44.53 121.62,39.66 122.97,38.3 122.97,28.21 121.33,26.57 121.33,22.37 121.23,22.27 120.94,22.27 120.86,22.19 120.86,21.84 120.94,21.76 121.23,21.76 121.33,21.66 121.33,21.02 121.75,20.6 121.75,20.42 121.49,20.17 121.31,20.17 v3(120.46,21.02)
  BOTTOM w0.089: v3(117.39,76.8) 117.53,76.8 CPU1.AV16
  BOTTOM w0.127: JDIMM2.132 120.35,18.71 120.97,19.33 120.97,20.51 v3(120.46,21.02)
DDR_B_D38: length 65.9
  IN1 w0.089: v3(119.19,76.73) 119.85,76.07 119.85,74.84 120.22,74.47 120.22,70.71 120.83,70.1 120.83,69.94 120.82,69.94
  IN1 w0.099: v3(123.46,21.02) 123.46,20.74 123.55,20.65 124.09,20.65 124.41,20.97 124.41,25.45 125.75,26.79 125.75,31.23 126.39,31.86 126.39,37.86 124.7,39.55 124.7,44.51 123.36,45.86 123.36,49.88 122.61,50.63 122.61,56.25 120.82,58.04 120.82,69.94
  BOTTOM w0.089: CPU1.AY15 119.19,76.12 v3(119.19,76.73)
  BOTTOM w0.127: v3(123.46,21.02) 122.75,20.31 JDIMM2.140
DDR_B_D39: length 65.7
  IN1 w0.089: 121.12,69.94 121.12,70.22 120.42,70.93 120.42,74.54 120.04,74.92 120.04,76.26 119.8,76.49 119.8,77.61 v3(119.27,78.15)
  IN1 w0.099: v3(123.46,19.49) 124.71,20.75 124.71,25.32 126.05,26.66 126.05,31.1 126.7,31.75 126.7,37.97 125,39.67 125,44.63 123.65,45.98 123.65,50 122.91,50.75 122.91,56.38 121.12,58.16 121.12,69.94
  BOTTOM w0.089: v3(119.27,78.15) 118.9,77.78 CPU1.AU15
  BOTTOM w0.127: JDIMM2.142 123.35,19.39 v3(123.46,19.49)
DDR_B_D40: length 69
  IN1 w0.089: 121.63,69.94 121.63,70.37 121.24,70.77 121.24,73.99 120.23,75 120.23,76.25 120.54,76.56 120.54,77.57 v3(121.11,78.13)
  IN1 w0.099: 121.63,69.94 121.63,58.37 123.41,56.59 123.41,56.02 123.54,55.89 124.03,55.89 124.16,55.77 124.16,55.51 124.03,55.38 123.54,55.38 123.41,55.26 123.41,55.01 123.54,54.88 124.03,54.88 124.16,54.75 124.16,54.5 124.03,54.37 123.54,54.37 123.41,54.25 123.41,53.99 123.54,53.87 124.03,53.87 124.16,53.74 124.16,53.49 124.03,53.36 123.54,53.36 123.41,53.24 123.41,52.98 123.54,52.86 124.03,52.86 124.16,52.73 124.16,52.48 124.03,52.35 123.54,52.35 123.41,52.22 123.41,51.97 123.54,51.85 124.03,51.85 124.16,51.72 124.16,51.47 124.03,51.34 123.54,51.34 123.41,51.21 123.41,50.96 123.54,50.84 124.03,50.84 124.16,50.71 124.16,46.19 125.5,44.84 125.5,39.92 127.69,37.73 127.69,33.4 127.6,33.3 127.3,33.3 127.2,33.2 127.2,32.9 127.3,32.8 127.6,32.8 127.69,32.7 127.69,32.03 126.88,31.21 126.88,26.77 125.86,25.76 v3(125.86,23.6)
  BOTTOM w0.089: v3(121.11,78.13) 120.76,77.78 CPU1.AU12
  BOTTOM w0.127: JDIMM2.147 124.85,24.69 125.86,23.69 v3(125.86,23.6)
DDR_B_D41: length 69.4
  IN1 w0.089: v3(120.99,76.01) 120.61,75.63 120.61,75.18 121.67,74.12 121.67,70.87 122.22,70.32 122.22,69.94
  IN1 w0.099: v3(125.86,20.55) 125.86,20.27 125.95,20.18 126.34,20.18 126.43,20.27 126.43,22.2 126.69,22.45 127.08,22.45 127.21,22.58 127.21,22.82 127.08,22.95 126.69,22.95 126.56,23.07 126.56,23.43 126.69,23.55 127.34,23.55 127.47,23.68 127.47,30.61 128.97,32.11 128.97,37.29 126.1,40.16 126.1,45.09 125.44,45.75 125.44,46.16 125.31,46.28 124.91,46.28 124.78,46.41 124.78,56.06 122.22,58.62 122.22,69.94
  BOTTOM w0.089: CPU1.AY12 120.81,75.68 120.99,75.87 v3(120.99,76.01)
  BOTTOM w0.127: JDIMM2.149 125.45,24.82 126.43,23.84 126.43,21.12 v3(125.86,20.55)
DDR_B_D42: length 69
  IN1 w0.089: v3(122.14,75.29) 122.54,75.29 123.7,74.13 123.7,73.56 123.86,73.41 123.86,70.86 124.17,70.55 124.17,69.94
  IN1 w0.099: v3(129.48,23.6) 129.48,23.32 129.56,23.23 130.05,23.23 130.14,23.32 130.14,24.04 130.02,24.17 129.42,24.17 129.32,24.26 129.32,24.57 129.42,24.67 130.02,24.67 130.14,24.8 130.14,25.05 130.02,25.18 129.42,25.18 129.32,25.28 129.32,25.58 129.42,25.68 130.02,25.68 130.14,25.81 130.14,26.06 130.02,26.19 129.42,26.19 129.32,26.29 129.32,26.59 129.42,26.69 130.02,26.69 130.14,26.82 130.14,30.38 131.56,31.8 131.56,37.34 127.95,40.95 127.95,46.19 127.76,46.38 127.41,46.38 127.24,46.55 127.24,56.19 127.03,56.4 127.03,56.54 127.22,56.73 127.22,56.91 127.05,57.09 126.87,57.09 126.67,56.9 126.53,56.9 126.32,57.11 126.32,57.25 126.51,57.45 126.51,57.63 126.33,57.8 126.15,57.8 125.96,57.61 125.82,57.61 125.6,57.83 125.6,57.97 125.79,58.16 125.79,58.34 125.61,58.52 125.44,58.52 125.24,58.33 125.1,58.33 124.89,58.55 124.89,58.69 125.08,58.88 125.08,59.06 124.9,59.24 124.72,59.24 124.53,59.04 124.39,59.04 124.17,59.26 124.17,59.46 124.34,59.63 124.34,59.79 124.17,59.96 124.17,69.94
  BOTTOM w0.089: CPU1.BA10 121.84,74.98 v3(122.14,75.29)
  BOTTOM w0.127: JDIMM2.157 127.85,24.71 128.96,23.6 v3(129.48,23.6)
DDR_B_D43: length 70.6
  IN1 w0.089: 124.79,69.94 124.79,70.63 124.24,71.18 124.24,73.56 124.08,73.72 124.08,74.29 122.54,75.83 122.54,77.77 122.17,78.14 v3(122.17,78.15)
  IN1 w0.099: 124.79,69.94 124.79,60.19 127.96,57.02 127.96,47.96 128.56,47.36 128.56,41.43 132.87,37.13 132.87,32.26 130.81,30.21 130.81,21.89 v3(129.48,20.55)
  BOTTOM w0.089: CPU1.AU10 121.94,78.15 v3(122.17,78.15)
  BOTTOM w0.127: JDIMM2.159 128.45,24.93 128.45,24.74 128.97,24.22 129.48,24.22 129.99,23.71 129.99,21.06 v3(129.48,20.55)
DDR_B_D44: length 70
  IN1 w0.089: 121.92,69.94 121.92,70.35 121.48,70.79 121.48,74.04 120.42,75.1 120.42,76.17 120.73,76.48 120.73,77.06 v3(121.11,77.43)
  IN1 w0.099: 121.92,69.94 121.92,58.49 124.46,55.96 124.46,46.31 125.8,44.97 125.8,40.04 127.99,37.85 127.99,31.9 127.17,31.08 127.17,25.97 127.07,25.87 126.39,25.87 126.27,25.75 126.27,25.49 126.39,25.37 127.07,25.37 127.17,25.27 127.17,24.96 127.07,24.86 126.28,24.86 126.15,24.74 126.15,24.48 126.28,24.36 127.07,24.36 127.17,24.26 127.17,23.95 127.07,23.85 126.39,23.85 126.26,23.72 126.26,22.48 v3(125.86,22.07)
  BOTTOM w0.089: CPU1.AV12 120.76,77.08 v3(121.11,77.43)
  BOTTOM w0.127: v3(125.86,22.07) 124.54,20.76 124.54,19.79 124.65,19.68 125.02,19.68 125.14,19.56 125.14,19.39 125.02,19.27 124.65,19.27 124.55,19.17 JDIMM2.146
DDR_B_D45: length 69.4
  IN1 w0.089: v3(120.98,75.33) 121.18,75.13 121.18,74.88 121.86,74.2 121.86,70.95 122.08,70.73 122.08,70.73 122.64,70.17 122.64,69.94
  IN1 w0.099: v3(125.86,19.02) 126.79,19.95 126.79,21.76 127.11,22.09 127.15,22.09 127.77,22.7 127.77,30.48 129.27,31.98 129.27,37.42 126.4,40.29 126.4,45.21 125.73,45.87 125.73,46.58 125.64,46.68 125.2,46.68 125.08,46.81 125.08,47.06 125.2,47.18 125.64,47.18 125.73,47.28 125.73,47.59 125.64,47.69 125.2,47.69 125.08,47.82 125.08,48.07 125.2,48.19 125.64,48.19 125.73,48.29 125.73,48.6 125.64,48.7 125.2,48.7 125.08,48.83 125.08,49.08 125.2,49.21 125.64,49.21 125.73,49.3 125.73,49.61 125.64,49.71 125.2,49.71 125.08,49.84 125.08,50.09 125.2,50.22 125.64,50.22 125.73,50.32 125.73,50.62 125.64,50.72 125.2,50.72 125.08,50.85 125.08,51.1 125.2,51.23 125.64,51.23 125.73,51.33 125.73,51.63 125.64,51.73 125.2,51.73 125.08,51.86 125.08,56.22 122.64,58.65 122.64,69.94
  BOTTOM w0.089: v3(120.98,75.33) 120.98,75.22 120.74,74.98 CPU1.BA12
  BOTTOM w0.127: JDIMM2.148 125.15,18.92 125.42,19.18 125.7,19.18 v3(125.86,19.02)
DDR_B_D46: length 69.5
  IN1 w0.089: v3(122.11,76.01) 122.11,75.99 123.89,74.21 123.89,73.64 124.05,73.48 124.05,71.05 124.47,70.63 124.47,69.94
  IN1 w0.099: v3(129.48,22.07) 129.48,21.93 129.6,21.81 130.31,21.81 130.44,21.93 130.44,22.25 130.31,22.38 130.05,22.38 129.92,22.51 129.92,22.77 130.05,22.9 130.31,22.9 130.44,23.02 130.44,30.26 131.86,31.68 131.86,32.03 131.99,32.16 132.34,32.16 132.47,32.29 132.47,32.54 132.34,32.66 131.99,32.66 131.86,32.79 131.86,35.49 132.01,35.64 132.47,35.64 132.57,35.74 132.57,35.99 132.44,36.12 131.99,36.12 131.86,36.25 131.86,36.5 131.99,36.62 132.44,36.62 132.57,36.75 132.57,37 132.44,37.13 131.99,37.13 131.86,37.26 131.86,37.46 128.25,41.07 128.25,46.46 127.54,47.18 127.54,57.02 124.47,60.08 124.47,69.94
  BOTTOM w0.089: CPU1.AY10 121.78,75.68 v3(122.11,76.01)
  BOTTOM w0.127: JDIMM2.158 128.15,18.38 128.97,19.2 128.97,21.57 v3(129.48,22.07)
DDR_B_D47: length 70
  IN1 w0.089: 123.88,69.94 123.88,70.46 123.67,70.67 123.67,73.33 123.51,73.49 123.51,73.98 122.61,74.88 121.99,74.88 121.75,75.12 121.75,76.21 121.93,76.39 122.19,76.39 122.34,76.55 122.34,77.11 v3(122.01,77.44)
  IN1 w0.099: 123.88,69.94 123.88,59.13 126.94,56.07 126.94,46.43 127.62,45.75 127.62,40.86 130.47,38.01 130.47,32.21 130.57,32.11 130.75,32.11 130.88,31.98 130.88,31.73 130.75,31.6 130.57,31.6 130.47,31.5 130.47,31.13 129.85,30.51 129.85,30.22 129.75,30.12 129.11,30.12 128.98,29.99 128.98,29.74 129.11,29.61 129.75,29.61 129.85,29.51 129.85,28.91 129.75,28.81 129.1,28.81 128.97,28.68 128.97,28.43 129.1,28.3 129.75,28.3 129.85,28.21 129.85,27.5 129.72,27.38 129.15,27.38 129.02,27.25 129.02,19.48 v3(129.48,19.02)
  BOTTOM w0.089: CPU1.AV10 121.67,77.08 122.01,77.42 v3(122.01,77.44)
  BOTTOM w0.127: v3(129.48,19.02) 129.3,19.02 128.75,18.48 JDIMM2.160
DDR_B_D48: length 71.5
  IN1 w0.089: 125.59,69.94 125.59,70.18 126.02,70.61 126.02,72.07 125.15,72.93 125.15,73.41 124.94,73.62 124.72,73.62 124.46,73.88 124.46,74.62 123.3,75.79 123.3,77.45 v3(123.91,78.07)
  IN1 w0.099: v3(131.76,22.52) 132.17,22.93 132.17,30.11 134.45,32.4 134.45,37.31 133.17,38.58 132.77,38.58 130.3,41.05 130.3,41.36 130.7,41.76 130.7,41.94 130.47,42.17 130.29,42.17 129.82,41.71 129.64,41.71 129.47,41.89 129.47,42.06 129.95,42.55 129.95,42.69 129.37,43.28 129.37,47.81 128.76,48.42 128.76,57.35 126.68,59.43 126.68,67.07 126.59,67.17 126.28,67.17 126.18,67.27 126.18,67.57 126.28,67.67 126.59,67.67 126.68,67.77 126.68,68.08 126.59,68.18 125.72,68.18 125.59,68.3 125.59,68.56 125.72,68.68 126.3,68.68 126.43,68.81 126.43,69.06 126.3,69.19 125.72,69.19 125.59,69.32 125.59,69.94
  BOTTOM w0.089: v3(123.91,78.07) 123.74,78.07 CPU1.AU8
  BOTTOM w0.127: JDIMM2.163 129.65,24.79 129.67,24.79 131.13,23.32 131.13,23.15 v3(131.76,22.52)
DDR_B_D49: length 70.6
  IN1 w0.089: v3(122.93,75.95) 123.07,75.82 123.07,75.75 124.27,74.54 124.27,73.8 124.43,73.64 124.43,71.56 124.65,71.34 125.22,71.34 125.48,71.08 125.48,70.51 125.29,70.33 125.29,69.94
  IN1 w0.099: 125.29,69.94 125.29,67.88 125.39,67.78 125.73,67.78 125.86,67.65 125.86,67.4 125.73,67.28 125.39,67.28 125.29,67.18 125.29,66.87 125.39,66.77 126.18,66.77 126.3,66.64 126.3,66.39 126.18,66.26 125.39,66.26 125.29,66.17 125.29,65.86 125.39,65.76 126.18,65.76 126.3,65.63 126.3,65.38 126.18,65.25 125.39,65.25 125.29,65.15 125.29,64.85 125.39,64.75 126.18,64.75 126.34,64.58 126.34,59.35 128.47,57.23 128.47,48.3 129.07,47.69 129.07,41.86 133.39,37.54 133.39,31.95 131.87,30.43 131.87,30.16 131.77,30.06 131.44,30.06 131.32,29.93 131.32,29.68 131.44,29.55 131.77,29.55 131.87,29.45 131.87,28.25 131.77,28.15 131.42,28.15 131.32,28.05 131.32,27.75 131.42,27.65 131.77,27.65 131.87,27.55 131.87,27.24 131.77,27.14 131.42,27.14 131.32,27.04 131.32,26.74 131.42,26.64 131.77,26.64 131.87,26.54 131.87,26.23 131.77,26.13 131.42,26.13 131.32,26.03 131.32,25.73 131.42,25.63 131.77,25.63 131.87,25.53 131.87,25.22 131.77,25.12 131.42,25.12 131.32,25.02 131.32,24.71 131.42,24.62 131.77,24.62 131.87,24.52 131.87,24.15 v3(131.76,24.05)
  BOTTOM w0.089: CPU1.BA8 122.93,75.51 v3(122.93,75.95)
  BOTTOM w0.127: JDIMM2.165 130.25,24.78 130.99,24.05 v3(131.76,24.05)
DDR_B_D50: length 71.1
  IN1 w0.099: v3(134.85,22.52) 135.26,22.93 135.26,24.7 135.15,24.81 135.15,29.64 137.63,32.13 137.63,37.65 135.47,39.82 135.47,40.95 131.82,44.6 131.82,49.01 131.16,49.67 131.16,63.85 130.26,64.75 129.61,64.75 129.48,64.88 129.48,65.13 129.61,65.26 130.01,65.26 130.14,65.38 130.14,65.63 130.01,65.76 129.61,65.76 129.48,65.89 129.48,66.14 129.61,66.27 130.01,66.27 130.14,66.39 130.14,66.65 130.01,66.77 129.61,66.77 129.48,66.9 129.48,67.15 129.61,67.28 130.01,67.28 130.14,67.4 130.14,75.38 128.43,77.08 125.15,77.08 v3(124.82,77.42)
  BOTTOM w0.089: CPU1.AV6 124.48,77.08 v3(124.82,77.42)
  BOTTOM w0.127: JDIMM2.175 133.25,24.12 v3(134.85,22.52)
DDR_B_D51: length 70.9
  IN1 w0.099: v3(125.79,75.89) 126.2,76.29 128.72,76.29 129.35,75.66 129.35,72.57 129.07,72.29 129.07,64.58 129.2,64.45 130.14,64.45 130.26,64.33 130.26,64.07 130.14,63.95 129.2,63.95 129.07,63.82 129.07,63.57 129.2,63.44 130.73,63.44 130.86,63.32 130.86,63.06 130.73,62.94 129.2,62.94 129.07,62.81 129.07,62.56 129.2,62.43 130.73,62.43 130.86,62.3 130.86,49.43 131.51,48.79 131.51,44.42 135.16,40.76 135.16,39.7 137.34,37.53 137.34,32.25 134.83,29.75 134.83,28.87 134.85,28.85 v3(134.85,24.05)
  BOTTOM w0.089: CPU1.BA6 124.48,74.98 125.38,75.89 v3(125.79,75.89)
  BOTTOM w0.127: JDIMM2.177 133.85,24.96 133.85,24.23 134.18,23.9 134.71,23.9 v3(134.85,24.05)
DDR_B_D52: length 71.8
  IN1 w0.089: v3(123.93,77.45) 123.49,77.01 123.49,75.9 125.35,74.04 125.35,73.12 126.4,72.07
  IN1 w0.099: 126.4,72.07 126.4,70.72 126.53,70.59 126.68,70.59 126.81,70.46 126.81,70.21 126.68,70.08 126.01,70.08 125.89,69.96 125.89,69.7 126.01,69.58 126.97,69.58 127.07,69.48 127.07,59.47 129.06,57.47 129.06,48.66 129.68,48.03 129.68,43.41 132.08,41.01 132.08,40.73 131.67,40.33 131.67,40.19 131.89,39.97 132.03,39.97 132.46,40.4 132.67,40.4 132.86,40.2 132.86,40.02 132.59,39.75 132.59,39.59 134.75,37.43 134.75,32.21 132.48,29.95 132.48,20.72 132.39,20.63 131.85,20.63 131.76,20.72 v3(131.76,21)
  BOTTOM w0.089: v3(123.93,77.45) 123.56,77.08 CPU1.AV8
  BOTTOM w0.127: JDIMM2.164 129.95,18.45 131.13,19.63 131.13,20.37 v3(131.76,21)
DDR_B_D53: length 71
  IN1 w0.089: 127.36,69.94 127.36,70.72 126.81,71.27 126.81,73.6 126.68,73.73 126.2,73.73 125.66,74.27 125.46,74.27 124.96,74.77 124.96,74.77 123.86,75.87 v3(123.86,76.04)
  IN1 w0.099: 127.36,69.94 127.36,60.04 127.49,59.92 128.59,59.92 128.72,59.79 128.72,59.54 128.59,59.41 128.24,59.41 128.15,59.31 128.15,59.01 128.24,58.91 129.26,58.91 129.36,58.81 129.36,48.78 129.98,48.16 129.98,43.53 133.16,40.35 133.16,39.44 135.05,37.55 135.05,32.09 132.78,29.82 132.78,27.33 132.88,27.23 133.09,27.23 133.21,27.1 133.21,26.85 133.09,26.72 132.88,26.72 132.78,26.62 132.78,26.32 132.88,26.22 133.09,26.22 133.21,26.09 133.21,25.84 133.09,25.71 132.88,25.71 132.78,25.61 132.78,25.31 132.88,25.21 133.09,25.21 133.21,25.08 133.21,24.83 133.09,24.7 132.88,24.7 132.78,24.6 132.78,24.29 132.88,24.2 133.09,24.2 133.21,24.07 133.21,23.82 133.09,23.69 132.88,23.69 132.78,23.59 132.78,23.28 132.88,23.18 133.09,23.18 133.21,23.06 133.21,22.81 133.09,22.68 132.88,22.68 132.78,22.58 132.78,20.49 v3(131.76,19.47)
  BOTTOM w0.089: v3(123.86,76.04) 123.51,75.68 CPU1.AY8
  BOTTOM w0.127: JDIMM2.166 130.55,18.47 131.55,19.47 v3(131.76,19.47)
DDR_B_D54: length 71.4
  IN1 w0.089: v3(124.82,78.12) 125.06,77.88 127.5,77.88 127.56,77.94 128.64,77.94 129.08,77.5 129.08,77 129.8,76.29
  IN1 w0.099: 129.8,76.29 130.43,75.65 130.43,65.14 131.45,64.12 131.45,49.79 132.11,49.13 132.11,44.73 135.76,41.08 135.76,39.94 138.61,37.09 138.61,32.68 135.48,29.55 135.48,24.9 135.55,24.83 135.55,21.7 v3(134.85,21)
  BOTTOM w0.089: v3(124.82,78.12) 124.48,77.78 CPU1.AU6
  BOTTOM w0.127: v3(134.85,21) 134.5,20.64 134.5,20.46 132.95,18.92 132.95,18.8 JDIMM2.174
DDR_B_D55: length 70.9
  IN1 w0.099: v3(134.85,19.47) 134.44,19.88 134.44,28.87 134.54,28.96 134.54,29.87 136.25,31.59 136.25,38.05 134.87,39.44 134.87,40.64 131.21,44.3 131.21,48.67 130.56,49.31 130.56,61 130.44,61.12 128.88,61.12 128.78,61.22 128.78,61.53 128.88,61.63 130.06,61.63 130.18,61.76 130.18,62.01 130.06,62.13 128.88,62.13 128.78,62.23 128.78,72.48 129.04,72.74 129.04,74.96 128.54,75.46 125.41,75.46 v3(124.87,75.99)
  BOTTOM w0.089: v3(124.87,75.99) 124.71,75.99 CPU1.AY6
  BOTTOM w0.127: JDIMM2.176 133.55,18.59 134.44,19.47 v3(134.85,19.47)
DDR_B_D56: length 76.4
  IN1 w0.089: 129.8,78.13 128.93,79 128.63,79 128.25,79.39 128.25,80.22 128.12,80.35 127.6,80.35 127.22,80.73 v3(127.17,80.73)
  IN1 w0.099: 129.8,78.13 131.56,76.37 131.56,65.57 132.72,64.41 132.72,50.09 133.21,49.59 133.21,46.28 133.34,46.15 134.88,46.15 135,46.02 135,45.77 134.88,45.64 133.34,45.64 133.21,45.52 133.21,45.26 133.34,45.14 135.08,45.14 135.18,45.04 135.18,44.73 135.08,44.63 134.27,44.63 134.14,44.51 134.14,44.25 134.27,44.13 135.08,44.13 135.18,44.03 135.18,43.38 137.83,40.73 137.83,40.14 140.45,37.53 140.45,31.8 138.32,29.68 138.32,28.77 137.82,28.27 137.82,23.34 137.16,22.68 v3(137.16,22.52)
  BOTTOM w0.089: CPU1.AM2 127.52,81.08 v3(127.17,80.73)
  BOTTOM w0.127: JDIMM2.181 135.05,24.63 137.1,22.59 v3(137.16,22.52)
DDR_B_D57: length 76.7
  IN1 w0.089: v3(126.47,81.55) 126.78,81.24 126.78,80.57 127,80.35 127.33,80.35 127.52,80.16 127.52,79.29 127.51,79.28 127.51,78.98 127.86,78.63 128.85,78.63 129.47,78.02 129.47,77.83 129.8,77.5
  IN1 w0.099: 129.8,77.5 131.26,76.04 131.26,65.45 132.26,64.45 132.26,50.13 132.92,49.47 132.92,45.06 136.83,41.14 136.83,40.01 139.41,37.43 139.41,32.35 137.48,30.42 137.48,30.2 137.35,30.08 137.16,30.08 137.04,29.95 137.04,29.67 137.16,29.55 137.35,29.55 137.48,29.42 137.48,29.17 137.35,29.04 136.48,29.04 136.36,28.91 136.36,28.64 136.46,28.54 137.39,28.54 137.52,28.41 137.52,28.13 137.42,28.03 136.48,28.03 136.36,27.9 136.36,27.12 136.48,26.99 137.39,26.99 137.52,26.86 137.52,26.61 137.39,26.49 136.5,26.49 136.4,26.39 136.4,26.08 136.5,25.98 137.39,25.98 137.51,25.85 137.51,25.57 137.41,25.47 136.5,25.47 136.4,25.38 136.4,25.07 136.5,24.97 137.39,24.97 137.51,24.84 137.51,24.17 137.39,24.05 v3(137.16,24.05)
  BOTTOM w0.089: v3(126.47,81.55) 126.82,81.2 CPU1.AM3
  BOTTOM w0.127: v3(137.16,24.05) 136.32,24.05 135.65,24.72 JDIMM2.183
DDR_B_D58: length 76.7
  IN1 w0.089: v3(128.57,82.36) 128.85,82.08 129.8,82.08
  IN1 w0.099: v3(140.75,22.52) 141.16,22.93 141.16,26.67 142.54,28.06 142.54,37.69 143.07,38.22 143.07,39.43 142.46,40.05 141.65,40.05 137.44,44.26 137.44,50.3 137.34,50.4 135.72,50.4 135.59,50.53 135.59,50.78 135.72,50.91 136.58,50.91 136.7,51.03 136.7,51.28 136.58,51.41 134.96,51.41 134.84,51.54 134.84,65.26 133.69,66.41 133.69,78.3 129.9,82.08 129.8,82.08
  BOTTOM w0.089: v3(128.57,82.36) 128.22,82.71 CPU1.AK1
  BOTTOM w0.127: JDIMM2.191 138.05,24.24 138.83,23.46 139.81,23.46 v3(140.75,22.52)
DDR_B_D59: length 76.9
  IN1 w0.089: v3(126.47,82.36) 126.94,82.83 127.59,82.83 128.94,81.49 129.25,81.49 129.8,80.94
  IN1 w0.099: 129.8,80.94 130.07,80.67 130.09,80.67 133.36,77.4 133.36,66.32 134.54,65.14 134.54,51.16 135.69,50 136.84,50 137.14,49.7 137.14,44.14 141.52,39.75 142.33,39.75 142.77,39.31 142.77,38.34 142.25,37.81 142.25,28.18 140.86,26.8 140.86,25.8 140.73,25.68 139.75,25.68 139.62,25.55 139.62,25.3 139.75,25.17 140.73,25.17 140.86,25.04 140.86,24.79 140.73,24.67 139.75,24.67 139.62,24.54 139.62,24.17 139.75,24.05 v3(140.75,24.05)
  BOTTOM w0.089: v3(126.47,82.36) 126.12,82.71 CPU1.AK4
  BOTTOM w0.127: JDIMM2.193 138.65,24.56 139.16,24.05 v3(140.75,24.05)
DDR_B_D60: length 76.6
  IN1 w0.089: v3(127.87,80.73) 128.02,80.73 128.44,80.31 128.44,79.46 128.63,79.28 129.16,79.28 129.8,78.64
  IN1 w0.099: v3(137.16,21) 137.57,21.4 137.57,22.66 138.12,23.21 138.12,28.14 138.62,28.65 138.62,29.48 140.74,31.6 140.74,37.65 138.14,40.25 138.14,40.85 135.48,43.51 135.48,46.35 135.35,46.48 133.61,46.48 133.51,46.58 133.51,46.89 133.61,46.98 135.35,46.98 135.48,47.11 135.48,47.36 135.35,47.49 133.61,47.49 133.51,47.59 133.51,49.71 133.03,50.19 133.03,64.51 131.85,65.69 131.85,76.58 129.8,78.64
  BOTTOM w0.089: v3(127.87,80.73) 128.22,81.08 CPU1.AM1
  BOTTOM w0.127: JDIMM2.180 134.75,18.38 135.82,19.46 135.82,19.66 v3(137.16,21)
DDR_B_D61: length 78.4
  IN1 w0.089: v3(126.42,80.75) 126.42,80.53 126.79,80.16 126.79,78.87 126.97,78.68 127.31,78.68 127.69,78.3 128.57,78.3 129.27,77.6 129.27,77.57 129.8,77.05
  IN1 w0.099: v3(137.16,19.47) 136.69,19.94 136.69,20.41 136.57,20.54 135.7,20.54 135.58,20.66 135.58,21.01 135.7,21.13 136.66,21.13 136.76,21.23 136.76,21.54 136.66,21.64 136.16,21.64 136.06,21.74 136.06,22.05 136.16,22.14 136.66,22.14 136.76,22.24 136.76,22.55 136.66,22.65 136.16,22.65 136.06,22.75 136.06,23.06 136.16,23.16 136.66,23.16 136.76,23.25 136.76,23.56 136.66,23.66 136.16,23.66 136.06,23.76 136.06,24.07 136.16,24.17 136.66,24.17 136.76,24.27 136.76,24.57 136.66,24.67 136.16,24.67 136.06,24.77 136.06,29.42 139.11,32.47 139.11,37.3 136.44,39.98 136.44,41.12 132.62,44.94 132.62,49.34 131.96,50 131.96,64.33 130.94,65.35 130.94,75.91 129.8,77.05
  BOTTOM w0.089: CPU1.AM4 126.12,81.04 v3(126.42,80.75)
  BOTTOM w0.127: v3(137.16,19.47) 136.47,19.47 135.35,18.35 JDIMM2.182
DDR_B_D62: length 77.1
  IN1 w0.089: 129.8,80.41 129.31,80.41 128.27,81.44 128.27,81.69 127.58,82.38 v3(127.19,82.38)
  IN1 w0.099: 129.8,80.41 129.93,80.41 133.06,77.27 133.06,66.19 134.24,65.01 134.24,51.04 135.57,49.71 136.72,49.71 136.84,49.58 136.84,49.33 136.72,49.2 135.96,49.2 135.83,49.07 135.83,48.82 135.96,48.7 136.72,48.7 136.84,48.57 136.84,43.92 139.36,41.41 139.36,40.76 141.95,38.17 141.95,28.31 139.32,25.68 139.32,22.43 v3(140.75,21)
  BOTTOM w0.089: v3(127.19,82.38) 127.52,82.71 127.52,82.71 CPU1.AK2
  BOTTOM w0.127: v3(140.75,21) 140.75,21 139.73,19.98 139.73,19.79 138.35,18.4 JDIMM2.192
DDR_B_D63: length 77.8
  IN1 w0.089: v3(127.89,83.14) 128.26,82.77 128.73,82.77 129.12,82.38 129.8,82.38
  IN1 w0.099: v3(140.75,19.47) 141.45,20.18 141.45,26.55 142.94,28.03 142.94,30.82 144.67,32.55 144.67,35.21 143.37,36.51 143.37,39.56 142.56,40.36 141.81,40.36 137.73,44.44 137.73,50.68 135.13,53.28 135.13,65.38 133.98,66.53 133.98,78.42 130.03,82.38 129.8,82.38
  BOTTOM w0.089: v3(127.89,83.14) 127.19,83.14 CPU1.AK3
  BOTTOM w0.127: v3(140.75,19.47) 139.91,19.47 138.95,18.52 JDIMM2.194
DDR_B_DQS0: length 84.4
  IN1 w0.089: 90.81,85.95 90.84,85.99 90.85,85.99 90.89,86.03 90.89,86.03 91.45,86.58 92.52,86.58 v3(92.72,86.78)
  IN1 w0.099: 90.81,85.95 89.32,84.46 89.32,73.43 87.12,71.23 87.12,68.94 85.35,67.17 85.35,64.97 81.28,60.89 81.28,45.43 78.04,42.19 78.04,38.37 77.94,38.27 77.26,38.27 77.02,38.03 77.02,37.62 77.26,37.38 77.94,37.38 78.04,37.28 78.04,37.05 77.94,36.95 76.5,36.95 76.26,36.71 76.26,36.3 76.5,36.05 77.94,36.05 78.04,35.96 78.04,26.78 80.87,23.95 80.87,22.5 80.73,22.36 80.47,22.36 80.33,22.5 80.33,22.59 v3(80.45,22.72)
  BOTTOM w0.089: CPU1.AD53 93.07,86.43 v3(92.72,86.78)
  BOTTOM w0.127: JDIMM2.12 81.95,18.4 81.74,18.61 81.74,18.77 81.49,19.01 81.49,22.11 81.19,22.42 80.75,22.42 v3(80.45,22.72)
DDR_B_DQS1: length 72.7
  IN1 w0.089: 91.25,69.94 92.81,71.5 92.81,73.31 94.98,75.48 94.98,75.84 95.38,76.23 95.52,76.23 96.11,76.82 96.11,76.95 96.4,77.24 96.84,77.24 97.09,76.99 97.09,76.99 97.1,76.99 98.05,76.99 98.48,77.42 v3(98.61,77.42)
  IN1 w0.099: v3(86.17,21.96) 86.17,22.25 86.23,22.31 86.61,22.31 86.87,22.57 86.87,24.66 85,26.53 85,29.26 83.25,31.01 83.25,37.43 85.93,40.11 85.93,40.86 86.37,41.29 86.37,49.89 86.15,50.1 85.84,50.1 85.71,50.23 85.71,50.48 85.84,50.61 86.19,50.61 86.43,50.85 86.43,51.26 86.19,51.5 85.85,51.5 85.72,51.63 85.72,51.88 85.85,52.01 86.15,52.01 86.37,52.22 86.37,52.53 90.23,56.39 90.23,59.87 89.64,60.45 89.64,66.24 90.83,67.43 90.83,69.52 91.11,69.8 91.25,69.94
  BOTTOM w0.089: v3(98.61,77.42) 98.28,77.08 CPU1.AV46
  BOTTOM w0.127: JDIMM2.29 87.05,24.45 86.93,24.33 86.93,22.5 86.55,22.13 86.34,22.13 v3(86.17,21.96)
DDR_B_DQS2: length 67.3
  IN1 w0.099: v3(91.47,21.96) 91.47,22.16 91.69,22.38 91.89,22.38 92.09,22.58 92.09,24.49 89.89,26.68 89.89,30.33 88.62,31.61 88.62,37.2 90.08,38.66 92.04,40.62 92.16,40.75 92.16,46.54 93.72,48.1 93.72,49.34 93.51,49.56 92.39,49.56 92.27,49.68 92.27,49.93 92.39,50.06 93.51,50.06 93.72,50.27 93.72,50.87 93.51,51.08 92.27,51.08 92.14,51.21 92.14,51.46 92.27,51.59 93.49,51.59 93.74,51.83 93.74,52.25 93.49,52.49 92.83,52.49 92.71,52.61 92.71,52.87 92.83,52.99 93.51,52.99 93.72,53.21 93.72,63.96 94.38,64.62 94.38,67.37 95.77,68.76 95.77,70.2 96.9,71.34 96.9,71.83 96.97,71.89 v3(97.13,71.89)
  BOTTOM w0.089: CPU1.BE48 96.84,72.18 v3(97.13,71.89)
  BOTTOM w0.127: v3(91.47,21.96) 91.62,22.11 92.06,22.11 92.45,22.5 JDIMM2.47
DDR_B_DQS3: length 60.7
  IN1 w0.089: v3(100.39,72.56) 100.22,72.56 100.14,72.48 100.14,70.86 99.47,70.18 99.47,69.96 99.47,69.95 99.47,69.94
  IN1 w0.099: v3(97.31,22.72) 97.31,22.47 97.22,22.38 97.03,22.38 96.91,22.5 96.91,25.24 95.38,26.77 95.38,30.62 94.72,31.27 94.72,36.78 97.37,39.42 97.37,59.44 97.88,59.95 97.88,65.77 99.47,67.37 99.47,69.94
  BOTTOM w0.089: v3(100.39,72.56) 100.39,72.41 100.16,72.18 CPU1.BE43
  BOTTOM w0.127: v3(97.31,22.72) 97.31,22.53 97.52,22.32 97.72,22.32 98.02,22.02 98.02,20.71 97.32,20.01 97.32,18.92 97.55,18.7 JDIMM2.64
DDR_B_DQS4: length 65.3
  IN1 w0.089: 119.64,69.94 119.64,69.95 119.5,70.09 119.48,70.09 119.45,70.13 119.23,70.35 118.74,70.83 118.74,75.58 118.86,75.69 118.86,76.24 118.62,76.48 118.43,76.48 v3(118.24,76.67)
  IN1 w0.099: 119.64,69.94 119.64,69.73 119.64,57.67 121.51,55.8 121.51,46.15 122.62,45.04 122.62,40.08 124.53,38.16 124.53,31.78 123.97,31.23 123.97,28.52 124.65,27.84 124.65,27.48 123.67,26.5 123.37,26.5 123.09,26.78 122.95,26.78 122.73,26.56 122.73,26.42 123.01,26.14 123.01,25.84 122.73,25.55 122.73,22.57 122.49,22.33 122.3,22.33 v3(122.13,22.16)
  BOTTOM w0.089: v3(118.24,76.67) 118.52,76.38 CPU1.AW15
  BOTTOM w0.127: v3(122.13,22.16) 122.29,22.32 122.53,22.32 122.83,22.62 122.83,23.95 122.42,24.37 122.23,24.37 121.85,24.75 JDIMM2.137
DDR_B_DQS5: length 69.6
  IN1 w0.089: 123.18,69.94 123.18,70.2 122.67,70.71 122.67,74.26 122.44,74.49 121.84,74.49 121.37,74.96 121.37,76.38 121.47,76.47 121.47,76.6 121.32,76.75 v3(121.12,76.75)
  IN1 w0.099: 123.18,69.94 123.18,58.84 125.61,56.41 125.61,55.53 125.86,55.27 126.11,55.27 126.24,55.15 126.24,54.74 126.14,54.64 125.82,54.64 125.58,54.39 125.58,53.98 125.82,53.74 126.14,53.74 126.24,53.64 126.24,53.33 126.14,53.23 125.82,53.23 125.58,52.99 125.58,52.58 125.82,52.34 126.14,52.34 126.24,52.24 126.24,46.14 126.9,45.48 126.9,40.5 129.77,37.63 129.77,31.42 129.29,30.94 128.94,30.94 128.27,30.27 128.27,20.81 127.98,20.52 127.49,20.52 127.29,20.72 v3(127.29,20.93)
  BOTTOM w0.089: CPU1.AW12 120.65,76.38 121.02,76.75 v3(121.12,76.75)
  BOTTOM w0.127: v3(127.29,20.93) 127.41,20.81 127.81,20.81 128.13,20.49 128.13,19.27 127.63,18.77 127.4,18.77 127.36,18.73 127.12,18.73 126.95,18.56 JDIMM2.154
