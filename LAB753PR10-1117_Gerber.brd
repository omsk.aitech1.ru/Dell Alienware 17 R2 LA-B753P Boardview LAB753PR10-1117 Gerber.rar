# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N198547586: length 1.2
  TOP w0.089: T68.1 220.62,32.08 v3(220.27,32.43)
  BOTTOM w0.089: v3(220.27,32.43) 220.39,32.43 UH1.AD10
N198588020: length 8.1
  BOTTOM w0.089: UH1.Y3 222.34,29.92 222.34,29.45 222.59,29.2 222.59,28.98 222.35,28.73 222.35,27.65
  BOTTOM w0.127: 222.35,27.65 222.35,26.71 222.79,26.27 224.56,26.27 225.11,25.72 225.11,25.11 225.44,24.78 RH83.1
N198588843: length 1.2
  TOP w0.089: T82.1 220.61,45.82 v3(220.28,45.49)
  BOTTOM w0.089: v3(220.28,45.49) 220.61,45.17 UH1.AD39
N198588869: length 1.2
  TOP w0.089: T84.1 220.44,44.87 v3(220.28,44.87)
  BOTTOM w0.089: UH1.AD38 220.46,44.87 v3(220.28,44.87)
N198608694: length 7.3
  BOTTOM w0.089: 212.84,48.48 213.46,47.85 UH1.BA45
  BOTTOM w0.127: T85.1 208.73,51.17 210.63,49.27 212.05,49.27 212.84,48.48
N198608700: length 5.4
  BOTTOM w0.089: UH1.BC45 212.87,48.09 212.48,48.48
  BOTTOM w0.127: T86.1 210.12,49.01 211.95,49.01 212.48,48.48
N198608716: length 4.4
  BOTTOM w0.127: UH1.BE43 211.51,46.83 210.83,46.83 209.82,47.84 208.24,47.84 T87.1
N198608718: length 5.4
  BOTTOM w0.127: T88.1 208.4,48.2 209.98,48.2 211.01,47.18 UH1.BE44
N198628812: length 1.7
  TOP w0.089: T91.1 212.7,41.86 v3(212.92,41.65)
  BOTTOM w0.089: v3(212.92,41.65) 212.66,41.39 UH1.BC30
N198628814: length 1.1
  TOP w0.089: v3(213.32,41.26) 213.24,41.18 T92.1
  BOTTOM w0.089: v3(213.32,41.26) 213.09,41.03 UH1.BB29
N198628819: length 1.9
  TOP w0.089: T89.1 225.26,43.54 v3(225.73,43.07)
  BOTTOM w0.089: UH1.M33 225.41,42.75 v3(225.73,43.07)
N198628821: length 1.2
  TOP w0.089: v3(226.3,43.09) 226.44,43.23 T90.1
  BOTTOM w0.089: UH1.L33 226.06,42.85 v3(226.3,43.09)
N201379861: length 2.6
  TOP w0.089: v3(223.82,45.58) 223.7,45.7 v1(223.7,46.55) 223.7,47.31 RH39.2
  BOTTOM w0.254: UH1.U40 223.63,45.77 v3(223.82,45.58)
N201503343: length 4.9
  BOTTOM w0.089: UH1.C40 229.87,45.3 230.24,45.67 230.58,45.67 230.85,45.94 230.85,46.06 231.02,46.23
  BOTTOM w0.127: 231.02,46.23 231.07,46.28 232.29,46.28 233.25,47.25 T80.1
N201737633: length 1.1
  BOTTOM w0.127: v1(130.95,130.74) 131.73,129.96
N201737689: length 1.3
  BOTTOM w0.127: PR550.1 134.07,121.15 v1(133.17,120.25)
N201737828: length 7.2
  BOTTOM w0.127: v1(134.74,118.16) 135.1,118.16 136.15,119.21 PR526.1
  BOTTOM w0.203: 136.59,122.39 136.74,122.54 136.74,123.73 PU500.17
  BOTTOM w0.254: PR526.1 135.97,120.23 135.97,121.03 135.94,121.06 PC511.1 135.94,121.74 136.59,122.39
N201737837: length 2.3
  BOTTOM w0.203: PU500.28 134.65,128.93 134.49,128.93 PR507.2
N201737838: length 2.6
  BOTTOM w0.203: PR512.2 135.43,129.28 v1(135.62,129.1) PU500.30
N201737840: length 2.4
  BOTTOM w0.203: PR509.2 134.82,129.33 136.15,128
N201737896: length 2
  TOP w0.127: PR533.1 141.56,127.87 v1(141.35,128.07)
  TOP w0.254: PC520.2 141.61,127.04 PR533.1
N201737910: length 2.2
  TOP w0.127: v1(139.61,124.28) 139.61,124.56 139.14,125.04
  TOP w0.254: PR543.1 139.14,126.31 139.14,125.04
N201737914: length 2.2
  BOTTOM w0.127: PC526.2 v1(147.22,123.04)
  BOTTOM w0.254: PR539.1 146.36,124.34 PC526.2
N201737923: length 2.6
  TOP w0.254: 138.25,127.47 138.65,127.07 v1(139.71,127.07) 140.21,126.57 v3(140.21,126.33)
N201737985: length 3.3
  BOTTOM w0.203: PU500.14 138.47,124.55 139.19,123.83 v1(139.19,123.7) 139.19,122.85
  BOTTOM w0.254: PR535.1 139.89,121.91 PC521.1 139.19,122.6 139.19,122.85
N201737986: length 0.9
  BOTTOM w0.254: PR545.2 138.66,121.84 PC521.2
N201738002: length 11.5
  TOP w0.127: v1(137,120.17) 137.9,120.17 PC538.1
  TOP w0.254: PC538.1 137.64,121.6 PC529.1 137.63,122.42 v3(137.73,122.52)
  IN1 w0.254: v3(143.23,120.36) 142.77,120.36 142.35,119.94 140.31,119.94 v3(137.73,122.52)
  BOTTOM w0.254: PR548.2 143.01,120.58 v3(143.23,120.36)
N201738025: length 6.7
  BOTTOM w0.203: PU500.16 137.91,123.99 138.17,123.73 138.17,123.61 137.28,122.72 v1(137.28,121.91)
  BOTTOM w0.254: v1(137.28,121.91) 136.78,121.42 136.78,119.81 PC518.1 136.33,118.49 PR530.1
N201738085: length 1.4
  TOP w0.127: PC501.1 100.41,117.06 v1(100.19,117.27)
N205002433: length 1
  TOP w0.127: CH11.1 RH108.1
N206180145: length 4.7
  TOP w0.127: PC626.1 182.55,16.35 v1(182.55,16.13)
  TOP w0.254: PQ610.2 180.96,17.49 181.22,17.24 PC626.1 PR631.1 PR620.2
N206181687: length 2.7
  TOP w0.254: PQ610.1 178.06,18.14 177.81,18.38 v1(177.81,18.99) 177.81,19.5 PR623.2
N212152397: length 5.6
  BOTTOM w0.127: JRTC1.1 262.02,10.4 261.79,10.63 261.79,12.37 v1(261.05,13.11) PR2.2
N213961754: length 7.8
  TOP w0.127: v1(74.93,27.47) 74.39,26.93 PC14.2
  TOP w0.254: PQ8.2 72.07,23.34 PR28.2 72.15,24.6 71.62,25.14 71.62,25.71 72.27,26.35 73.03,26.35 PC14.2
N215666090: length 10.5
  BOTTOM w0.089: UH1.AA2 221.96,29.47 221.96,28.89 221.56,28.48 221.56,28.15 221.85,27.85
  BOTTOM w0.127: RH81.2 224.97,22.38 224.97,24.89 224.88,24.97 224.88,25.63 224.47,26.04 222.69,26.04 222.12,26.62 222.12,27.71 221.97,27.85 221.85,27.85
N215666239: length 6.4
  BOTTOM w0.089: UH1.AE4 220.25,29.93 219.97,29.65 219.97,29.39 220.17,29.19 220.17,28.81 220.26,28.72 220.26,27.5 220.28,27.48
  BOTTOM w0.127: RH82.2 220.72,26.28 220.3,26.7 220.3,27.46 220.28,27.48
N219840090: length 1.2
  TOP w0.089: v3(221.02,30.61) 221.39,30.24 T67.1
  BOTTOM w0.089: UH1.AB6 221.37,30.97 v3(221.02,30.61)
N303520630: length 2.2
  TOP w0.127: C2506.1 57.43,14.11 56.31,14.11 56.22,14.02 U17.12
N303520770: length 2.1
  TOP w0.127: U17.10 57.44,13.22 C2507.1
N359184751: length 4.7
  BOTTOM w0.127: UV2.3 91.34,127.6 RV2.1 89.61,129.69 v1(90.16,130.24)
N359204640: length 2.7
  BOTTOM w0.127: v1(193.36,135.16) 193.36,134.75 193.18,134.57 RT11.1 193.51,134.11 193.74,134.34 193.74,134.56 193.95,134.77 UT1.3
N384977821: length 3.3
  TOP w0.127: PC628.1 v2(194.76,47.4)
  TOP w0.508: PR640.2 194.2,45.87 PC628.1
N384979741: length 3.6
  TOP w0.127: PR608.2 177.99,47.14 v1(178.06,47.21)
  TOP w0.254: PC615.1 178.84,44.77 178.52,45.09 PR608.2
N384981221: length 1.7
  TOP w0.254: PR626.2 186.2,46.28 PC621.1

## Copper pours and planes (outline as drawn)
1.35V_B+ on TOP (solid shape): 153.8,43.92 153.8,43.03 153.41,42.64 149.24,42.64 148.97,42.37 148.97,40.82 148.92,40.76 148.35,40.76 148.08,40.5 148.08,37.6 147.94,37.45 145.38,37.45 145.11,37.71 145.11,39.37 147.24,41.49 147.24,43.38 147.39,43.53 148.75,43.53 148.76,43.54 148.76,44.08 148.93,44.08 148.93,43.53 148.94,43.53 149.6,43.53 150.23,44.16 153.56,44.16
2.5VOUT on BOTTOM (solid shape): 155.95,128.77 155.95,128.66 155.93,128.64 155.82,128.37 155.95,128.11 155.95,127.7 155.83,127.59 153.9,127.59 153.75,127.74 153.75,128.74 153.9,128.89 155.82,128.89
3/5V_B+ on TOP (solid shape): 40.64,31.33 40.64,27.14 40.45,26.95 38.86,26.95 38.67,26.76 38.67,25.11 38.1,24.54 34.86,24.54 34.55,24.86 34.55,26.95 34.8,27.21 36.01,27.21 36.26,27.46 36.26,30.06 36.39,30.19 36.39,33.17 36.51,33.3 38.67,33.3
3/5V_B+ on BOTTOM (solid shape): 41.28,34.7 41.28,24.28 40.13,23.14 38.1,23.14 38.04,23.2 38.04,24.35 37.75,24.64 37.75,34.85 37.91,35.02 40.96,35.02
3/5V_B+ on IN1 (solid shape): 40.14,32.07 40.14,30.6 40.58,30.15 40.58,26.17 40.25,25.84 37.34,25.84 36.96,26.22 36.96,31.75 37.58,32.37 39.83,32.37
3/5V_B+ on IN2 (solid shape): 40.64,32.43 40.64,26.92 40.21,26.49 37.71,26.49 37.15,27.05 37.15,32.45 37.37,32.66 40.42,32.66
3/5V_B+ on IN3 (solid shape): 40.64,32.43 40.64,26.92 40.21,26.49 37.71,26.49 37.15,27.05 37.15,32.45 37.37,32.66 40.42,32.66
3/5V_B+ on IN4 (solid shape): 40.64,32.43 40.64,26.92 40.21,26.49 37.71,26.49 37.15,27.05 37.15,32.45 37.37,32.66 40.42,32.66
3/5V_B+ on IN5 (solid shape): 40.64,32.43 40.64,26.92 40.21,26.49 37.71,26.49 37.15,27.05 37.15,32.45 37.37,32.66 40.42,32.66
3/5V_B+ on IN6 (solid shape): 40.64,32.43 40.64,26.92 40.21,26.49 37.71,26.49 37.15,27.05 37.15,32.45 37.37,32.66 40.42,32.66
3VALW_PCH on TOP (solid shape): 218.93,15.7 219.44,15.7 219.44,16.25 219.73,16.25 219.73,15.7 220.24,15.7 220.24,16.25 221.03,16.25 221.3,15.98 221.3,14.74 221.13,14.44 221.3,14.14 221.3,13.69 220.91,13.3 219.08,13.3 219,13.38 219,14.58 218.44,15.14 218.44,16.16 218.53,16.25 218.93,16.25
3VS on TOP (solid shape): 57.06,12.83 57.06,12.65 57.29,12.42 58.06,12.42 58.3,12.19 58.3,10.9 57.78,10.9 57.78,10.4 58.3,10.4 58.3,10.1 57.78,10.1 57.78,9.6 58.3,9.6 58.3,9.13 58.25,9.11 58.2,9.08 58.16,9.05 58.13,9.01 58.1,8.97 58.08,8.92 58.07,8.89 55.91,8.89 55.5,9.3 55.5,9.93 55.78,9.93 55.78,9.88 55.8,9.83 55.81,9.78 55.84,9.73 55.87,9.69 55.91,9.65 55.96,9.62 56.01,9.6 56.06,9.59 56.11,9.58 56.16,9.58 56.22,9.59 56.27,9.6 56.31,9.62 56.36,9.65 56.4,9.69 56.43,9.73 56.46,9.78 56.48,9.83 56.49,9.88 56.49,9.93 56.49,9.99 56.48,10.04 56.46,10.09 56.43,10.13 56.4,10.18 56.36,10.21 56.31,10.24 56.27,10.27 56.22,10.28 56.16,10.29 56.11,10.29 56.06,10.28 56.01,10.27 55.96,10.24 55.91,10.21 55.87,10.18 55.84,10.13 55.81,10.09 55.8,10.04 55.78,9.99 55.78,9.93 55.5,9.93 55.5,11.84 55.25,12.09 55.25,12.85 55.31,12.92 56.23,12.92 56.34,13.03 56.87,13.03
5VS on TOP (solid shape): 58.3,17.68 58.3,16.87 57.78,16.87 57.78,16.37 58.3,16.37 58.3,16.07 57.78,16.07 57.78,15.57 58.3,15.57 58.3,15.07 58.11,14.89 57.34,14.89 56.77,14.31 55.3,14.31 55.24,14.38 55.24,14.86 55.34,14.97 55.8,14.97 55.94,15.11 55.94,15.15 55.98,15.33 55.95,15.49 55.94,15.51 55.94,17.67 56.14,17.87 58.1,17.87
+0.675VS on TOP (solid shape): 143.19,24.74 143.19,22.51 142.75,22.06 142.75,21.43 143.39,20.78 143.39,16.93 143.26,16.79 142.62,16.79 142.62,16.8 141.78,16.8 141.19,17.39 141.19,23.24 141.35,23.4 141.35,24.72 141.53,24.91 143.02,24.91
+0.675VS on TOP (solid shape): outline of 94 points within 141.56,29.1 146.83,39.52
+0.675VS on BOTTOM (solid shape): outline of 355 points within 141.44,16.53 145.86,39.94
+0.675VSP on TOP (solid shape): 148.16,35.76 148.16,32.86 150.05,30.98 150.14,30.98 150.2,30.93 150.2,30.14 150.13,30.07 149.01,30.07 149.01,30.09 148.4,30.34 148.66,29.73 148.69,29.73 148.76,29.66 148.92,29.5 149.76,29.5 149.79,29.47 149.79,29.3 149.76,29.27 148.62,29.27 148.28,29.39 148.01,29.15 147.99,29.11 147.2,29.11 146.98,29.33 146.98,34.25 146.43,34.8 146.43,35.43 146.95,35.43 146.95,35.87 146.43,35.87 146.43,36.23 146.55,36.35 147.58,36.35
+1.2VS on TOP (solid shape): 15.49,19 15.6,19 15.98,18.62 15.98,18.04 16.05,17.97 16.53,17.97 16.58,17.92 16.58,17.74 16.53,17.7 15.58,17.7 15.47,17.81 15.47,18.2 15.23,18.44 15.15,18.44 15.15,18.44 14.58,18.44 14.45,18.57 14.45,18.83 14.51,18.9 14.56,18.99 14.57,19 15.48,19
+1.2VS on TOP (solid shape): 15.05,17.54 15.05,17.26 14.9,17.1 14.9,16.92 14.86,16.89 14.83,16.85 14.81,16.82 14.79,16.78 14.77,16.75 14.77,16.54 14.8,16.5 14.81,16.49 14.88,16.4 14.97,16.33 14.98,16.33 15.38,15.92 16.51,15.92 16.6,15.83 16.6,15.75 16.53,15.68 14.89,15.68 14.57,16 14.51,16.07 14.43,16.13 14.43,16.82 14.59,17.08 14.5,17.37 14.5,17.57 14.59,17.66 14.93,17.66
+1.2VS on BOTTOM (solid shape): 19.88,19.9 19.88,17.62 19.07,16.81 18.3,16.81 18.24,16.81 18.04,16.6 18.04,15.25 17.95,15.17 17.18,15.17 17.18,15.17 17.09,15.17 17.02,15.25 17.02,16.82 16.45,17.39 16.45,17.87 16.02,18.3 15.39,18.3 15.26,18.43 15.11,18.43 15.01,18.53 14.64,18.53 14.57,18.61 14.57,18.99 14.64,19.06 15.01,19.06 15.07,19.13 15.19,19.25 18.21,19.25 19.03,20.07 19.71,20.07
+1.2VS on BOTTOM (solid shape): 24.01,16.48 24.01,15.98 24.18,15.81 24.59,15.81 25.18,15.22 25.18,14.59 25.59,14.19 25.59,14.19 25.68,14.1 26.46,14.1 26.54,14.02 26.54,13.6 26.48,13.54 25.18,13.54 24.8,13.92 24.76,14 24.73,14.04 24.71,14.06 24.34,14.43 23.54,14.43 23.41,14.56 23.4,14.57 23.38,14.59 22.93,14.59 22.86,14.65 22.86,15.3 23.55,15.3 23.55,15.25 23.56,15.19 23.57,15.14 23.6,15.1 23.63,15.05 23.66,15.01 23.7,14.98 23.75,14.95 23.8,14.93 23.85,14.92 23.9,14.92 23.96,14.92 24.01,14.93 24.06,14.95 24.1,14.98 24.15,15.01 24.18,15.05 24.21,15.1 24.24,15.14 24.25,15.19 24.26,15.25 24.26,15.3 24.25,15.35 24.24,15.4 24.21,15.45 24.18,15.5 24.15,15.54 24.1,15.57 24.06,15.6 24.01,15.62 23.96,15.63 23.9,15.63 23.85,15.63 23.8,15.62 23.75,15.6 23.7,15.57 23.66,15.54 23.63,15.5 23.6,15.45 23.57,15.4 23.56,15.35 23.55,15.3 22.86,15.3 22.86,16.18 22.86,16.19 22.86,16.41 22.98,16.53 22.99,16.53 23.07,16.61 23.89,16.61
+1.2VS on IN4 (solid shape): outline of 533 points within 14.46,12.98 24.78,19.01
+1.05V_+1.5V_RUN on TOP (solid shape): outline of 107 points within 211.95,44.59 215.02,48.56
+1.05V_+1.5V_RUN on IN2 (solid shape): outline of 1818 points within 210.67,37.43 220.78,47.58
+1.05V_GPUP_B+ on BOTTOM (solid shape): 138.77,91.56 138.77,90.69 139.7,89.76 140.27,89.76 140.42,89.61 140.42,88.52 140.3,88.41 139.1,88.41 138.59,88.92 137.58,88.92 137.58,88.41 137.29,88.41 137.29,88.92 136.78,88.92 136.78,88.41 136.49,88.41 136.49,88.92 135,88.92 134.8,89.13 134.8,91.48 134.99,91.67 138.66,91.67
+1.05VS on TOP (solid shape): 204.42,37.6 204.42,36.78 204.73,36.48 204.73,35.44 204.52,35.23 203.79,35.23 202.76,36.26 202.76,37.57 202.9,37.71 204.31,37.71
+1.05VS on TOP (solid shape): 243.08,23.13 243.08,21.31 243.39,21 243.39,18.78 243.22,18.61 242.82,18.61 242.58,18.37 240.39,18.37 240.12,18.64 240.12,22.55 240.87,23.31 242.91,23.31
+1.5VS on TOP (solid shape): 107.02,140.8 107.91,140.8 107.97,140.74 107.97,140.65 107.91,140.59 106.72,140.59 106.64,140.67 106.38,140.67 105.88,140.17 105.69,140.17 105.56,140.3 105.56,140.92 105.82,141.18 106.64,141.18
+1.05VS on TOP (solid shape): 219.14,59.46 219.14,55.4 219.01,55.27 216.16,55.27 215.97,55.46 215.97,56.92 216.09,57.05 216.28,57.05 216.35,57.11 216.35,58.38 216.28,58.45 214.19,58.45 214.06,58.57 214.06,59.68 214.12,59.74 218.86,59.74
+1.05VS on TOP (solid shape): 239.59,35.84 239.65,35.78 243.87,35.78 244.1,35.55 244.1,34.4 243.91,34.21 238.87,34.21 238.51,34.57 238.51,36.15 238.57,36.21 239.22,36.21
+1.5VS on TOP (solid shape): 207.81,26.16 207.81,25.04 208.18,24.67 208.18,24.2 208.14,24.16 207.1,24.16 207.09,24.16 207.02,24.16 206.8,24.39 206.73,24.59 206.57,24.72 206.57,26.19 206.72,26.34 207.63,26.34
+1.05VS on TOP (solid shape): 218.86,38.44 218.86,38.06 218.61,37.81 218.35,37.81 218.25,37.71 218.25,37.7 218.16,37.6 218.16,36.46 218.07,36.38 217.71,36.38 217.66,36.33 217,36.33 216.83,36.5 216.83,36.76 216.58,37.01 215.91,37.01 215.6,37.32 215.6,37.7 215.73,37.84 215.81,37.84 216,38.03 216,38.43 216.17,38.6 218.71,38.6
+1.05VS on BOTTOM (solid shape): 149.82,98.68 149.82,94.81 149.56,94.54 147.58,94.54 147.27,94.85 147.27,97.21 147.41,97.35 148,97.35 148.08,97.43 148.08,98.6 148.26,98.78 149.72,98.78
+1.05VS on BOTTOM (solid shape): 223.51,41.52 223.51,41.33 223.69,41.15 223.69,40.99 223.69,40.98 223.69,40.85 222.96,40.12 222.8,40.12 222.05,40.87 222.05,41.16 222.25,41.37 222.25,41.56 222.42,41.72 222.68,41.72 222.77,41.63 222.98,41.63 223.07,41.73 223.3,41.73
+1.05VS on BOTTOM (solid shape): 223.69,43.87 223.98,43.87 224.06,43.78 224.06,43.45 224.05,43.38 224.06,43.31 224.06,42.89 223.92,42.75 223.72,42.75 223.52,42.94 223.49,42.98 223.16,43.31 223.16,43.55 223.17,43.63 223.16,43.71 223.16,44.03 223.27,44.14 223.42,44.14
+1.05VS on BOTTOM (solid shape): 242.83,22.82 242.83,21.54 242.81,21.52 242.28,21.52 242.28,21.52 242.28,20.83 242.33,20.78 242.81,20.78 242.82,20.76 242.82,20.33 242.81,20.31 242.3,20.31 242.27,20.29 242.27,19.6 242.29,19.58 242.81,19.58 242.82,19.56 242.82,18.63 242.4,18.21 240.33,18.21 240.14,18.39 240.14,22.57 240.71,23.14 242.51,23.14
+1.05VS on BOTTOM (solid shape): 223.68,38.71 223.68,38.56 223.52,38.41 223.52,38.08 223.69,37.91 223.69,37.12 224.07,36.73 224.07,36.54 224.35,36.27 224.35,36.27 224.39,36.23 224.39,36.11 224.32,36.05 221.47,36.05 221.38,36.13 221.38,36.28 221.48,36.38 221.92,36.38 222.03,36.5 222.03,37.9 222.28,38.15 222.28,38.32 222.77,38.81 222.93,38.81 223.05,38.69 223.34,38.69 223.46,38.82 223.58,38.82
+1.05VS on BOTTOM (solid shape): 217.71,38.07 217.75,38.03 217.75,37.31 217.87,37.19 218.33,37.19 218.41,37.1 218.41,36.96 218.23,36.78 218.23,36.46 218.41,36.28 218.41,36.11 218.32,36.02 217.16,36.02 216.87,36.31 216.87,36.94 216.88,36.96 216.88,37.25 216.61,37.35 216.6,37.35 216.15,37.35 216.08,37.36 216,37.35 215.81,37.35 215.72,37.38 215.68,37.41 215.64,37.45 215.59,37.54 215.59,37.65 215.6,37.71 215.58,37.73 215.58,37.74 215.32,38.01 215.32,38.18 215.42,38.27 217.51,38.27
+1.05VS on BOTTOM (solid shape): 221.05,40.37 221.05,40.15 220.9,39.96 220.93,39.72 220.93,39.7 220.99,39.64 221.04,39.6 221.22,39.54 221.41,39.6 221.46,39.64 221.48,39.67 221.64,39.82 221.64,40.03 221.65,40.04 221.71,40.08 221.75,40.13 222,40.13 222.14,39.99 222.14,39.8 222.37,39.57 222.37,39.4 221.72,38.75 221.72,38.58 221.08,37.93 221.08,36.97 220.82,36.71 220.82,36.54 220.34,36.07 220.34,36.06 219.5,36.06 219.4,36.16 219.4,37.91 219.58,38.09 219.41,38.55 219.41,38.74 219.81,39.15 219.83,39.16 219.83,39.58 219.81,39.6 219.64,39.77 219.64,39.99 219.76,40.1 220.03,40.1 220.11,40.02 220.37,40.02 220.8,40.45 220.97,40.45
+1.05VS on IN1 (solid shape): 225.35,37.43 225.37,37.38 225.41,37.34 225.44,37.3 225.49,37.27 225.54,37.25 225.59,37.23 225.64,37.22 225.7,37.22 225.75,37.23 225.8,37.25 225.85,37.27 225.89,37.3 225.92,37.33 225.97,37.35 226.07,37.25 226.07,36.47 225.98,36.38 225.27,36.38 224.94,36.05 222.53,36.05 222.31,36.27 222.31,36.63 224.11,36.63 224.12,36.57 224.13,36.52 224.15,36.47 224.17,36.42 224.21,36.37 224.25,36.34 224.29,36.3 224.34,36.28 224.4,36.26 224.45,36.25 224.51,36.25 224.56,36.25 224.62,36.27 224.67,36.29 224.71,36.32 224.76,36.35 224.79,36.4 224.83,36.44 224.85,36.49 224.87,36.55 224.87,36.6 224.87,36.66 224.87,36.71 224.85,36.76 224.83,36.82 224.79,36.86 224.76,36.9 224.71,36.94 224.67,36.97 224.62,36.99 224.56,37 224.51,37.01 224.45,37.01 224.4,37 224.34,36.98 224.29,36.95 224.25,36.92 224.21,36.88 224.17,36.84 224.15,36.79 224.13,36.74 224.12,36.68 224.11,36.63 222.31,36.63 222.31,37.31 222.49,37.49 225.32,37.49
+1.05VS on IN2 (solid shape): 223.43,38.53 223.54,38.48 223.55,38.36 223.69,37.97 224.1,38.02 224.19,38.06 224.29,38.02 224.7,37.97 224.83,38.36 224.85,38.48 224.95,38.53 226.15,38.53 226.51,38.18 226.51,38.02 226.46,37.92 226.35,37.9 226.29,37.91 226.16,37.9 226.05,37.83 225.97,37.8 225.88,37.83 225.34,37.58 225.88,37.33 225.97,37.36 226.05,37.33 226.22,37.25 226.41,37.29 226.43,37.29 226.51,37.29 226.51,37.19 226.23,36.91 226.19,36.88 226.16,36.84 226.04,36.72 226.04,36.48 225.85,36.29 224.9,36.29 224.79,36.35 224.78,36.47 224.49,36.96 224.2,36.47 224.2,36.35 224.09,36.29 222.52,36.29 222.32,36.49 222.32,38.32 222.53,38.53
+1.5VS on IN2 (solid shape): outline of 1281 points within 203.39,25.11 216.07,49.07
+1.05VS on IN5 (solid shape): 196.94,22.93 196.94,20.92 196.71,20.69 193.85,20.69 193.69,20.86 193.69,23.29 193.89,23.49 196.37,23.49
+1.05VS on IN5 (solid shape): 242.65,22.86 242.65,20.5 241.72,19.58 241.72,18.92 241.51,18.7 240.16,18.7 239.9,18.96 239.9,20.62 240.08,20.79 240.08,22.5 240.94,23.36 242.16,23.36
+1.5VS on IN6 (solid shape): 214.54,52.96 214.54,52.11 216.07,50.57 216.07,48.9 215.78,48.61 215.55,48.61 212.03,52.13 212.03,52.88 212.28,53.13 214.37,53.13
+1.05VS on IN6 (solid shape): outline of 1383 points within 215.51,35.82 224.51,44.66
+1.5VS on TOP: 107.9,138.03 106.53,138.03 106.4,137.89 106.4,136.99 106.59,136.79 106.97,136.79 107.52,137.34 107.91,137.34 107.99,137.42 107.99,137.94
+1.5VS on BOTTOM: 105.02,141.94 106.63,141.94 106.75,141.82 106.75,140.74 106.63,140.63 106.39,140.63 105.93,140.17 105.16,140.17 104.98,140.35 104.98,141.9
+1.5VS on BOTTOM: 107.06,139.56 107.71,139.56 107.8,139.47 107.8,137.67 106.94,136.81 106.48,136.81 106.15,137.14 106.15,138.51 106.94,139.3 106.94,139.44
+1.5VS on IN2: 106.04,141.49 105.63,141.08 105.63,135.98 107.22,134.38 114.69,134.38 115.7,135.39 115.7,136.93 115.03,137.6 115.03,140.42 113.82,141.62 112.45,141.62 112.18,141.35 112.18,137.55 111.87,137.25 108.2,137.25 107.97,137.47 107.97,141.09 107.57,141.49
+1.05VS on VCC: 192.7,18.32 190.69,20.33 190.69,30.51 196.13,30.51 197.91,32.29 199.81,32.29 212.13,44.6 235.04,44.6 244.29,35.36 244.29,20.58 243.29,19.59 235.12,19.59 231.06,23.65 208.88,23.65 203.54,18.32
+1.05VS on IN3: outline of 151 points within 142.86,19.57 196.8,100.39
+1.05VS on IN4: outline of 197 points within 143.17,21.07 196.8,100.4
+1.05VS_VGA on TOP (solid shape): outline of 1132 points within 152.42,85.21 170.38,100.97
+1.05VS_VGA on BOTTOM (solid shape): outline of 128 points within 143.89,91.74 159.23,97.99
+1.05VS_VGA on IN1 (solid shape): outline of 2076 points within 153.7,85.03 170.17,98.03
+1.05VS_VGA on IN6 (solid shape): outline of 2106 points within 152.7,84.53 169.61,98.03
+1.05VS_VGAP on BOTTOM (solid shape): 143.76,97.76 143.76,96.39 144.31,96.39 144.31,95.9 143.76,95.9 143.76,95.19 144.31,95.19 144.31,94.7 143.76,94.7 143.76,90.55 143.51,90.3 140.89,90.3 140.69,90.51 140.69,97.86 140.77,97.95 143.57,97.95
+1.5VSP on TOP (solid shape): outline of 133 points within 204.5,21.24 208.58,24.42
+1.05VSP on BOTTOM (solid shape): 251.02,22.38 251.02,19.36 250.75,19.09 248.21,19.09 247.49,19.81 244.52,19.81 243.65,18.95 242.95,18.95 242.95,19.62 242.94,19.63 242.94,19.7 242.87,19.7 242.86,19.71 242.42,19.71 242.42,20.19 242.86,20.19 242.87,20.2 242.94,20.2 242.94,20.26 242.95,20.28 242.95,20.81 242.94,20.82 242.94,20.9 242.86,20.9 242.86,20.9 242.42,20.9 242.42,21.38 242.95,21.38 242.95,21.48 242.96,21.48 242.96,22.69 243.14,22.87 250.52,22.87
+1.05VSP_B+ on BOTTOM (solid shape): 253.1,30.17 253.1,28.78 253,28.67 251.87,28.67 251.23,28.04 251.23,25.98 251.18,25.93 248.89,25.93 248.72,26.11 248.72,27.97 248.44,28.25 246.96,28.25 246.87,28.34 246.87,29.83 246.9,29.86 247.39,29.86 247.39,29.32 247.82,29.32 247.82,29.86 252.09,29.86 252.45,30.22 253.05,30.22
+1.35V on TOP (solid shape): outline of 9696 points within 99.51,14.72 146.72,51.21
+1.35V on BOTTOM (solid shape): 150.22,49.2 150.22,48.59 149.65,48.59 149.65,47.82 150.22,47.82 150.22,47.4 149.65,47.4 149.65,46.62 150.22,46.62 150.22,45.6 149.18,44.55 149.18,41.75 148.64,41.22 145.52,41.22 145.04,41.71 145.04,47.91 145.36,48.23 148.27,48.23 149.35,49.32 150.1,49.32
+1.35V on BOTTOM (solid shape): 121.29,45.71 121.29,43.37 120.31,42.39 116.68,42.39 116.19,41.9 116.19,40.19 115.98,39.98 113.83,39.98 113.28,40.54 113.28,41.79 112.9,42.18 112.63,42.18 112.12,42.44 111.59,42.24 111.55,42.2 111.24,42.2 111.22,42.18 110.93,42.18 110.44,41.69 110.44,40.55 110.06,40.16 102.38,40.16 101.76,40.79 101.76,43.27 102.32,43.83 119.8,43.83 120.42,44.45 120.42,45.68 120.57,45.83 121.17,45.83
+1.35V on BOTTOM (solid shape): 113.89,16.35 118.01,16.35 118.19,16.17 118.19,15.61 118.59,15.2 118.59,13.02 118.56,12.93 118.47,12.9 117.88,12.63 118.47,12.36 118.56,12.32 118.59,12.23 118.59,11.47 117.95,10.83 117.91,10.83 117.9,10.82 115.31,10.82 114.84,11.29 114.84,13.45 114.11,14.19 103.66,14.19 103.06,14.78 103.06,16.35 103.16,16.44 113.79,16.44
+1.35V on VCC: 100.23,15.9 100.23,25.93 98.57,27.59 98.57,29.54 99.05,30.02 99.05,38.01 100.01,38.97 100.01,64.86 101.68,66.52 101.68,70.15 102.2,70.67 102.2,79.28 116.26,79.28 116.26,69.92 117.12,69.06 117.12,56.88 119.12,54.89 119.12,45.22 120.33,44 120.33,38.14 120.91,37.57 120.91,31.08 120.33,30.51 120.33,27.49 119.57,26.73 119.57,15.9
+1.35V_CPU_VDDQ on TOP (solid shape): outline of 6010 points within 102.49,49.78 125.71,80.33
+1.35VP on TOP (solid shape): 148.06,28.35 148.8,28.35 148.87,28.28 149.73,28.28 149.79,28.23 149.79,27.96 149.67,27.85 147.41,27.85 147.36,27.89 147.36,28.37 147.47,28.48 147.94,28.48
+1.35VP on TOP (solid shape): 150.55,32.23 150.63,32.15 150.63,30.14 150.57,30.08 150.43,30.08 150.38,30.13 150.38,30.92 150.12,31.19 150.12,32.18 150.16,32.23
+1.35VP on BOTTOM (solid shape): 153.94,54.14 153.94,51.22 154.63,50.53 154.63,46.74 155.14,46.24 155.14,42.41 154.43,41.7 150.48,41.7 149.51,42.67 149.51,44.57 150.36,45.42 150.36,49.91 148.99,51.28 148.99,54.28 149.23,54.52 153.56,54.52
+1.35VP on IN1 (solid shape): 150.74,32.19 150.74,30.98 150.54,30.78 149.39,30.78 149.24,30.94 149.24,32.33 149.43,32.52 150.41,32.52
+1.35VP on IN1 (solid shape): 155.16,44.99 155.16,44.19 154.98,44 153.83,44 153.67,44.16 153.67,45.55 153.71,45.59 154.56,45.59
+1.35VS_VGA on TOP (solid shape): 190.17,124.65 190.33,124.59 190.49,124.62 191.02,124.62 191.25,124.39 191.25,123.85 191.18,123.78 190.06,123.78 189.98,123.86 189.98,124.51 190.11,124.65
+1.35VS_VGA on TOP (solid shape): 221.59,70.64 221.67,70.49 221.83,70.4 222.46,69.77 222.46,69.39 222.32,69.24 222.32,68.98 222.07,68.73 221.15,68.73 220.99,68.89 220.99,69.64 220.88,69.75 220.88,70.06 220.96,70.13 220.96,70.21 220.98,70.32 220.96,70.44 220.96,70.46 220.5,70.92 220.5,71.1 220.74,71.34 220.89,71.34
+1.35VS_VGA on TOP (solid shape): 186.5,119.48 186.5,119.38 186.47,119.36 186.36,119.24 186.32,119.08 186.29,118.99 186.21,118.95 186.01,118.82 185.99,118.58 185.99,118.33 184.98,118.33 184.87,118.4 184.87,118.53 184.9,118.58 184.92,118.64 184.96,118.72 185.04,118.75 185.28,118.84 185.38,119.08 185.41,119.16 185.49,119.21 185.66,119.31 185.72,119.51 185.72,119.54 185.81,119.64 186.34,119.64
+1.35VS_VGA on TOP (solid shape): 169.61,118.39 169.61,117.81 169.2,117.41 169.15,117.35 169.07,117.35 168.87,117.31 168.75,117.15 168.74,117.13 168.62,117.01 168.6,117.01 168.37,116.9 168.28,116.68 168.25,116.59 168.17,116.55 168.07,116.51 167.98,116.43 167.7,116.43 167.36,116.76 167.36,116.83 167.24,116.96 167.24,117.16 167.34,117.26 167.56,117.26 167.93,117.17 168.14,117.48 168.17,117.56 168.25,117.61 168.41,117.68 168.48,117.84 168.53,117.92 168.61,117.95 168.77,117.98 168.88,118.09 169.31,118.51 169.49,118.51
+1.35VS_VGA on TOP (solid shape): 214.71,70.39 214.79,70.36 214.84,70.28 215.11,70.05 215.38,70.28 215.42,70.36 215.51,70.39 215.51,70.39 215.59,70.36 215.64,70.28 215.71,70.13 215.87,70.05 215.95,70.01 215.98,69.93 216.07,69.69 216.31,69.59 216.39,69.56 216.44,69.48 216.45,69.43 216.48,69.37 216.48,69.25 216.71,68.68 216.94,69.25 216.94,69.37 216.97,69.43 216.98,69.48 217.02,69.56 217.11,69.59 217.19,69.6 217.26,69.63 217.31,69.64 217.38,69.64 217.45,69.71 217.51,69.71 217.62,69.61 217.62,69.24 217.67,69.19 217.67,68.93 217.57,68.83 217.52,68.83 217.51,68.84 217.46,68.83 217.25,68.74 217.15,68.54 217.14,68.49 216.26,68.49 216.25,68.54 216.03,68.77 215.72,68.74 215.68,68.73 215.63,68.76 215.54,68.86 215.43,68.94 215.42,69.11 215.34,69.25 215.34,69.37 215.35,69.39 215.11,69.8 214.87,69.39 214.88,69.37 214.88,69.25 214.79,69.09 214.79,68.9 214.74,68.85 214.63,68.75 213.91,68.75 213.76,68.9 213.76,69.41 213.78,69.52 213.76,69.64 213.76,69.95 213.85,70.05 214.21,70.05 214.24,70.05 214.27,70.05 214.47,70.1 214.58,70.28 214.62,70.36 214.7,70.39
+1.35VS_VGA on TOP (solid shape): outline of 23832 points within 156.34,63.56 232.28,132.3
+1.35VS_VGA on BOTTOM (solid shape): 219.3,78.39 219.3,78.22 218.97,77.89 218.97,77.8 218.47,77.29 218.26,77.29 218.12,77.44 218.12,77.58 218.56,78.02 218.56,78.12 218.72,78.28 218.78,78.28 219.01,78.51 219.19,78.51
+1.35VS_VGA on BOTTOM (solid shape): 184.01,117.18 184.01,116.91 183.94,116.8 183.92,116.67 183.89,116.59 183.81,116.55 183.76,116.54 183.7,116.51 183.57,116.51 183.01,116.36 183.43,115.96 183.53,115.96 183.59,115.89 183.63,115.85 183.78,115.85 184,115.62 184,115.32 183.85,115.17 182.89,115.17 182.77,115.29 182.77,117.21 182.92,117.35 183.85,117.35
+1.35VS_VGA on BOTTOM (solid shape): 216.17,80.94 216.22,80.88 216.28,80.83 216.33,80.76 216.32,80.66 216.28,80.41 216.45,80.21 216.48,80.19 216.48,80.07 216.45,80.01 216.44,79.96 216.39,79.89 216.31,79.85 216.18,79.83 216.07,79.76 215.74,79.76 215.63,79.83 215.51,79.85 215.42,79.89 215.38,79.96 215.37,79.98 215.37,80.31 215.42,80.32 215.65,80.51 215.63,80.81 215.61,80.85 215.73,80.97 216.15,80.97
+1.35VS_VGA on BOTTOM (solid shape): 174.86,123.59 174.86,123.5 174.93,123.21 175.14,123 175.24,122.95 175.35,122.93 175.38,122.92 175.42,122.92 175.59,122.75 175.59,122.56 175.4,122.37 175.4,122.28 175.11,121.99 175.11,121.79 175,121.68 174.52,121.68 174.4,121.8 174.4,121.96 174.35,122.01 174.28,122.18 174.15,122.31 174.14,122.33 174.14,122.43 174.14,122.46 174.13,122.53 174.14,122.54 174.25,122.54 174.36,122.44 174.47,122.44 174.49,122.42 174.51,122.42 174.54,122.42 174.62,122.4 174.71,122.42 174.85,122.54 174.88,122.73 174.81,122.87 174.67,122.95 174.63,122.95 174.56,122.95 174.39,123.12 174.39,123.62 174.45,123.67 174.78,123.67
+1.35VS_VGA on BOTTOM (solid shape): 167.54,123.65 167.66,123.53 167.82,123.5 167.9,123.47 167.95,123.4 168.03,123.27 168.17,123.21 168.25,123.16 168.28,123.08 168.32,122.93 168.41,122.82 168.41,122.25 168.35,122.19 168.08,122.19 167.58,121.68 167.33,121.68 167.21,121.81 167.21,122.01 167.31,122.13 167.34,122.28 167.37,122.36 167.45,122.41 167.69,122.68 167.45,122.95 167.38,122.99 167.34,123.06 167.28,123.22 167.15,123.33 167.15,123.49 167.31,123.65
+1.35VS_VGA on BOTTOM (solid shape): 216.1,78.42 216.1,78.25 215.95,78.09 215.95,77.77 216.11,77.61 216.11,77.39 216.01,77.27 215.98,77.12 215.95,77.04 215.87,76.99 215.64,76.79 215.74,76.51 215.74,76.09 215.15,76.09 215.05,76.14 215.03,76.25 215.01,76.45 214.89,76.6 214.89,76.85 215,76.97 215.04,77.13 215.07,77.21 215.15,77.25 215.38,77.49 215.22,77.77 215.22,77.93 215.22,77.98 215.5,78.26 215.55,78.26 215.81,78.53 216,78.53
+1.35VS_VGA on BOTTOM (solid shape): 185.62,120.33 185.62,120.22 184.68,119.28 184.51,119.28 184,119.3 184.07,118.8 184.1,118.78 184.1,118.63 183.93,118.46 183.68,118.46 183.6,118.54 183.6,118.61 183.54,119.04 183.1,119.04 183.02,119 182.93,119.04 182.88,119.08 182.82,119.11 182.77,119.12 182.77,119.82 182.91,119.96 183,120 183.09,119.96 183.37,119.86 183.62,120.02 183.63,120.05 183.7,120.05 183.71,120.04 183.85,120 183.98,120.04 184,120.05 184.5,120.05 184.51,120.04 184.77,120.03 184.92,120.24 185.1,120.24 185.33,120.47 185.48,120.47
+1.35VS_VGA on BOTTOM (solid shape): 224.18,78.36 224.26,78.36 224.59,78.03 224.59,77.77 224.5,77.7 224.44,77.6 224.44,77.58 224.32,77.46 224.29,77.45 224.07,77.35 223.98,77.11 223.95,77.04 223.88,77 223.64,76.74 223.84,76.46 223.85,76.45 223.98,76.33 223.98,76.31 224.49,76.04 224.46,76.62 224.46,76.8 224.59,76.93 224.81,76.93 224.98,76.76 225.08,76.76 225.35,76.49 225.35,75.52 225.18,75.36 222.41,75.36 222.26,75.5 222.26,75.92 222.76,76.42 222.76,76.78 222.95,76.97 223.34,76.97 223.66,77.29 223.66,77.63 223.84,77.94 223.64,78.23 223.64,78.37 223.8,78.53 224.01,78.53
+1.35VS_VGA on BOTTOM (solid shape): 222.55,96.94 222.63,96.88 222.72,96.77 222.83,96.68 222.89,96.6 222.88,96.5 222.85,96.26 223.04,96.09 223.05,96.09 223.18,95.96 223.18,95.9 223.17,95.85 223.12,95.83 222.93,95.77 222.84,95.6 222.79,95.52 222.71,95.49 222.71,95.49 222.62,95.52 222.58,95.6 222.31,95.83 222.04,95.6 221.99,95.52 221.91,95.49 221.76,95.45 221.64,95.35 221.43,95.35 221.35,95.43 221.35,95.99 221.45,96.09 221.48,96.09 221.68,96.14 221.78,96.32 221.82,96.4 221.91,96.43 222.14,96.52 222.24,96.76 222.27,96.84 222.35,96.89 222.4,96.9 222.45,96.93
+1.35VS_VGA on BOTTOM (solid shape): 225.61,91.95 225.56,91.94 225.49,91.92 225.43,91.88 225.29,91.6 225.45,91.33 225.48,91.32 225.48,91.03 225.43,91.02 225.31,90.95 225.24,90.83 225.24,90.81 225.12,90.69 225.09,90.69 225.01,90.67 224.94,90.64 224.89,90.6 224.84,90.55 224.58,90.55 224.55,90.59 224.45,90.66 224.45,90.86 224.48,90.87 224.64,91.17 224.46,91.45 224.21,91.47 224.02,91.32 223.8,91.32 223.57,91.48 223.3,91.41 223.18,91.15 223.31,90.89 223.37,90.86 223.43,90.84 223.43,90.68 223.39,90.67 223.32,90.63 223.26,90.58 222.95,90.58 222.84,90.66 222.7,90.69 222.62,90.72 222.58,90.79 222.52,90.94 222.38,91.02 222.36,91.03 222.24,91.15 222.24,91.17 222.19,91.34 222.06,91.45 221.81,91.47 221.62,91.31 221.6,91.28 221.35,91.28 220.96,91.66 220.96,91.73 220.84,91.85 220.81,91.99 220.93,92.06 225.61,92.06
+1.35VS_VGA on BOTTOM (solid shape): 193.05,123.64 193.14,123.6 193.18,123.5 193.23,123.31 193.41,123.21 193.49,123.16 193.52,123.08 194.08,122.84 193.85,123.41 193.76,123.44 193.72,123.52 193.71,123.56 193.71,123.64 194.66,123.64 194.87,123.43 194.87,122.71 194.76,122.59 194.72,122.6 194.44,122.54 194.32,122.28 194.29,122.19 194.21,122.15 194.07,122.08 193.98,121.95 193.98,121.93 193.86,121.82 193.83,121.82 193.72,121.93 193.71,121.95 193.63,122.08 193.49,122.15 193.41,122.19 193.38,122.28 193.28,122.51 193.05,122.61 192.96,122.64 192.92,122.72 192.84,122.87 192.69,122.95 192.61,122.99 192.58,123.08 192.46,123.33 192.14,123.42 192.12,123.47 192.12,123.54 192.21,123.64
+1.35VS_VGA on BOTTOM (solid shape): outline of 339 points within 162.1,121.15 166.8,130.03
+1.35VS_VGA on BOTTOM (solid shape): outline of 201 points within 155.79,100.08 168.41,121.15
+1.35VS_VGA on BOTTOM (solid shape): outline of 1081 points within 219.79,76.47 230.63,90.65
+1.35VS_VGA on BOTTOM (solid shape): outline of 1264 points within 173.38,74.57 198.55,104.57
+1.35VS_VGA on BOTTOM (solid shape): outline of 4197 points within 173.26,58.6 233.48,131.01
+1.35VS_VGA on IN1 (solid shape): 215.84,71.88 215.84,71.14 215.77,71.07 213.7,71.07 213.63,71.13 213.63,71.74 213.83,71.94 215.79,71.94
+1.35VS_VGA on IN1 (solid shape): outline of 258 points within 172.49,114.67 175.25,117.77
+1.35VS_VGA on IN1 (solid shape): outline of 443 points within 212.85,77.68 223.04,80.61
+1.35VS_VGA on IN1 (solid shape): outline of 775 points within 212.94,86.66 218.78,91.94
+1.35VS_VGA on IN1 (solid shape): outline of 1021 points within 173.7,75.15 192.93,100.23
+1.35VS_VGA on IN1 (solid shape): outline of 1179 points within 216.29,61.93 228.77,72.76
+1.35VS_VGA on IN1 (solid shape): outline of 4905 points within 171.1,114.16 198.16,131.59
+1.35VS_VGA on IN2 (solid shape): outline of 433 points within 190.85,118.86 195.28,123.41
+1.35VS_VGA on IN2 (solid shape): outline of 543 points within 165.1,114.83 168.09,120.09
+1.35VS_VGA on IN2 (solid shape): outline of 1831 points within 173.7,78.84 198.61,103.39
+1.35VS_VGA on IN2 (solid shape): outline of 10227 points within 178.03,62.3 231.94,131.68
+1.35VS_VGA on IN3 (solid shape): outline of 6325 points within 204.31,62.69 233.88,108.59
+1.35VS_VGA on IN4 (solid shape): outline of 335 points within 189.04,116.02 192.72,120.22
+1.35VS_VGA on IN4 (solid shape): outline of 838 points within 163.04,124.87 170.35,130.96
+1.35VS_VGA on IN4 (solid shape): outline of 821 points within 164.38,114.87 170.05,124.55
+1.35VS_VGA on IN4 (solid shape): outline of 1568 points within 181.75,75.98 198.25,104.78
+1.35VS_VGA on IN4 (solid shape): outline of 1812 points within 204.34,62.44 234.38,108.55
+1.35VS_VGA on IN4 (solid shape): outline of 1986 points within 220.09,68.38 227.62,81.09
+1.35VS_VGA on IN4 (solid shape): outline of 2128 points within 178.23,115.66 188.91,129.84
+1.35VS_VGA on IN5 (solid shape): outline of 8907 points within 170.98,55.84 232.79,130.22
+1.35VS_VGA on IN6 (solid shape): outline of 210 points within 216.9,68.65 219.31,73.63
+1.35VS_VGA on IN6 (solid shape): outline of 1048 points within 212.28,75.34 219.14,81.05
+1.35VS_VGA on IN6 (solid shape): outline of 3346 points within 194.46,67.33 232.77,128.37
+1.35VS_VGA on IN6 (solid shape): outline of 3673 points within 165.07,114.32 186.58,130.16
+1.35VS_VGA on VCC: 239.05,60.72 230.21,51.97 210.91,51.97 207.73,48.8 202.14,48.8 197.06,43.72 193.17,43.72 193.17,49.09 191.94,50.32 173.26,50.32 173.03,50.56 172.79,50.32 172.74,50.32 171.54,49.11 155.75,49.11 150.72,54.15 148.79,56.08 148.79,58.24 148.78,58.24 148.78,135.16 148.95,135.16 149.11,135.22 154.58,135.22 157.88,138.52 203.73,138.52 203.73,133.61 203.98,132.35 204.69,131.29 207.52,128.46 208.58,127.75 209.83,127.51 225.73,127.51 225.73,109.88 227.71,105.09 232.5,103.11 235.73,103.11 235.73,70.48 235.69,69.68 235.58,68.89 234.57,63.4 235.05,61.53 236.8,60.72 ; 2 cut-outs
+1.35VS_VGA_PGOOD on BOTTOM (solid shape): 132.39,108.93 132.39,108.73 132.26,108.6 132.26,108.14 132.59,107.81 132.59,107.51 132.15,107.06 132.15,106.69 131.98,106.53 131.52,106.53 131.35,106.71 131.35,108.78 131.61,109.04 132.27,109.04
+1.35VS_VGAP on BOTTOM (solid shape): 157.67,116.71 157.67,111.47 157.29,111.09 156.46,111.09 156.32,110.95 156.32,109.25 156.36,109.2 156.85,109.2 156.86,109.19 156.86,108.77 156.85,108.75 156.34,108.75 156.32,108.73 156.32,108.02 156.33,108 156.86,108 156.86,108 156.86,107.56 156.86,107.55 156.32,107.55 156.32,107.55 156.32,106.79 156.19,106.66 156.19,104.88 156.19,104.87 155.67,104.87 155.65,104.85 155.65,104.42 155.67,104.39 156.2,104.39 156.22,104.37 156.22,102.56 155.7,102.56 155.68,102.54 155.68,102.1 155.68,102.09 156.23,102.09 156.23,102.08 156.23,101.59 156.07,101.42 151.24,101.42 150.73,101.93 150.73,107.45 148.49,109.69 147.13,109.69 146.24,110.58 146.24,116.42 147.07,117.25 154.58,117.25 154.58,117.26 154.87,117.26 155.16,117.55 156.83,117.55
+1.35VS_VGAP_B+ on TOP (solid shape): 151.77,114.45 151.77,104.93 150.7,103.86 148.47,103.86 148.33,104 148.33,104.39 148.87,104.39 148.87,104.83 148.33,104.83 148.33,107.29 148.04,107.59 148.04,109.48 147.51,110.01 145.73,110.01 145.47,110.28 145.47,114.52 145.81,114.86 151.36,114.86
+1.35VS_VGAP_B+ on BOTTOM (solid shape): 150.4,107.13 150.4,106.11 150.12,105.82 148.66,105.82 148.4,106.07 148.4,107.15 148.59,107.34 150.19,107.34
+1.35VS_VGAP_B++ on TOP (solid shape): outline of 963 points within 132.62,46.8 167.37,105.35
+3.3V_AVDD on TOP (solid shape): 19.04,12.21 19.04,10.43 18.65,10.04 18.65,9.88 18.57,9.8 18.57,9.46 18.21,9.1 17.11,9.1 17.1,9.1 16.98,9.12 16.87,9.1 16.84,9.1 16.76,9.04 16.72,9 16.49,9 15.81,9.68 15.81,10.06 15.48,10.4 15.48,11.12 16.61,12.26 16.98,12.26 17.03,12.21 17.03,11.29 16.94,11.2 16.81,11.2 16.48,10.87 16.48,10.87 16.3,10.68 16.31,10.42 16.31,10.41 16.31,10.38 16.39,10.3 16.53,10.16 17.96,10.16 18,10.2 18.02,10.21 18.16,10.29 18.24,10.43 18.25,10.44 18.82,11.02 18.82,12.21 18.87,12.26 19,12.26
+3.3V_AVDD on BOTTOM (solid shape): 18.94,10.48 18.94,10.39 18.95,10.3 18.96,10.26 18.96,10.19 19.01,10.15 19.01,10.14 19.25,9.9 19.57,9.81 19.74,9.81 19.86,9.68 19.86,9.37 19.81,9.32 19.48,9.32 19.25,9.09 19.25,8.13 19.15,8.03 18.62,8.03 18.24,8.4 17.7,8.4 17.66,8.44 17.66,9 17.72,9.06 18.06,9.06 18.24,9.23 18.24,9.47 18.48,9.71 18.48,10.45 18.63,10.6 18.82,10.6
+3.3V_AVDD on IN3 (solid shape): outline of 999 points within 1.3,8.03 19.85,15.26
+3.3V_DVDD on BOTTOM (solid shape): 27.4,11.96 27.4,10.95 27.27,10.82 27.26,10.82 26.34,9.89 25.7,9.89 25.63,9.97 25.63,10.63 25.47,10.79 24.98,10.79 24.81,10.96 24.81,11.38 24.9,11.47 25.6,11.47 25.7,11.37 25.7,11.33 25.83,10.99 26.2,10.92 26.21,10.92 26.35,10.92 26.57,11.14 26.57,11.24 26.74,11.4 26.74,11.96 26.82,12.05 27.31,12.05
+3.3V_F347 on TOP (solid shape): outline of 275 points within 248.85,37.06 261.25,43.03
+3.3V_F347 on BOTTOM (solid shape): 260.44,21.92 260.44,21.33 260.21,21.1 258.94,21.1 258.7,21.34 258.7,22.5 259.2,23 259.36,23
+3.3V_F347 on BOTTOM (solid shape): 259.31,42.24 259.56,42.24 260.45,41.82 261.34,41.43 262.13,40.64 262.13,35.02 264.15,33 264.15,32.36 265.22,31.29 265.22,31.1 264.47,30.34 264.29,30.34 262.89,31.74 262.89,31.79 262.66,32.02 262.61,32.02 259.34,35.29 258.81,35.29 258.71,35.38 258.71,37.28 259.08,37.64 259.46,37.64 259.62,37.8 259.62,39.21 259.39,39.43 257.46,39.43 257.28,39.62 257.28,41.26 257.6,41.58 257.6,42.14 257.71,42.25 259.3,42.25
+3.3V_F347 on IN2 (solid shape): 181.98,15.58 181.98,14.21 181.75,13.98 179.85,13.98 179.47,14.37 179.47,15.62 179.67,15.83 181.74,15.83
+3.3V_F347 on IN2 (solid shape): 270,35.04 270,34.44 270.4,34.05 270.4,33.29 270.18,33.06 269.47,33.06 268.93,33.61 268.93,34.87 269.25,35.2 269.85,35.2
+3.3V_F347 on IN2 (solid shape): 263.19,22.33 263.19,20.69 262.94,20.43 259.59,20.43 259.23,20.07 258.83,20.07 258.37,20.53 258.37,22.22 258.62,22.46 263.06,22.46
+3.3V_F347 on IN2 (solid shape): 253.48,42.41 253.7,42.41 253.72,42.39 253.75,42.35 253.79,42.31 253.83,42.28 253.88,42.25 253.93,42.24 253.99,42.23 254.04,42.23 254.1,42.24 254.15,42.25 254.2,42.28 254.24,42.31 254.28,42.35 254.31,42.39 254.33,42.41 258.62,42.41 259.65,41.39 261.35,41.39 261.64,41.1 261.64,39.43 261.27,39.06 258.37,39.06 257.73,39.7 252.77,39.7 251.95,40.52 250.94,40.52 250.58,40.87 250.58,41.55 250.95,41.55 250.95,41.49 250.96,41.44 250.98,41.39 251,41.34 251.03,41.3 251.07,41.26 251.11,41.22 251.15,41.2 251.2,41.18 251.26,41.17 251.31,41.16 251.36,41.17 251.41,41.18 251.46,41.2 251.51,41.22 251.55,41.26 251.59,41.3 251.62,41.34 251.64,41.39 251.66,41.44 251.67,41.49 251.67,41.55 251.66,41.6 251.64,41.65 251.62,41.7 251.59,41.74 251.55,41.78 251.51,41.81 251.46,41.84 251.41,41.86 251.36,41.87 251.31,41.87 251.26,41.87 251.2,41.86 251.15,41.84 251.11,41.81 251.07,41.78 251.03,41.74 251,41.7 250.98,41.65 250.96,41.6 250.95,41.55 250.58,41.55 250.58,42.21 250.77,42.4 250.77,42.86 250.91,42.99 252.9,42.99
+3.3V_GFX_AON on TOP (solid shape): 169.15,81.19 169.29,81.05 169.29,80.42 168.91,80.04 168.91,79.84 168.81,79.74 167.43,79.74 167.28,79.9 167.28,81.05 167.42,81.19 168.67,81.19
+3.3V_GFX_AON on TOP (solid shape): 156.62,59.17 156.62,57.46 156,56.85 154.31,56.85 154.02,57.14 154.02,57.85 154.07,57.9 154.62,57.9 154.67,57.95 154.7,57.95 154.7,57.98 154.9,58.18 154.9,58.48 154.9,58.49 154.9,58.82 155.55,59.47 156.32,59.47
+3.3V_GFX_AON on TOP (solid shape): 152.96,78.02 152.96,67.9 153.11,67.75 153.57,67.75 153.98,67.34 153.98,62.86 153.45,62.33 153.12,62.33 152.94,62.16 152.94,60.91 152.65,60.61 152.65,59.27 152.55,59.17 151.51,59.17 151.38,59.3 151.38,62.32 151.56,62.55 151.73,62.8 152.01,63.32 152.23,63.88 152.24,63.93 152.28,66.36 151.06,68.46 151.06,78.13 151.44,78.51 152.47,78.51
+3.3V_GFX_AON on BOTTOM (solid shape): 157.38,80.22 157.38,78.62 156.79,78.04 155.52,78.04 155.37,78.19 155.37,79.22 155.5,79.35 155.5,80.1 155.51,80.11 155.51,80.86 155.57,80.92 156.67,80.92
+3.3V_GFX_AON on IN1 (solid shape): outline of 377 points within 151.47,57.63 159.17,64.8
+3.3V_GFX_AON on IN5 (solid shape): outline of 142 points within 151.51,76.59 157.42,79.83
+3.3V_GFX_AON on IN6 (solid shape): outline of 335 points within 151.47,57.84 158.64,64.8
+3V_PCH on TOP (solid shape): 221.1,18.12 221.96,18.12 222.13,17.96 222.13,17.35 222.3,17.17 224.17,17.17 224.79,16.55 224.79,16.12 224.73,16.05 221.4,16.05 221.08,16.38 220.11,16.38 220.11,15.83 219.86,15.83 219.86,16.38 219.31,16.38 219.31,15.83 219.06,15.83 219.06,16.38 218.48,16.38 218.38,16.48 218.38,16.92 218.95,17.49 218.95,17.87 218.88,17.94 218.88,18.27 219.03,18.42 220.8,18.42
+3V_PCH on BOTTOM (solid shape): 224.35,40.35 224.35,40.22 224.11,39.98 224.11,39.77 224.35,39.53 224.35,38.59 224.16,38.4 224.16,38.11 224.18,38.09 224.36,37.92 224.36,37.69 224.36,36.97 224.26,36.87 224.09,36.87 223.79,37.17 223.79,37.95 223.63,38.12 223.63,38.34 223.8,38.52 223.8,38.79 223.67,38.92 223.39,38.92 223.31,38.84 223.09,38.84 222.95,38.98 222.95,39.17 223.1,39.32 223.15,39.32 223.44,39.61 223.62,39.79 223.62,39.98 224.08,40.44 224.26,40.44
+3V_PCH on IN1 (solid shape): outline of 3425 points within 216.23,16.19 235.83,41.71
+3V_PCH on IN2 (solid shape): outline of 808 points within 207.35,20.8 228.11,24.05
+3V_PCH on IN4 (solid shape): outline of 301 points within 218.81,17.53 225.91,20.76
+3VALW on TOP (solid shape): 281.15,8.32 281.15,7.13 281.04,7.01 279.9,7.01 279.78,7.13 279.78,8.28 279.89,8.39 281.08,8.39
+3VALW on TOP (solid shape): 175.81,148.62 175.81,147.26 176.35,146.71 176.35,146.03 176.26,145.93 175.31,145.93 175.22,146.01 175.22,146.89 175.5,147.17 175.5,148.59 175.57,148.66 175.77,148.66
+3VALW on TOP (solid shape): 339.37,37.01 339.37,36.37 338.97,35.96 337.62,35.96 337.04,36.53 332.85,36.53 331.98,35.66 331.98,33.43 331.87,33.31 329.59,33.31 329.41,33.5 329.41,38.02 330.15,38.76 337.62,38.76
+3VALW on TOP (solid shape): 52.5,13.14 52.5,13.12 52.69,12.83 53.05,12.84 53.12,12.91 53.17,12.98 53.85,12.98 53.98,12.85 53.98,11.51 53.87,11.4 53.87,10.72 53.86,10.71 53.85,10.61 53.86,10.51 53.87,10.5 53.87,10.08 53.86,10.07 53.85,9.97 53.87,9.86 53.87,9.36 53.87,9.35 53.87,9.07 53.74,8.94 50.44,8.94 50.27,9.11 50.27,13.16 50.5,13.39 52.25,13.39
+3VALW on TOP (solid shape): 249.24,42.76 249.24,40.1 248.67,40.1 248.67,39.4 248.72,39.4 248.72,39.39 249.18,39.39 249.24,39.33 249.24,39.02 249.12,38.9 248.72,38.9 248.72,38.89 248.67,38.89 248.67,38.13 249.24,38.13 249.24,37.49 249.81,37.49 250.76,38.44 253.3,38.44 253.37,38.38 253.37,36.99 250.9,34.53 250.89,34.53 250.49,34.13 249.24,34.13 248.26,35.11 248.26,35.61 250.34,35.61 250.34,35.56 250.35,35.51 250.37,35.46 250.39,35.41 250.42,35.36 250.46,35.33 250.5,35.29 250.55,35.27 250.59,35.25 250.65,35.23 250.7,35.23 250.75,35.23 250.81,35.25 250.85,35.27 250.9,35.29 250.94,35.33 250.98,35.36 251.01,35.41 251.03,35.46 251.05,35.51 251.06,35.56 251.06,35.61 251.05,35.67 251.03,35.72 251.01,35.77 250.98,35.81 250.94,35.85 250.9,35.88 250.85,35.91 250.81,35.93 250.75,35.94 250.7,35.94 250.65,35.94 250.59,35.93 250.55,35.91 250.5,35.88 250.46,35.85 250.42,35.81 250.39,35.77 250.37,35.72 250.35,35.67 250.34,35.61 248.26,35.61 248.26,35.8 247.02,37.03 247.02,42.45 247.53,42.95 249.05,42.95
+3VALW on TOP (solid shape): outline of 90 points within 200.58,13.29 217.74,21.23
+3VALW on BOTTOM (solid shape): 199.58,134.54 199.58,133.91 199.38,133.7 197.62,133.7 197.55,133.77 197.55,134.59 198,135.03 199.09,135.03
+3VALW on BOTTOM (solid shape): 194.82,139.27 194.82,138.79 194.34,138.31 193.83,138.31 193.7,138.18 191.79,138.18 191.71,138.26 191.71,138.65 191.4,138.96 191.4,139.53 191.5,139.62 194.46,139.62
+3VALW on BOTTOM (solid shape): 29.93,20.26 31.58,20.26 32.04,19.8 32.04,18.42 30.66,17.04 28.78,17.04 28.39,17.43 28.39,18.44 28.9,18.44 28.9,19.15 28.39,19.15 28.39,19.64 28.9,19.64 28.9,20.35 28.39,20.35 28.39,20.92 29.28,20.92
+3VALW on BOTTOM (solid shape): 154.5,74.03 155.14,74.03 155.55,73.62 155.55,72.76 155.41,72.61 154.69,72.61 154.58,72.72 153.52,72.72 153.38,72.86 153.38,73.74 153.48,73.84 154.02,73.84 154.22,74.04 154.5,74.04
+3VALW on BOTTOM (solid shape): 136.36,88.28 136.38,88.28 136.38,88.27 136.89,88.27 136.89,88.28 136.91,88.28 136.91,88.8 137.16,88.8 137.16,88.28 137.18,88.28 137.18,88.27 137.69,88.27 137.69,88.28 137.71,88.28 137.71,88.8 138.44,88.8 138.53,88.71 138.53,86.79 138.38,86.64 134.94,86.64 134.8,86.78 134.8,88.48 135.12,88.8 136.36,88.8
+3VALW on BOTTOM (solid shape): 158.36,20.77 158.36,19.02 158.94,18.44 158.94,17.35 158.66,17.07 158.47,17.07 158.45,17.05 158.44,17.05 158.22,16.82 158.22,16.82 157.36,15.96 156.69,15.96 156.54,15.81 156.54,15.72 156.5,15.69 156.5,15.14 156.33,14.96 155.84,14.96 155.73,15.08 155.76,15.15 155.76,15.2 155.77,15.25 155.76,15.3 155.76,15.33 155.76,15.78 155.97,15.99 155.97,18.04 156.04,18.11 156.04,19.45 155.39,20.1 155.39,20.16 157.19,20.16 157.19,20.1 157.2,20.05 157.21,20 157.24,19.95 157.27,19.91 157.3,19.87 157.34,19.84 157.39,19.81 157.44,19.79 157.49,19.78 157.55,19.77 157.6,19.78 157.65,19.79 157.7,19.81 157.75,19.84 157.79,19.87 157.82,19.91 157.85,19.95 157.88,20 157.89,20.05 157.9,20.1 157.9,20.16 157.89,20.21 157.88,20.26 157.85,20.31 157.82,20.35 157.79,20.39 157.75,20.43 157.7,20.45 157.65,20.47 157.6,20.48 157.55,20.49 157.49,20.48 157.44,20.47 157.39,20.45 157.34,20.43 157.3,20.39 157.27,20.35 157.24,20.31 157.21,20.26 157.2,20.21 157.19,20.16 155.39,20.16 155.39,20.66 155.65,20.91 155.65,20.91 155.77,21.03 158.1,21.03
+3VALW on BOTTOM (solid shape): outline of 175 points within 286.39,7.79 291.97,35.43
+3VALW on IN1 (solid shape): 273.11,27.41 281.66,27.41 282.52,28.26 285.43,28.26 286.59,29.42 286.7,29.42 286.77,29.49 288.17,29.49 288.55,29.11 288.55,28.53 286.71,26.69 284.51,26.69 282.95,25.13 281.45,25.13 281.3,25.29 272.72,25.29 272.09,25.91 279.34,25.91 279.34,25.86 279.35,25.81 279.36,25.75 279.39,25.71 279.42,25.66 279.45,25.62 279.49,25.59 279.54,25.56 279.59,25.54 279.64,25.53 279.69,25.53 279.75,25.53 279.8,25.54 279.85,25.56 279.9,25.59 279.94,25.62 279.97,25.66 280,25.71 280.03,25.75 280.04,25.81 280.05,25.86 280.05,25.91 280.04,25.96 280.03,26.01 280,26.06 279.97,26.11 279.94,26.15 279.9,26.18 279.85,26.21 279.8,26.23 279.75,26.24 279.69,26.24 279.64,26.24 279.59,26.23 279.54,26.21 279.49,26.18 279.45,26.15 279.42,26.11 279.39,26.06 279.36,26.01 279.35,25.96 279.34,25.91 272.09,25.91 268.23,29.78 268.23,30.06 268.67,30.51 270,30.51
+3VALW on IN1 (solid shape): outline of 569 points within 239.35,33.24 256.45,40.34
+3VALW on IN2 (solid shape): 137.98,88.27 137.98,86.69 137.79,86.5 136.86,86.5 136.58,86.79 136.58,88.28 136.84,88.54 137.71,88.54
+3VALW on IN2 (solid shape): 193.91,139.07 193.91,138.25 193.82,138.17 192.36,138.17 192.22,138.31 192.22,139.05 192.41,139.24 193.73,139.24
+3VALW on IN2 (solid shape): 199.26,135.16 199.26,134.7 199.06,134.5 198.3,134.5 197.14,135.65 197.14,135.99 197.6,136.45 197.97,136.45
+3VALW on IN2 (solid shape): 176.87,146.39 176.87,144.99 176.67,144.79 174.48,144.79 174.41,144.87 174.41,145.12 174.4,145.12 174.4,145.59 174.62,145.82 174.99,145.82 175.01,145.83 175.02,145.83 175.25,146.06 175.25,146.4 175.4,146.54 176.71,146.54
+3VALW on IN2 (solid shape): outline of 100 points within 155.89,139.17 162.03,141.51
+3VALW on IN2 (solid shape): outline of 193 points within 286.26,22.38 333.12,37.17
+3VALW on IN3 (solid shape): 176.72,146.27 176.72,144.91 176.57,144.75 175.51,144.75 175.26,145 175.26,146.35 175.38,146.47 176.52,146.47
+3VALW on IN3 (solid shape): 193.44,139.75 193.44,138.33 193.23,138.12 192.33,138.12 192.17,138.29 192.17,139.75 192.27,139.85 193.33,139.85
+3VALW on IN4 (solid shape): 137.99,87.18 137.99,86.48 137.74,86.23 135.69,86.23 135.22,86.71 135.22,87.18 135.54,87.5 137.67,87.5
+3VALW on IN4 (solid shape): outline of 312 points within 50.29,10.42 61.91,17.14
+3VALW on IN4 (solid shape): outline of 3046 points within 67.78,16.64 202.82,27.42
+3VALW on IN6 (solid shape): 154.71,73.87 154.71,73.13 154.55,72.97 153.06,72.97 152.88,73.14 152.88,73.71 153.22,74.05 154.53,74.05
+3VALW on IN6 (solid shape): 139.24,86.64 139.24,86.16 138.79,85.71 138.45,85.71 137.92,86.23 136.9,86.23 136.6,86.53 136.6,87.37 136.68,87.44 138.44,87.44
+3VALW on VCC: 31.5,8.55 30.83,8.45 30.23,8.16 30.23,10.29 29.13,11.39 28.49,11.39 25.21,14.67 25.21,17.89 26.78,19.46 34.89,19.46 41.11,13.24 53.79,13.24 53.79,8.55
