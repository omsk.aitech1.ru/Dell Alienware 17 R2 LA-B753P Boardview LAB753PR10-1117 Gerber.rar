# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_ABI#_H: length 35.4
  TOP w0.089: 212.67,91.5 212.87,91.5 213.57,92.2 214.53,92.2 218.25,92.2 218.42,92.03 218.55,92.03 218.72,92.2 218.89,92.2 218.97,92.13 218.97,92.01 218.78,91.82 218.78,91.69 218.9,91.57 219.03,91.57 219.22,91.75 219.34,91.75 220.21,90.88 220.21,89.72 220.45,89.49 220.45,89.33 220.35,89.23 220.27,89.23 220.04,89.46 219.78,89.46 219.55,89.23 219.47,89.23 219.33,89.37 219.33,89.45 219.46,89.57 219.46,89.99 219.65,90.18 219.65,90.38 219.72,90.45 219.92,90.45 219.99,90.38 219.99,90.04 UV12.J4
  TOP w0.157: 212.67,91.5 210.02,91.5 209.77,91.26 209.43,91.26 209.2,91.03 209.2,90.69 208.97,90.46 208.63,90.46 208.4,90.23 208.4,89.89 208,89.49 207.66,89.49 v1(207.44,89.26) 207.22,89.04 207.22,88.94 207.47,88.69 207.47,88.53 206.37,87.43 206.36,87.43 206.22,87.29 206.22,87.27 206.09,87.14 205.89,87.14 205.75,87.27 205.75,87.36 205.54,87.57 204.99,87.57 204.57,87.15 204.57,86.46 204.48,86.37 204.03,86.37 203.95,86.46 203.95,86.95 203.8,87.1 203.52,87.1 203.41,86.99 203.41,86.69 203.28,86.55 203.11,86.55 202.76,86.91 v3(202.69,86.91)
  BOTTOM w0.157: UV1.B23 198.07,85.18 197.96,85.29 197.96,85.46 198.07,85.57 199.58,85.57 200.91,86.91 v3(202.69,86.91)
FBC_ABI#_L: length 34.1
  BOTTOM w0.089: UV1.A11 199.2,75.81 200.92,77.53 201.11,77.53 ; UV13.J4 219.6,90.26 219.6,91.54 219.57,91.57 219.57,91.68
  BOTTOM w0.157: 219.57,91.68 218.25,93 212.93,93 212.82,93.11 212.15,93.11 207.69,88.65 v1(207.69,85.6) 207.69,81.95 204.04,78.31 202.52,78.31 201.74,77.53 201.11,77.53
FBC_CAS#_H: length 32.5
  TOP w0.089: UV12.G3 218.31,89.07 218.2,88.97 217.75,88.97 217.64,88.85 217.64,88.7 217.75,88.58 217.93,88.58 218,88.51 218,88.27 217.91,88.18 217.89,88.18 217.8,88.09 217.8,87.92 217.89,87.83 217.91,87.83 218,87.74 218,87.05 217.68,86.72 217.67,86.72 217.54,86.6 217.54,86.38 217.43,86.26
  TOP w0.157: 217.43,86.26 217.43,86.22 217.18,85.97 216.26,85.97 215.75,86.47 213.36,86.47 212.12,85.23 211.52,85.23 211.16,85.59 210.12,85.59 207.94,83.4 v1(205.25,83.4) 201.23,83.4 200.84,83.8 200.84,87.6 200.99,87.76 200.99,89.41 200.79,89.61 200.5,89.61 v3(200.35,89.46)
  BOTTOM w0.102: UV1.C27 197.84,88.38 198.24,88.78 198.63,88.78 198.9,89.05 199.94,89.05 v3(200.35,89.46)
FBC_CAS#_L: length 34.8
  TOP w0.089: 212.67,86.56 212.75,86.64 v3(212.89,86.64)
  TOP w0.157: 212.67,86.56 v3(211.83,85.71)
  BOTTOM w0.089: 217.74,86.22 218.07,86.55 218.07,87.28 218,87.35 218,88.85 UV13.L3
  BOTTOM w0.157: v3(212.89,86.64) 212.9,86.63 215.46,86.63 216.06,86.03 217.55,86.03 217.74,86.22 ; v3(211.83,85.71) 211.95,85.71 213.11,84.55 213.11,83.18 211.25,81.33 211.25,80.58 208.54,77.86 208.54,76.59 206.47,74.52 205.61,73.66 204.61,73.66 v1(203.41,72.46) 202.97,72.02 202.94,72.02 201.61,70.69 200.81,70.69 200.18,70.06 200.18,69.85 200.09,69.76 199.63,69.76 199.46,69.59 198.82,69.59 UV1.B3
FBC_CKE_H: length 35.8
  TOP w0.089: 219.22,86.22 219.22,86.71 219.41,86.91 219.41,88.23 219.53,88.34 219.53,88.49 219.91,88.87 UV12.J3
  TOP w0.157: v3(200.33,88.88) 200.73,88.48 200.73,87.87 200.51,87.65 200.51,83.58 201.21,82.88 v1(207.62,82.88) 208.26,82.88 RV148.2 209.49,84.12 209.49,84.3 209.95,84.76 210.64,84.76 210.74,84.86 211.27,84.86 211.34,84.79 212.3,84.79 212.37,84.86 212.41,84.86 213.59,86.04 215.56,86.04 216.08,85.53 217.9,85.53 217.97,85.61 217.97,86.52 218.1,86.65 218.47,86.65 218.6,86.52 218.6,84.88 218.78,84.7 219.04,84.7 219.22,84.88 219.22,86.22
  BOTTOM w0.13: v3(200.33,88.88) 200.18,88.88 200.06,88.76 199.08,88.76 198.7,88.38 UV1.B27
FBC_CKE_L: length 36
  BOTTOM w0.089: UV13.J3 220.23,88.84 220.23,88.12 220.04,87.93 219.78,87.93 219.6,87.75 219.6,86.85 218.97,86.22
  BOTTOM w0.157: 218.97,86.22 217.82,85.06 215.71,85.06 215.23,85.54 212.74,85.54 212.11,86.17 211.64,86.17 211.16,85.69 211.16,85.26 211.43,84.99 211.86,84.99 RV147.2 212.63,83.32 210.81,81.51 210.81,80.76 208.1,78.04 208.1,76.77 v1(207.56,76.23) 206.29,74.96 206.29,74.96 205.43,74.1 204.43,74.1 202.78,72.46 202.76,72.46 201.43,71.13 200.88,71.13 199.9,70.15 199.65,70.15 199.59,70.15 199.42,69.98 UV1.A4
FBC_CLK0: length 47.9
  IN4 w0.112: v3(220.31,95.96) 220.41,95.96 220.52,96.07 220.52,100.3 v3(220.33,100.48)
  IN6 w0.089: 219.53,94.29 219.53,95.14 220.31,95.91 v3(220.31,95.96)
  IN6 w0.119: v3(195.6,79.18) 195.72,79.3 195.72,80.66 196.08,81.02 198.52,81.02 199.66,82.17 202.69,82.17 206.15,85.63 206.15,87.6 209.25,90.71 209.6,90.71 209.74,90.56 209.91,90.56 210.16,90.81 210.16,90.98 210.02,91.13 210.02,91.47 210.4,91.85 210.74,91.85 210.89,91.7 211.05,91.7 211.31,91.96 211.31,92.13 211.16,92.27 211.16,92.61 211.94,93.39 215.51,93.39 215.75,93.15 215.75,92.55 215.87,92.43 216.23,92.43 216.35,92.55 216.35,93.15 216.59,93.39 217.72,93.39 219.43,91.68 219.99,91.68 220.45,92.14 220.45,92.73 219.86,93.32 219.86,93.84 219.7,93.99 219.7,94.12 219.53,94.29
  BOTTOM w0.089: UV13.J12 v3(220.31,95.96)
  BOTTOM w0.11: UV1.F15 v3(195.6,79.18)
  BOTTOM w0.14: v3(220.33,100.48) 220.28,100.54 RV179.1
FBC_CLK0#: length 48.9
  IN4 w0.112: v3(220.92,100.48) 220.73,100.3 220.73,95.58 v3(220.31,95.16)
  IN6 w0.089: 219.75,94.37 219.71,94.4 219.71,95.06 220.04,95.39 220.21,95.39 220.31,95.29 v3(220.31,95.16)
  IN6 w0.119: v3(196.4,79.18) 196.13,79.18 195.93,79.37 195.93,80.57 196.17,80.81 198.6,80.81 199.75,81.96 202.78,81.96 206.36,85.54 206.36,87.51 209.34,90.49 209.51,90.49 209.65,90.35 210,90.35 210.38,90.73 210.38,91.07 210.23,91.22 210.23,91.38 210.48,91.64 210.65,91.64 210.8,91.49 211.14,91.49 211.52,91.87 211.52,92.21 211.37,92.36 211.37,92.53 212.03,93.18 215.42,93.18 215.54,93.06 215.54,92.46 215.79,92.22 216.32,92.22 216.56,92.46 216.56,93.06 216.68,93.18 217.63,93.18 219.34,91.47 220.08,91.47 220.66,92.06 220.66,92.82 220.07,93.41 220.07,93.92 219.92,94.08 219.92,94.2 219.75,94.37
  BOTTOM w0.089: UV13.J11 v3(220.31,95.16)
  BOTTOM w0.11: UV1.E15 196.16,78.78 196.4,79.02 v3(196.4,79.18)
  BOTTOM w0.14: v3(220.92,100.48) 220.92,101.18 RV179.2
FBC_CLK1: length 50.8
  TOP w0.089: UV12.J12 v3(219.51,96.76)
  TOP w0.14: RV141.1 v3(218.41,100.48)
  IN1 w0.119: v3(218.41,100.48) 218.69,100.2 218.69,99.95 219.94,98.7 219.94,96.6 219.79,96.45 219.69,96.45 219.57,96.57 219.57,96.69 v3(219.51,96.76)
  IN4 w0.112: v3(192.4,81.58) 192.23,81.58 191.91,81.26 191.91,81.01 192.04,80.89 197.08,80.89 200.28,84.09 200.28,86.52 203.77,90.02 202.87,90.92 202.87,91.27 203.21,91.61 203.56,91.61 204.55,90.62 204.7,90.62 204.94,90.86 204.94,91.02 203.96,92 203.96,92.35 204.29,92.69 204.64,92.69 205.63,91.7 205.79,91.7 207.6,93.51 218.15,93.51 218.67,94.03 218.67,94.79 219.1,95.22 219.1,96.35 v3(219.51,96.76)
  BOTTOM w0.102: UV1.J18 v3(192.4,81.58)
FBC_CLK1#: length 51.2
  TOP w0.089: UV12.J11 v3(219.51,95.96)
  TOP w0.14: RV141.2 219.04,101.16 v3(219.04,100.5)
  IN1 w0.119: v3(219.04,100.5) 218.9,100.36 218.9,100.04 220.15,98.78 220.15,96.51 219.88,96.24 219.57,96.24 219.51,96.17 v3(219.51,95.96)
  IN4 w0.112: v3(191.4,81.58) 191.71,81.27 191.71,80.93 191.95,80.69 197.17,80.69 200.48,84 200.48,86.44 204.07,90.02 203.08,91.01 203.08,91.19 203.29,91.4 203.47,91.4 204.46,90.41 204.79,90.41 205.15,90.77 205.15,91.1 204.16,92.08 204.16,92.26 204.38,92.48 204.56,92.48 205.54,91.5 205.87,91.5 207.68,93.31 218.24,93.31 218.87,93.95 218.87,94.7 219.31,95.14 219.31,95.75 219.45,95.9 v3(219.51,95.96)
  BOTTOM w0.102: v3(191.4,81.58) 191.8,81.18 UV1.K18
FBC_CS#_H: length 40.8
  TOP w0.089: UV12.L12 221.36,96.2 221.04,96.2 220.93,96.1 220.93,95.94 221.04,95.84 221.13,95.84 221.2,95.77 221.2,95.43 221.35,95.28 221.35,95.09 221.2,94.94 221.2,94.56 221.36,94.4 221.36,94 220.42,93.06 219.56,93.06 219.54,93.04 213.12,93.04 212.91,93.25 212.67,93.25
  TOP w0.157: v3(204.87,89.84) 204.87,90.57 205.07,90.77 205.31,90.77 205.46,90.93 205.46,91.18 205.63,91.34 205.86,91.34 206.03,91.18 206.03,90.93 206.19,90.77 206.47,90.77 206.83,91.13 206.83,91.35 v1(206.59,91.6) 206.35,91.83 206.35,92.05 206.53,92.23 206.75,92.23 207.23,91.75 207.45,91.75 207.63,91.93 207.63,92.15 207.15,92.63 207.15,92.85 207.33,93.03 207.55,93.03 208.03,92.55 208.25,92.55 208.95,93.25 212.67,93.25
  BOTTOM w0.157: v3(204.87,89.84) 204.98,89.73 205.44,89.73 205.64,89.52 205.64,89.19 205.44,88.99 205.04,88.99 204.46,88.41 204.46,87.49 204.08,87.11 204.08,83.3 202.67,81.88 201.03,81.88 199.94,80.79 198.79,80.79 UV1.B18
FBC_CS#_L: length 33.7
  IN4 w0.112: v3(204.88,87.97) 205.87,87.97 210.2,92.29 218.49,92.29 219.61,93.41 220.04,93.41 220.46,93.83 v3(221.73,93.83)
  BOTTOM w0.089: v3(221.73,93.83) 221.2,94.35 221.2,96.05 UV13.G12
  BOTTOM w0.157: v3(204.88,87.97) 204.98,87.87 204.98,87.39 204.52,86.93 v1(204.52,83.12) 202.77,81.37 201.25,81.37 200.57,80.68 200.27,80.68 199.97,80.38 UV1.A17
FBC_D0: length 38.8
  IN1 w0.119: v3(199.6,72.78) 199.97,73.14 199.97,75.3 209.5,84.82 211.85,84.82 212.41,85.39 212.73,85.39 213.3,85.96 217.19,85.96 218,86.76 218,88.1 218.25,88.36 219.01,88.36 219.8,89.14 223.72,89.14 223.91,89.33 223.91,89.71 224.17,89.97 226.99,89.97 v3(227.27,89.69)
  BOTTOM w0.089: UV13.A4 226.35,89.92 227.04,89.92 v3(227.27,89.69) ; UV1.A8 v3(199.6,72.78)
FBC_D1: length 40.6
  IN1 w0.119: v3(197.2,73.56) 197.83,73.56 198.38,73.01 198.38,72.47 198.53,72.32 199.72,72.32 205.49,78.08 205.49,79.34 210.56,84.41 212.02,84.41 212.58,84.98 212.87,84.98 213.39,85.5 217.31,85.5 218.45,86.64 218.58,86.64 219.17,87.23 219.17,87.89 219.62,88.34 223.69,88.34 223.91,88.57 223.91,88.95 224.1,89.14 226.13,89.14 226.32,88.95 226.32,88.34 v3(226.71,87.96)
  BOTTOM w0.089: UV13.A2 v3(226.71,87.96) ; v3(197.2,73.56) 197.2,73.54 196.84,73.18 UV1.D8
FBC_D2: length 39.4
  IN1 w0.119: v3(225.62,91.61) 225.62,91.09 225.29,90.76 224.13,90.76 223.91,90.53 223.91,90.22 223.65,89.96 219.22,89.96 217.59,88.33 217.59,87.82 217.24,87.47 216.47,87.47 216.31,87.31 216.31,86.64 215.97,86.29 213.05,86.29 212.92,86.16 210.25,86.16 198.8,74.71 v3(198.8,72.78)
  BOTTOM w0.089: UV13.B4 225.88,90.33 225.88,90.85 225.62,91.11 v3(225.62,91.61) ; UV1.B8 v3(198.8,72.78)
FBC_D3: length 37.2
  IN1 w0.119: v3(225.91,87.96) UV13.B2 224.08,88.36 223.76,88.04 220.43,88.04 217.45,85.06 215.54,85.06 215.04,84.57 212.75,84.57 212.22,84.04 210.87,84.04 206.62,79.79 205.94,79.1 205.94,78.02 205.48,77.57 204.25,76.34 199.91,71.99 198.36,71.99 198,72.35 v3(198,72.78)
  BOTTOM w0.089: v3(198,72.78) UV1.C8 ; UV13.B2 v3(225.91,87.96)
FBC_D4: length 40.2
  IN1 w0.119: v3(223.4,85.73) 223.4,85.74 223.37,85.71 222.95,85.29 222.95,84.74 222.35,84.14 220.92,84.14 218.48,81.69 214.7,81.69 214.09,81.09 213.22,81.09 212.6,80.47 211.19,80.47 208.89,78.18 208.89,77.1 203.2,71.4 201.33,69.54 200.25,69.54 200.04,69.75 198.76,69.75 198.14,69.14 197.89,69.14 197.61,69.41 197.61,69.96 v3(197.2,70.38)
  BOTTOM w0.089: UV13.E4 222.8,89.65 222.8,86.91 223.01,86.7 223.01,86.45 ; v3(197.2,70.38) UV1.C5
  BOTTOM w0.157: 223.01,86.45 223.4,86.07 v3(223.4,85.73)
FBC_D5: length 35.4
  IN1 w0.119: v3(223.53,86.58) 223.12,86.17 222.42,86.17 221.64,85.4 220.96,85.4 218.7,83.14 217.67,83.14 217.05,82.51 214.44,82.51 213.81,81.88 212.9,81.88 212.3,81.29 210.85,81.29 208.08,78.52 208.08,77.44 202.38,71.74 200.97,70.33 198.04,70.33 v3(198,70.38)
  BOTTOM w0.089: UV13.E2 223.53,87.94 v3(223.53,86.58) ; UV1.B5 v3(198,70.38)
FBC_D6: length 37.6
  IN1 w0.119: v3(196.4,71.18) 196.79,70.79 200.84,70.79 201.11,71.05 201.34,71.28 204.93,74.88 207.54,77.48 207.54,78.56 210.68,81.7 211.96,81.7 213.37,83.11 217.11,83.11 217.54,83.54 218.58,83.54 220.85,85.81 221.47,85.81 221.68,86.01 221.68,86.01 222.26,86.59 v3(222.57,86.59)
  BOTTOM w0.089: UV13.F4 222.61,89.65 222.61,86.91 222.57,86.87 v3(222.57,86.59) ; UV1.D5 v3(196.4,71.18)
FBC_D7: length 36.2
  IN1 w0.119: v3(198,69.58) 198.45,70.03 200.18,70.03 200.26,69.95 201.17,69.95 202.79,71.57 208.49,77.27 208.49,78.35 211.02,80.88 212.43,80.88 213.04,81.5 213.92,81.5 214.53,82.1 217.22,82.1 217.84,82.73 218.93,82.73 220.75,84.55 222.18,84.55 222.51,84.87 222.51,85.43 222.7,85.63 v3(222.7,85.74)
  BOTTOM w0.089: UV1.C4 v3(198,69.58) ; UV13.F2 221.83,87.88 221.83,86.61
  BOTTOM w0.157: v3(222.7,85.74) 222.23,86.22 221.83,86.61
FBC_D8: length 40.6
  IN3 w0.112: v3(201.07,75.09) 202.51,75.09 210.32,82.89 212.22,82.89 212.84,83.52 214.55,83.52 216.72,85.69 218.7,85.69 220.94,87.94 223.24,87.94 223.92,88.61 223.92,91.35 226.32,93.75 226.32,95.34 v3(226.78,95.81)
  BOTTOM w0.089: v3(226.78,95.81) 226.53,95.56 UV13.A11 ; v3(201.07,75.09) 201.07,75.05 200.44,74.42 198.84,74.42 UV1.B9
FBC_D9: length 45.9
  IN3 w0.112: v3(226.71,96.76) 227.17,96.29 227.17,93.78 224.7,91.3 224.7,87.59 224.3,87.19 224.3,86.8 223.68,86.17 221.4,86.17 218.3,83.07 213.08,83.07 212.54,82.52 210.58,82.52 202.44,74.39 197.17,74.39 196.4,75.15 v3(196.4,75.18)
  BOTTOM w0.089: UV13.A13 v3(226.71,96.76) ; UV1.E11 v3(196.4,75.18)
FBC_D10: length 40.6
  IN3 w0.112: v3(202.66,76.56) 202.68,76.53 203.32,76.53 210.81,84.02 214.42,84.02 216.57,86.18 218.49,86.18 220.67,88.36 222.07,88.36 223.12,89.41 223.12,91.32 225.5,93.7 225.5,94.76 v3(225.11,95.16)
  BOTTOM w0.089: v3(225.11,95.16) 225.28,95.16 225.51,95.39 UV13.B11 ; UV1.D9 197.21,74.39 198.54,74.39 198.76,74.61 199.89,74.61 200.38,75.1 200.38,75.44 200.67,75.73 201.11,75.73
  BOTTOM w0.157: v3(202.66,76.56) 202.66,76.38 v1(202.15,75.88) 202.01,75.73 201.11,75.73
FBC_D11: length 38.8
  IN3 w0.112: v3(225.11,96.76) 224.72,96.37 224.72,95.32 224.72,95.32 224.72,94.99 224.72,94.99 224.72,93.74 222.32,91.34 222.32,90.52 222.32,90.21 222.07,89.96 221.27,89.96 218.87,87.56 215.87,87.56 213.79,85.48 213.03,85.48 212.02,84.47 210.63,84.47 210.37,84.22 210.37,84.09 203.24,76.95 v3(203.14,76.95)
  BOTTOM w0.089: UV13.B13 v3(225.11,96.76)
  BOTTOM w0.13: UV1.A9 200.04,73.98
  BOTTOM w0.157: v3(203.14,76.95) 203.25,76.84 203.25,76.19 202.24,75.18 202.09,75.18 200.89,73.98 200.04,73.98
FBC_D12: length 40.2
  IN3 w0.112: v3(194,75.18) 195.12,76.29 199.94,76.29 200.97,77.32 201.17,77.32 212.4,88.55 213.04,88.55 213.51,89.01 213.51,91.42 213.87,91.78 220.42,91.78 221.82,93.19 221.82,93.2 222.51,93.88 222.51,94.96 v3(222.71,95.16)
  BOTTOM w0.089: UV1.H11 v3(194,75.18) ; UV13.E11 v3(222.71,95.16)
FBC_D13: length 49
  IN3 w0.112: v3(194.8,74.38) 194.4,74.78 193.07,74.78 192.83,75.02 192.83,75.33 193.61,76.11 193.61,76.91 193.89,77.19 194.19,77.19 194.41,77.42 194.41,77.72 194.7,78.01 200.59,78.01 208.54,85.95 208.54,87.73 213.68,92.87 217.74,92.87 219.64,94.77 220.14,94.77 220.15,94.77 220.47,94.77 221.26,95.55 222.03,95.55 222.91,96.44 222.91,98.36 223.31,98.76 223.32,98.76 v3(223.65,99.09)
  BOTTOM w0.089: UV13.E13 223.11,97.53 222.8,97.83 222.8,98.24 223.48,98.92 ; UV1.F9 v3(194.8,74.38)
  BOTTOM w0.157: 223.48,98.92 v3(223.65,99.09)
FBC_D14: length 39.5
  IN3 w0.112: v3(193.2,75.18) 193.2,75.22 194.4,76.42 194.4,77.02 194.56,77.18 200.2,77.18 200.82,77.8 201.02,77.8 208.99,85.77 208.99,87.54 213.86,92.42 219.17,92.42 v3(221.91,95.16)
  BOTTOM w0.089: UV1.J11 v3(193.2,75.18) ; UV13.F11 v3(221.91,95.16)
FBC_D15: length 47.2
  IN3 w0.112: v3(196.4,73.56) 195.71,73.56 195.3,73.97 192.79,73.97 192.34,74.41 192.34,75.83 192.8,76.29 192.8,77.96 193.23,78.39 199.72,78.39 202.97,81.64 203.59,81.64 208.09,86.14 208.09,87.91 213.49,93.31 217.55,93.31 219.79,95.55 220.7,95.55 v3(221.91,96.76)
  BOTTOM w0.089: v3(196.4,73.56) 196.4,73.54 196.04,73.18 UV1.E8 ; UV13.F13 v3(221.91,96.76)
FBC_D16: length 32.2
  IN1 w0.119: v3(210.63,95.8) 208.64,95.8 203.78,90.94 203.78,89.99 201.91,88.11 201.91,86.87 200.16,85.12 200.16,83.68 197.64,81.16 192.58,81.16 v3(191.4,79.98)
  BOTTOM w0.089: UV1.K17 v3(191.4,79.98)
  BOTTOM w0.157: UV13.U11 213.51,95.42 213.17,95.09 v1(211.18,95.09) 210.63,95.64 v3(210.63,95.8)
FBC_D17: length 32.5
  IN1 w0.119: v3(194,79.98) 194.53,80.5 199.29,80.5 203.49,84.71 203.49,87.8 206.47,90.77 206.47,92.47 208.82,94.82 211.51,94.82 211.84,95.15 211.84,96.48 212.54,97.18 212.54,98.27 v3(212.51,98.29)
  BOTTOM w0.089: UV1.G17 v3(194,79.98)
  BOTTOM w0.157: v3(212.51,98.29) 212.67,98.14 212.67,98.01 213.51,97.17 UV13.U13
FBC_D18: length 31.9
  IN1 w0.119: v3(211.3,95.8) 210.72,95.21 208.63,95.21 204.19,90.77 204.19,89.88 202.26,87.95 202.26,86.65 200.67,85.05 200.67,83.3 198.24,80.86 193.29,80.86 v3(192.4,79.98)
  BOTTOM w0.089: UV13.T11 213.94,95.93 213.48,95.93 213.04,96.36 212.67,96.36 ; UV1.J17 v3(192.4,79.98)
  BOTTOM w0.157: v3(211.3,95.8) 211.86,96.36 212.67,96.36
FBC_D19: length 33.5
  IN1 w0.119: v3(213.87,98.45) 213.87,97.53 213.49,97.15 213.49,95.4 212.5,94.41 208.99,94.41 206.87,92.3 206.87,90.65 203.9,87.68 203.9,84.54 198.94,79.58 195.2,79.58 v3(194.8,79.18)
  BOTTOM w0.089: v3(213.87,98.45) 213.87,97.6 UV13.T13 ; UV1.G15 v3(194.8,79.18)
FBC_D20: length 38.3
  IN1 w0.119: v3(216.31,95.16) 215.9,94.75 215.9,94.01 214.38,92.49 209.87,92.49 208.8,91.42 208.8,87.79 206.15,85.14 206.15,84.06 200,77.92 200,77.36 199.82,77.18 193.84,77.18 193.6,77.41 193.6,77.88 193.45,78.03 192.55,78.03 v3(191.4,79.18)
  BOTTOM w0.089: UV13.N11 v3(216.31,95.16) ; UV1.K15 v3(191.4,79.18)
FBC_D21: length 41.6
  IN1 w0.119: v3(192.02,77.45) 192.58,77.45 192.79,77.24 192.79,76.48 193.25,76.02 199.54,76.02 200.98,77.46 200.98,77.74 206.96,83.72 206.96,84.8 209.62,87.45 209.62,91.08 210.18,91.64 215.44,91.64 217.49,93.69 217.49,95.34 217.26,95.57 216.91,95.57 216.73,95.75 216.73,96.34 v3(216.31,96.76)
  BOTTOM w0.089: UV1.K14 192,77.47 v3(192.02,77.45) ; UV13.N13 v3(216.31,96.76)
FBC_D22: length 37.3
  IN1 w0.119: v3(217.11,95.16) 216.73,94.78 216.73,93.75 215.05,92.08 210.04,92.08 209.21,91.25 209.21,87.62 206.55,84.97 206.55,83.89 200.41,77.74 200.41,77.28 199.48,76.35 193.8,76.35 193.6,76.55 193.6,77.02 193.2,77.42 v3(193.2,77.58)
  BOTTOM w0.089: UV1.H14 v3(193.2,77.58) ; UV13.M11 v3(217.11,95.16)
FBC_D23: length 39.6
  IN1 w0.119: v3(216.31,97.56) 215.93,97.18 215.93,95.37 215.11,94.55 215.11,94.04 213.97,92.9 209.7,92.9 208.39,91.59 208.39,87.96 205.74,85.31 205.74,84.23 199.51,78 194.05,78 193.63,78.43 192.77,78.43 192.4,78.8 v3(192.4,79.18)
  BOTTOM w0.089: v3(216.31,97.56) 217.11,97.56 UV13.M13 ; v3(192.4,79.18) 192.4,78.38 UV1.J14
FBC_D24: length 24.3
  IN6 w0.119: v3(211.97,89.37) 211.97,88.44 211.11,87.59 210.7,87.59 210.57,87.72 209.73,87.72 207.87,85.87 207.87,84.79 203.44,80.36 201.41,80.36 199.04,77.99 196.82,77.99 v3(196.4,77.58)
  BOTTOM w0.089: UV1.E14 v3(196.4,77.58) ; UV13.U4 212.78,89.96 212.72,90.02 212.67,90.02
  BOTTOM w0.157: v3(211.97,89.37) 211.97,89.62 212.36,90.02 212.67,90.02
FBC_D25: length 24.5
  IN6 w0.119: v3(194.8,77.58) 195.44,78.22 198.69,78.22 201.24,80.77 203.27,80.77 207.46,84.96 207.46,86.04 209.91,88.49 v3(211.41,88.49)
  BOTTOM w0.089: UV1.F14 v3(194.8,77.58)
  BOTTOM w0.13: UV13.U2 212.67,88.36
  BOTTOM w0.157: v3(211.41,88.49) 211.54,88.36 212.67,88.36
FBC_D26: length 22.8
  IN6 w0.119: v3(199.6,77.58) 199.6,77.6 201.95,79.95 203.61,79.95 210.85,87.19 211.21,87.19 212.64,88.61 212.98,88.61 213.51,89.14 213.51,90.76 v3(213.91,91.16)
  BOTTOM w0.089: v3(213.91,91.16) 213.91,90.36 UV13.T4 ; UV1.A14 v3(199.6,77.58)
FBC_D27: length 20.9
  IN6 w0.119: v3(198.8,77.58) 199.2,77.18 199.75,77.18 202.12,79.54 203.69,79.54 210.93,86.78 211.31,86.78 212.49,87.96 v3(213.91,87.96)
  BOTTOM w0.089: v3(213.91,87.96) UV13.T2 ; UV1.B14 v3(198.8,77.58)
FBC_D28: length 27.7
  IN6 w0.119: v3(196.4,76.78) 196.53,76.78 196.93,76.38 197.54,76.38 197.77,76.15 200,76.15 200.66,76.81 201.53,76.81 202.75,78.02 204.45,78.02 210.63,84.21 211.63,84.21 212.83,85.42 213.54,85.42 215.11,86.99 215.11,87.02 215.91,87.82 215.91,89.16 v3(216.31,89.56)
  BOTTOM w0.089: UV13.N4 v3(216.31,89.56) ; v3(196.4,76.78) UV1.E12
FBC_D29: length 28.2
  IN6 w0.119: v3(216.31,87.96) 216.31,87.7 216,87.39 215.8,87.39 215.34,86.93 215.34,86.48 214.41,85.56 214.41,84.6 213.79,83.97 212.82,83.97 211.83,82.97 209.98,82.97 204.62,77.61 202.91,77.61 201.7,76.4 200.63,76.4 200.15,75.92 197.66,75.92 197.46,76.13 196.25,76.13 v3(195.6,76.78)
  BOTTOM w0.089: UV13.N2 v3(216.31,87.96) ; UV1.F12 v3(195.6,76.78)
FBC_D30: length 32.7
  IN6 w0.119: v3(217.11,89.56) 216.73,89.18 216.73,87.72 216.31,87.3 216.31,86.77 215.78,86.24 215.78,85.22 214.12,83.56 212.99,83.56 212.02,82.58 210.17,82.58 204.45,76.86 203.67,76.86 202.8,75.99 200.74,75.99 200.45,75.69 197.55,75.69 197.35,75.9 195.21,75.9 194.8,76.3 v3(194.8,76.78)
  BOTTOM w0.089: UV1.G12 194.4,76.07 194.56,75.91 194.73,75.91 194.8,75.99 v3(194.8,76.78) ; UV13.M4 v3(217.11,89.56)
FBC_D31: length 32.6
  IN6 w0.119: v3(194,77.58) 194.4,77.18 194.4,76.2 194.95,75.66 197.27,75.66 197.47,75.46 200.78,75.46 200.85,75.53 202.91,75.53 203.8,76.42 204.58,76.42 210.34,82.17 212.19,82.17 213.16,83.15 214.29,83.15 217.18,86.04 v3(217.18,86.57)
  BOTTOM w0.089: UV13.M2 217.51,88.36 217.81,88.06 217.81,87.27 217.87,87.22 217.87,86.83 217.61,86.57 v3(217.18,86.57) ; UV1.G14 v3(194,77.58)
FBC_D32: length 43
  TOP w0.089: v3(226.7,90.36) 226.7,90.35 UV12.U4
  IN5 w0.119: v3(194,87.18) 194.4,86.78 194.4,85.92 194.95,85.37 199.27,85.37 201.11,83.52 204.19,83.52 205.22,84.55 217.08,84.55 217.21,84.41 226.07,84.41 226.38,84.73 226.38,85.78 227.66,87.06 227.66,89.9 227.21,90.36 v3(226.7,90.36)
  BOTTOM w0.089: UV1.G26 v3(194,87.18)
FBC_D33: length 38.8
  TOP w0.089: UV12.U2 v3(226.71,88.76)
  IN5 w0.119: v3(226.71,88.76) 226.46,88.76 226.06,89.16 225.73,89.16 225.51,88.95 225.51,87.74 225.31,87.54 210.75,87.54 210.5,87.78 205.29,87.78 203.34,85.84 202.54,85.84 201.01,87.38 200.59,87.38 200.45,87.51 199.12,87.51 198.75,87.88 192.5,87.88 v3(192.4,87.98)
  BOTTOM w0.089: UV1.J26 v3(192.4,87.98)
FBC_D34: length 43.1
  TOP w0.089: v3(226.15,91.23) 225.88,90.96 225.88,90.33 UV12.T4
  IN5 w0.119: v3(226.15,91.23) 226.15,89.88 226.32,89.71 226.32,89.44 226.32,89.43 226.32,89.39 226.55,89.16 226.86,89.16 227.1,88.92 227.1,87.24 225.16,85.3 221.31,85.3 220.87,85.73 212.98,85.73 212.3,85.06 205.09,85.06 203.95,83.91 202.31,83.91 202,84.23 202,85.31 201.57,85.73 195.54,85.73 195.21,86.06 195.21,86.77 v3(194.8,87.18)
  BOTTOM w0.089: v3(194.8,87.18) UV1.F26
FBC_D35: length 37.8
  TOP w0.089: UV12.T2 v3(225.91,88.76)
  IN5 w0.119: v3(225.91,88.76) 226.3,88.36 226.3,87.71 225.91,87.31 225.91,86.68 225.41,86.18 205.58,86.18 204.88,85.47 202.34,85.47 201.21,86.6 200.51,86.6 199.94,87.17 198.99,87.17 198.59,87.57 193.59,87.57 v3(193.2,87.18)
  BOTTOM w0.089: v3(193.2,87.18) UV1.H26
FBC_D36: length 32.9
  TOP w0.089: UV12.N4 v3(222.71,90.36)
  IN5 w0.119: v3(194,88.78) 194.4,89.18 194.4,89.73 194.65,89.98 196.64,89.98 196.91,90.26 198.88,90.26 200.34,91.72 201.49,91.72 202.1,92.32 212.25,92.32 212.37,92.44 219.09,92.44 221.58,89.96 222.31,89.96 v3(222.71,90.36)
  BOTTOM w0.089: v3(194,88.78) UV1.G27
FBC_D37: length 32.6
  TOP w0.089: UV12.N2 v3(223.51,88.76)
  IN5 w0.119: v3(194.8,88.78) 194.8,88.98 195.37,89.55 196.56,89.55 196.98,89.97 199.04,89.97 200.28,91.21 201.7,91.21 202.37,91.88 212.43,91.88 212.55,92 218.87,92 221.71,89.16 223.11,89.16 v3(223.51,88.76)
  BOTTOM w0.089: UV1.F27 v3(194.8,88.78)
FBC_D38: length 35
  TOP w0.089: UV12.M4 v3(221.91,90.36)
  IN5 w0.119: v3(192.4,88.78) 192.8,89.18 192.8,90.59 192.99,90.78 198.85,90.78 199.68,91.61 199.68,91.72 200.95,92.99 202.06,92.99 202.28,92.77 212.06,92.77 212.19,92.9 220.24,92.9 221.24,91.9 221.24,91.03 v3(221.91,90.36)
  BOTTOM w0.089: UV1.J27 v3(192.4,88.78)
FBC_D39: length 32.7
  TOP w0.089: UV12.M2 v3(221.91,88.76)
  IN5 w0.119: v3(221.91,88.76) 221.66,88.76 218.87,91.55 212.74,91.55 212.62,91.43 203.06,91.43 201.92,90.28 199.8,90.28 199.01,89.5 197.68,89.5 197.36,89.18 195.45,89.18 195.2,88.93 195.2,88.62 194.96,88.38 193.59,88.38 v3(193.2,88.78)
  BOTTOM w0.089: UV1.H27 v3(193.2,88.78)
FBC_D40: length 41.3
  TOP w0.089: UV12.U11 v3(226.71,95.16)
  IN6 w0.119: v3(226.71,95.16) 226.32,94.77 221.43,94.77 220.79,95.4 220.79,96.14 220.49,96.44 220.16,96.44 219.93,96.21 219.93,95.82 218.86,94.76 218.86,94.35 218.44,93.93 211.75,93.93 211.51,93.69 210.72,92.9 210.41,92.9 204.44,86.94 204.44,85.02 202.08,82.66 200.47,82.66 200,83.13 197.4,83.13 196.79,83.74 196.79,84.38 v3(196.4,84.78)
  BOTTOM w0.089: UV1.E23 v3(196.4,84.78)
FBC_D41: length 40
  TOP w0.089: UV12.U13 v3(225.91,97.56)
  IN6 w0.119: v3(225.91,97.56) 225.53,97.18 225.53,95.8 225.28,95.55 221.72,95.55 220.58,96.69 219.99,96.69 219.64,96.34 218.47,96.34 218.25,96.13 218.25,95.34 217.68,94.77 211,94.77 204.03,87.8 204.03,85.19 201.91,83.07 200.66,83.07 200.22,83.52 197.66,83.52 v3(197.2,83.98)
  BOTTOM w0.089: UV1.D21 v3(197.2,83.98)
FBC_D42: length 41.6
  TOP w0.089: UV12.T11 225.76,95.56 226.13,95.93 226.4,95.93 227.08,96.62 227.08,97.18 v3(226.71,97.56)
  IN6 w0.119: v3(197.2,84.78) 197.59,85.17 200.99,85.17 201.87,86.05 201.87,88.04 203.89,90.07 203.89,90.85 209.4,96.36 217.31,96.36 218.32,97.36 218.32,97.74 218.53,97.96 221.34,97.96 222.15,97.14 224.49,97.14 224.73,97.39 224.73,97.77 224.92,97.96 226.3,97.96 v3(226.71,97.56)
  BOTTOM w0.089: UV1.D23 v3(197.2,84.78)
FBC_D43: length 39.2
  TOP w0.089: UV12.T13 v3(225.11,97.56)
  IN6 w0.119: v3(225.11,97.56) 225.11,97.36 224.73,96.98 224.73,96.49 224.6,96.36 221.68,96.36 221.49,96.55 221.49,96.97 221.32,97.14 218.45,97.14 218,96.69 218,95.72 217.83,95.55 213.76,95.55 213.35,95.14 208.77,95.14 204.3,90.68 204.3,89.96 202.25,87.91 202.25,85.69 202.06,85.5 202.06,83.8 201.74,83.48 200.98,83.48 199.69,84.77 198.01,84.77 v3(198,84.78)
  BOTTOM w0.089: UV1.C23 v3(198,84.78)
FBC_D44: length 37.3
  TOP w0.089: 222.58,98.92 222.69,98.8 222.69,98.24 222.61,98.16 222.61,97.75 222.8,97.56 222.8,95.86 UV12.N11
  TOP w0.157: v3(222.74,100.36) 222.82,100.28 222.82,99.85 222.58,99.6 222.58,98.92
  IN6 w0.119: v3(222.74,100.36) 222.42,100.04 217.55,100.04 217.49,100.1 216.05,100.1 215.27,99.32 209.36,99.32 204.03,93.98 204.03,93.7 201.67,91.35 200.59,91.35 199.91,90.66 199.91,86.48 v3(199.8,86.38)
  BOTTOM w0.089: UV1.A24 v3(199.8,86.38)
FBC_D45: length 37.3
  TOP w0.089: 223.2,98.92 223.2,98.61 222.88,98.28 222.88,98.16 222.8,98.08 222.8,97.83 223.11,97.53 UV12.N13
  TOP w0.157: v3(223.33,100.48) 223.46,100.48 223.59,100.36 v1(223.59,100.04) 223.59,99.81 223.2,99.43 223.2,98.92
  IN6 w0.119: v3(198.8,86.38) 199.2,85.98 199.98,85.98 200.3,86.3 200.76,86.76 200.76,89.1 201.11,89.44 202.32,90.65 202.32,91.42 204.44,93.53 204.44,93.81 209.55,98.92 217.07,98.92 217.83,99.68 222.67,99.68 223.33,100.35 v3(223.33,100.48)
  BOTTOM w0.089: UV1.B24 v3(198.8,86.38)
FBC_D46: length 40.8
  TOP w0.089: 221.88,98.92 221.88,98.29 222,98.16 222,97.75 222.19,97.56 222.38,97.56 222.61,97.33 222.61,95.86 UV12.M11
  TOP w0.157: v3(222.19,100.61) 222.19,100.22 v1(222.05,100.08) 221.88,99.91 221.88,98.92
  IN6 w0.119: v3(222.19,100.61) 221.29,101.51 216.31,101.51 214.93,100.14 208.47,100.14 203.41,95.08 202.83,95.08 202.46,94.71 199.78,92.02 199.78,91.24 199.4,90.86 199.4,88.02 198.35,86.98 198.15,86.78 196.8,86.78 v3(196.4,86.38)
  BOTTOM w0.089: UV1.E24 v3(196.4,86.38)
FBC_D47: length 37.5
  TOP w0.089: UV12.M13 221.81,97.65 221.81,98.08 221.69,98.21 221.69,98.48 221.61,98.56 221.25,98.92
  TOP w0.157: v3(221.55,100.61) 221.55,100.42 221.24,100.1 221.24,98.93 221.25,98.92
  IN6 w0.119: v3(197.2,86.38) 198.18,86.38 199.65,87.85 199.65,90.77 200.64,91.76 201.51,91.76 202.06,92.31 202.06,93.15 208.64,99.73 215.1,99.73 216.52,101.14 221.1,101.14 221.55,100.69 v3(221.55,100.61)
  BOTTOM w0.089: UV1.D24 v3(197.2,86.38)
FBC_D48: length 25.5
  TOP w0.089: UV12.A11 v3(213.91,95.16)
  IN3 w0.112: v3(197.2,79.18) 197.6,79.58 199.19,79.58 201.64,82.03 202.25,82.03 206.79,86.57 206.79,88.39 213.55,95.16 v3(213.91,95.16)
  BOTTOM w0.089: UV1.D15 v3(197.2,79.18)
FBC_D49: length 25.6
  TOP w0.089: UV12.A13 212.97,97.16
  TOP w0.13: 212.97,97.16 212.72,96.92 212.72,96.14 v3(212.97,95.9)
  IN3 w0.112: v3(198,79.98) 198.83,79.98 201.33,82.47 202.06,82.47 206.34,86.75 206.34,88.58 212.98,95.22 212.98,95.89 v3(212.97,95.9)
  BOTTOM w0.089: UV1.C17 v3(198,79.98)
FBC_D50: length 28.5
  TOP w0.089: UV12.B11 v3(214.71,95.16)
  IN3 w0.112: v3(214.71,95.16) 214.32,94.77 214.32,94.21 213.99,93.88 212.91,93.88 207.23,88.21 207.23,86.38 202.43,81.58 201.82,81.58 199,78.76 197.05,78.76 196.8,79.01 196.8,79.58 v3(197.2,79.98)
  BOTTOM w0.089: UV1.D17 v3(197.2,79.98)
FBC_D51: length 27.9
  TOP w0.089: 212.67,97.28 212.85,97.46 214,97.46 UV12.B13
  TOP w0.157: v3(212.4,95.89) 212.4,97.01 212.67,97.28
  IN3 w0.112: v3(212.4,95.89) 212.4,95.27 205.89,88.76 205.89,88.4 204.45,86.95 204.45,86.16 203.49,85.2 203.49,84.53 201.88,82.92 201.14,82.92 198.59,80.37 196.79,80.37 v3(196.4,79.98)
  BOTTOM w0.089: UV1.E17 v3(196.4,79.98)
FBC_D52: length 32.2
  TOP w0.089: UV12.E11 v3(217.11,95.96)
  IN3 w0.112: v3(217.11,95.96) 216.72,96.35 216.72,96.93 216.49,97.16 214.6,97.16 214.07,97.69 211.3,97.69 201.62,88.01 201.62,87 200.05,85.44 200.05,83.87 197.36,81.18 196,81.18 v3(195.6,81.58)
  BOTTOM w0.089: UV1.F18 v3(195.6,81.58)
FBC_D53: length 32.8
  TOP w0.089: 216.78,98.92 217.01,98.69 217.01,97.47 216.71,97.16 UV12.E13
  TOP w0.157: v3(216.51,99.63) 216.51,99.19 216.78,98.92
  IN3 w0.112: v3(196.4,81.58) 196.8,81.98 196.8,82.84 197.6,83.64 197.6,85.73 199.18,87.31 199.88,87.31 200.72,88.15 200.72,88.38 211.98,99.63 v3(216.51,99.63)
  BOTTOM w0.089: UV1.E18 v3(196.4,81.58)
FBC_D54: length 33.3
  TOP w0.089: 218.16,98.92 218.16,98.43 217.91,98.17 217.91,96.29 217.51,95.89 UV12.F11
  TOP w0.157: v3(217.93,99.15) 218.16,98.92 218.16,98.92
  IN3 w0.112: v3(197.2,82.38) 198.6,83.77 198.6,84.62 201.17,87.19 201.17,88.19 210.13,97.15 211.93,98.96 217.74,98.96 v3(217.93,99.15)
  BOTTOM w0.089: UV1.D20 v3(197.2,82.38)
FBC_D55: length 34.3
  TOP w0.089: UV12.F13 217.2,97.46 217.2,98.78 217.34,98.92
  TOP w0.157: v3(217.17,99.66) 217.17,99.32 217.34,99.15 217.34,98.92
  IN3 w0.112: v3(217.17,99.66) 216.73,100.1 211.82,100.1 201.78,90.07 199.54,90.07 196.8,87.33 196.8,83.61 196.4,83.21 v3(196.4,82.38)
  BOTTOM w0.089: UV1.E20 v3(196.4,82.38)
FBC_D56: length 25.4
  TOP w0.089: UV12.A4 v3(213.11,89.56)
  IN2 w0.119: v3(213.11,89.56) 213.26,89.41 213.26,88.75 210.44,85.93 209.58,85.93 204.2,80.55 199.47,80.55 198.05,81.98 194.4,81.98 v3(194,82.38)
  BOTTOM w0.089: UV1.G20 v3(194,82.38)
FBC_D57: length 25.7
  TOP w0.089: UV12.A2 213.34,88.19 212.67,87.52
  TOP w0.157: 212.67,87.52 212.38,87.23 v3(212.38,87.06)
  IN2 w0.119: v3(193.2,82.38) 193.61,81.97 193.61,81.42 193.96,81.06 198.14,81.06 199.1,80.11 204.39,80.11 209.77,85.49 210.63,85.49 212.2,87.06 v3(212.38,87.06)
  BOTTOM w0.089: UV1.H20 v3(193.2,82.38)
FBC_D58: length 25.5
  TOP w0.089: 212.67,89.57 212.67,89.63 213.31,90.27 213.99,90.27 UV12.B4
  TOP w0.157: v3(212.54,89.58) 212.62,89.58 212.64,89.56 arc(212.66,89.55) 212.67,89.57
  IN2 w0.119: v3(212.54,89.58) 212.42,89.46 212.42,88.54 210.26,86.38 209.4,86.38 204.02,81 199.73,81 197.96,82.77 195.19,82.77 v3(194.8,82.38)
  BOTTOM w0.089: UV1.F20 v3(194.8,82.38)
FBC_D59: length 25.8
  TOP w0.089: 212.67,88.31 213.02,88.66 214,88.66 UV12.B2
  TOP w0.157: v3(210.91,88.04) 212.4,88.04 212.67,88.31
  IN2 w0.119: v3(210.91,88.04) 210.42,88.04 203.83,81.45 199.79,81.45 197.99,83.25 193.93,83.25 v3(193.2,83.98)
  BOTTOM w0.089: UV1.H21 v3(193.2,83.98)
FBC_D60: length 28.8
  TOP w0.089: UV12.E4 v3(217.11,90.36)
  IN2 w0.119: v3(194.8,84.78) 195.19,85.17 198.98,85.17 201.08,83.08 203.16,83.08 211.63,91.55 216.47,91.55 216.72,91.3 216.72,90.75 v3(217.11,90.36)
  BOTTOM w0.089: UV1.F23 v3(194.8,84.78)
FBC_D61: length 32.2
  TOP w0.089: UV12.E2 v3(217.11,88.76)
  IN2 w0.119: v3(217.11,88.76) 217.5,89.15 217.5,91.32 216.82,92 211.44,92 202.97,83.52 201.32,83.52 199.42,85.42 194.91,85.42 194.27,84.78 v3(194,84.78)
  BOTTOM w0.089: UV1.G23 v3(194,84.78)
FBC_D62: length 31
  TOP w0.089: UV12.F4 v3(217.91,90.36)
  IN2 w0.119: v3(193.21,84.75) 193.62,85.15 194.18,85.15 194.76,85.73 203.23,85.73 209.94,92.44 217.18,92.44 218.3,91.32 218.3,90.75 v3(217.91,90.36)
  BOTTOM w0.089: v3(193.21,84.75) 193.41,84.94 193.6,85.14 UV1.H23
FBC_D63: length 36.5
  TOP w0.089: UV12.F2 v3(217.11,87.96)
  IN2 w0.119: v3(191.41,84.74) 192.66,85.98 200.15,85.98 207.05,92.89 217.09,92.89 218.55,91.42 218.55,89.63 218.01,89.09 218.01,88.86 v3(217.11,87.96)
  BOTTOM w0.089: UV1.K23 191.85,85.18 v3(191.41,84.74)
FBC_DBI0#: length 36.6
  IN1 w0.119: v3(196.4,71.98) 196.8,71.58 200.21,71.58 203.58,74.96 204.04,75.41 206.44,77.81 206.44,78.89 210.26,82.71 211.61,82.71 212.96,84.06 215.17,84.06 215.69,84.58 217.69,84.58 220.89,87.78 224.14,87.78 v3(224.31,87.96)
  BOTTOM w0.089: UV13.D2 v3(224.31,87.96) ; UV1.E6 v3(196.4,71.98)
FBC_DBI1#: length 41.1
  IN3 w0.112: v3(195.6,74.38) 195.6,74.62 195.21,75.01 195.21,75.4 195.84,76.04 200.46,76.04 201.06,76.64 201.26,76.64 212.62,88 212.91,88 214.3,89.39 214.3,89.7 214.54,89.95 218.06,89.95 218.46,90.36 219.55,90.36 222.89,93.69 222.89,94.64 223.12,94.87 223.12,96.37 v3(223.51,96.76)
  BOTTOM w0.089: UV1.E9 v3(195.6,74.38) ; UV13.D13 v3(223.51,96.76)
FBC_DBI2#: length 37.7
  IN1 w0.119: v3(193.2,79.98) 192.79,79.57 192.79,78.91 192.98,78.72 193.9,78.72 194.28,78.34 199.14,78.34 205.23,84.44 205.23,85.52 207.89,88.17 207.89,91.8 209.42,93.33 213.64,93.33 214.31,94.01 214.31,94.64 214.44,94.77 214.91,94.77 215.11,94.97 215.11,97.16 v3(215.51,97.56)
  BOTTOM w0.089: v3(215.51,97.56) UV13.P13 ; UV1.H17 v3(193.2,79.98)
FBC_DBI3#: length 24.7
  IN6 w0.119: v3(215.51,87.96) 215.11,87.56 214.53,87.56 214.31,87.34 214.31,86.79 213.36,85.84 212.62,85.84 211.42,84.63 210.34,84.63 204.24,78.53 202.54,78.53 201.32,77.31 200.71,77.31 199.77,76.38 197.86,76.38 197.46,76.78 v3(197.2,76.78)
  BOTTOM w0.089: UV13.P2 v3(215.51,87.96) ; UV1.D12 v3(197.2,76.78)
FBC_DBI4#: length 37.1
  TOP w0.089: UV12.P2 v3(224.31,88.76)
  IN5 w0.119: v3(224.31,88.76) 224.31,88.51 223.64,87.85 220.86,87.85 218.75,89.96 213.54,89.96 213.43,90.07 210.42,90.07 209.41,89.05 204.98,89.05 204.38,88.45 203.75,88.45 203.5,88.7 202.09,88.7 201.31,87.92 199.45,87.92 199.23,88.13 192.93,88.13 192.68,88.38 191.79,88.38 v3(191.4,88.78)
  BOTTOM w0.089: UV1.K27 191.6,88.78 v3(191.4,88.78)
FBC_DBI5#: length 38.1
  TOP w0.089: UV12.P13 v3(223.51,97.56)
  IN6 w0.119: v3(223.51,97.56) 222.13,97.56 221.55,98.13 221.55,98.59 221.25,98.9 219.1,98.9 217.38,97.17 209.5,97.17 203.39,91.06 203.39,90.28 201.44,88.33 201.44,86.33 200.55,85.45 196.28,85.45 196,85.18 196,84.38 v3(196.4,83.98)
  BOTTOM w0.089: UV1.E21 v3(196.4,83.98)
FBC_DBI6#: length 31
  TOP w0.089: UV12.D13 v3(215.51,96.76)
  IN3 w0.112: v3(215.51,96.76) 215.11,96.36 212.16,96.36 211.86,96.06 211.86,95.5 211.51,95.15 210.82,95.15 203.91,88.23 203.91,86.38 203.28,85.75 202.57,85.75 202.06,85.24 202.06,83.87 201.65,83.47 200.91,83.47 198.09,80.64 195.47,80.64 v3(194.8,79.98)
  BOTTOM w0.089: UV1.F17 v3(194.8,79.98)
FBC_DBI7#: length 30.2
  TOP w0.089: UV12.D2 v3(215.51,88.76)
  IN2 w0.119: v3(192.4,84.78) 192.81,84.37 198.16,84.37 198.65,83.88 199.66,83.88 201,82.53 203.38,82.53 211.6,90.75 214.87,90.75 215.1,90.52 215.1,89.16 v3(215.51,88.76)
  BOTTOM w0.089: UV1.J23 v3(192.4,84.78)
FBC_EDC0: length 36.9
  IN1 w0.119: v3(225.11,87.96) 224.61,87.45 222.05,87.45 221.77,87.17 221.77,86.77 221.45,86.45 220.19,86.45 217.79,84.05 217.4,84.05 216.91,83.56 213.17,83.56 211.82,82.21 210.47,82.21 207.03,78.77 207.03,77.69 201.47,72.12 201.11,71.77 200.81,71.47 200.44,71.1 197.28,71.1 v3(197.2,71.18)
  BOTTOM w0.089: UV1.D6 v3(197.2,71.18) ; UV13.C2 v3(225.11,87.96)
FBC_EDC1: length 41.9
  IN3 w0.112: v3(195.6,75.18) 196.02,75.59 200.98,75.59 201.21,75.83 201.37,75.83 201.65,75.55 201.8,75.55 201.96,75.71 201.96,75.87 201.69,76.14 201.69,76.3 210.44,85.05 211.84,85.05 212.81,86.02 213.43,86.02 214.3,86.9 214.3,88.1 214.54,88.35 217.26,88.35 218.66,89.75 219.84,89.75 223.91,93.82 223.91,96.36 v3(224.31,96.76)
  BOTTOM w0.089: UV1.F11 v3(195.6,75.18) ; UV13.C13 v3(224.31,96.76)
FBC_EDC2: length 35.3
  IN1 w0.119: v3(193.2,79.18) 193.6,79.58 194.18,79.58 194.21,79.55 194.39,79.37 194.39,78.98 194.71,78.66 198.74,78.66 204.47,84.39 204.47,86.81 207.38,89.71 207.38,92.09 209.2,93.91 212.7,93.91 213.57,94.77 214.06,94.77 214.31,95.02 214.31,97.11 v3(214.76,97.56)
  BOTTOM w0.089: UV1.H15 193.6,78.78 v3(193.2,79.18) ; v3(214.76,97.56) 215.11,97.21 UV13.R13
FBC_EDC3: length 24
  IN6 w0.119: v3(197.2,77.58) 197.6,77.18 198.4,77.18 198.76,76.82 199.86,76.82 200.86,77.82 201.11,77.82 202.33,79.03 204.03,79.03 211.26,86.26 213.19,86.26 213.5,86.58 213.5,87.35 213.7,87.56 214.15,87.56 214.55,87.96 v3(214.71,87.96)
  BOTTOM w0.089: UV13.R2 v3(214.71,87.96) ; UV1.C14 v3(197.2,77.58)
FBC_EDC4: length 36.2
  TOP w0.089: UV12.R2 v3(225.11,88.76)
  IN5 w0.119: v3(225.11,88.76) 224.71,89.16 224.13,89.16 223.9,88.93 223.9,88.55 223.59,88.23 220.92,88.23 220.22,88.93 220.22,89.18 218.64,90.76 207.62,90.76 207.5,90.64 207.5,89.96 207.38,89.84 207.15,89.84 207.03,89.96 207.03,90.64 206.91,90.76 206.67,90.76 206.55,90.64 206.55,89.96 206.43,89.84 206.19,89.84 206.07,89.96 206.07,90.64 205.95,90.76 203.38,90.76 202.36,89.74 200.74,89.74 200.6,89.88 199.9,89.88 198.4,88.38 196.74,88.38 v3(196.34,88.78)
  BOTTOM w0.089: v3(196.34,88.78) 196,88.43 UV1.E27
FBC_EDC5: length 38.5
  TOP w0.089: UV12.R13 v3(224.31,97.56)
  IN6 w0.119: v3(195.6,86.38) 196.23,85.75 200.14,85.75 201.11,86.72 201.11,88.73 202.83,90.44 202.83,91.21 209.31,97.69 214.19,97.69 214.51,98.01 217.74,98.01 218.96,99.23 221.46,99.23 221.87,98.82 221.87,98.26 222.16,97.97 224.14,97.97 224.31,97.81 v3(224.31,97.56)
  BOTTOM w0.089: UV1.F24 v3(195.6,86.38)
FBC_EDC6: length 31.4
  TOP w0.089: UV12.C13 v3(214.71,96.76)
  IN3 w0.112: v3(193.2,81.58) 193.89,80.89 197.77,80.89 200.73,83.85 200.73,85.34 202.16,86.78 202.16,87.96 211.35,97.15 214.12,97.15 214.51,96.76 v3(214.71,96.76)
  BOTTOM w0.089: UV1.H18 193.6,81.18 v3(193.2,81.58)
FBC_EDC7: length 27.4
  TOP w0.089: UV12.C2 v3(214.71,88.76)
  IN2 w0.119: v3(214.71,88.76) 214.32,89.15 214.32,89.82 214.01,90.13 211.74,90.13 203.61,81.99 199.75,81.99 199.12,82.62 199.12,82.79 199.49,83.15 199.49,83.32 199.32,83.49 199.15,83.49 198.78,83.13 198.61,83.13 198.16,83.58 195.19,83.58 v3(194.8,83.98)
  BOTTOM w0.089: UV1.G21 v3(194.8,83.98)
FBC_MA0_MA10_H: length 35.2
  TOP w0.089: UV12.K4 220.64,90.03 220.64,90.3 220.81,90.47 220.93,90.47 221.01,90.39 221.01,89.54 220.93,89.46 220.75,89.46 220.4,89.81 220.4,90.96 218.89,92.47 213.36,92.47 212.82,91.94 212.67,91.94
  TOP w0.157: v3(202.69,87.49) 203.33,87.49 203.43,87.59 203.43,87.77 203.57,87.91 203.77,87.91 203.91,87.77 203.91,87.57 203.99,87.49 204.23,87.49 204.38,87.64 204.38,88.05 205.29,88.96 205.72,88.96 205.95,88.72 205.95,88.46 205.76,88.27 205.76,87.98 205.87,87.87 206.19,87.87 206.8,88.48 206.8,88.68 206.4,89.08 206.4,89.28 206.54,89.42 206.97,89.42 v1(208.97,91.41) 209.5,91.94 212.67,91.94
  BOTTOM w0.157: UV1.B26 198.4,87.28 198.5,87.18 199.57,87.18 199.7,87.05 200.65,87.05 200.95,87.35 201.67,87.35 201.85,87.54 201.85,88.92 202.04,89.11 202.3,89.11 202.49,88.92 202.49,87.69 v3(202.69,87.49)
FBC_MA0_MA10_L: length 37.4
  BOTTOM w0.089: 218.8,91.26 218.8,89.83 218.98,89.65 220.4,89.65 UV13.H4 ; 200.6,73.24 199.29,71.92 198.75,71.92 UV1.B6
  BOTTOM w0.157: 218.8,91.26 218.01,92.05 213.39,92.05 212.83,91.5 212.39,91.5 209,88.1 209,81.41 207.78,80.19 206.29,78.7 206.29,77.43 v1(205.42,76.57) 204.7,75.85 203.7,75.85 202.25,74.4 202.1,74.4 201.1,73.4 200.77,73.4 200.6,73.24
FBC_MA1_MA9_H: length 35.3
  TOP w0.089: 212.67,92.38 212.89,92.38 213.17,92.66 218.97,92.66 219.74,91.9 219.85,91.9 220.5,92.55 220.65,92.55 220.76,92.44 220.76,92.3 220.1,91.64 220.1,91.55 220.28,91.37 220.36,91.37 221.51,92.53 221.6,92.62 221.74,92.62 221.84,92.51 221.84,92.35 221.66,92.17 221.66,92.05 221.76,91.95 221.76,91.83 221.63,91.7 221.51,91.7 221.41,91.8 221.29,91.8 221.16,91.67 221.16,91.54 221.25,91.45 221.25,91.32 221.13,91.2 221,91.2 220.91,91.29 220.78,91.29 220.61,91.12 220.61,91.03 220.71,90.93 UV12.K5
  TOP w0.157: 212.67,92.38 209.31,92.38 206.79,89.86 205.54,89.86 204.02,88.34 203.38,88.34 203.18,88.55 203.18,88.77 203.03,88.91 202.83,88.91 v1(202.68,88.77) 202.68,88.25 202.88,88.04 v3(202.97,88.04)
  BOTTOM w0.157: UV1.A26 199.75,87.58 199.86,87.47 200.6,87.47 201.42,88.29 201.42,89.1 201.99,89.68 202.79,89.68 203.02,89.45 203.02,88.09 v3(202.97,88.04)
FBC_MA1_MA9_L: length 37.7
  BOTTOM w0.089: UV13.H5 221.01,90.45 221.01,89.83 220.64,89.46 218.9,89.46 218.61,89.75 218.61,91.05 217.94,91.72
  BOTTOM w0.157: 217.94,91.72 213.65,91.72 212.83,90.9 212.42,90.9 209.43,87.91 209.43,81.23 208.22,80.01 208.22,80.01 v1(207.68,79.48) 206.73,78.52 206.73,77.25 204.88,75.41 203.88,75.41 202.44,73.96 202.41,73.96 201.41,72.97 200.83,72.97 199.44,71.58 UV1.A6
FBC_MA2_BA0_H: length 38.5
  TOP w0.089: 212.67,93.69 212.83,93.69 213.28,93.23 219.46,93.23 219.48,93.25 220.31,93.25 221.01,93.96 221.01,95.48 220.93,95.56 UV12.K11
  TOP w0.157: v3(204.37,89.31) 204.37,90.69 204.81,91.13 204.81,91.35 204.33,91.82 204.33,92.06 204.5,92.22 204.73,92.22 205.21,91.75 205.43,91.75 205.6,91.92 205.6,92.15 205.25,92.5 205.25,92.74 205.41,92.9 205.65,92.9 206,92.54 206.23,92.54 206.4,92.72 206.4,92.94 206.06,93.29 206.06,93.52 206.22,93.69 206.46,93.69 206.8,93.34 207.02,93.34 207.37,93.69 v1(208,93.69) 212.67,93.69
  BOTTOM w0.157: v3(204.37,89.31) 204.36,89.32 203.72,89.32 203.46,89.05 203.46,87.87 203.19,87.61 203.19,84.28 201.93,83.02 201.2,83.02 200.18,82 199.01,82 198.62,82.39 197.99,82.39 UV1.C20
FBC_MA2_BA0_L: length 34.3
  IN4 w0.112: v3(221.43,93.36) 221.38,93.41 220.81,93.41 220.35,92.95 219.78,92.95 218.68,91.84 210.64,91.84 205.78,86.99 205.4,86.99 v3(205.36,87.02)
  BOTTOM w0.089: UV13.H11 221.01,95.25 221.01,93.77 v3(221.43,93.36)
  BOTTOM w0.157: UV1.B15 199.24,79.61 200.74,79.61 201.62,80.49 v1(202.05,80.49) 203.13,80.49 205.39,82.75 205.39,85.9 205.49,85.99 205.49,86.9 v3(205.36,87.02)
FBC_MA3_BA3_H: length 38.8
  TOP w0.089: 212.67,94.12 212.71,94.12 213.41,93.42 219.38,93.42 219.4,93.44 219.59,93.44 219.69,93.54 219.69,93.84 219.79,93.95 219.94,93.95 220.04,93.84 220.04,93.72 220.18,93.59 220.37,93.59 220.51,93.72 220.51,93.95 220.76,94.2 220.76,94.7 UV12.K10
  TOP w0.157: 212.67,94.12 205.78,94.12 205.07,93.41 204.85,93.41 204.1,94.16 203.87,94.16 203.7,93.99 203.7,93.76 204.45,93.01 204.45,92.79 203.77,92.12 v1(203.77,91.19) 203.77,89.59 203.57,89.39 203.57,89.01 203.74,88.84 203.88,88.84 v3(203.92,88.88)
  BOTTOM w0.157: UV1.C18 198.01,81.59 200.27,81.59 201.13,82.45 202.62,82.45 202.82,82.65 202.82,82.88 202.73,82.97 202.73,83.2 202.9,83.37 203.12,83.37 203.22,83.28 203.44,83.28 203.65,83.48 203.65,87.4 204.03,87.78 204.03,88.78 v3(203.92,88.88)
FBC_MA3_BA3_L: length 32.6
  IN4 w0.112: v3(205.03,86.44) 205.06,86.41 205.83,86.41 207.02,87.59 209.68,87.59 209.81,87.72 210.5,87.72 210.63,87.59 211.13,87.59 212.2,88.66 213.03,88.66 213.52,89.15 213.52,89.72 213.76,89.96 218.19,89.96 220.99,92.76 v3(220.99,93.02)
  BOTTOM w0.089: UV13.H10 220.71,93.3 v3(220.99,93.02)
  BOTTOM w0.157: UV1.B17 198.82,79.96 200.47,79.96 201.44,80.93 202.95,80.93 204.96,82.93 v1(204.96,85.13) 204.96,86.36 v3(205.03,86.44)
FBC_MA4_BA2_H: length 39.4
  TOP w0.089: UV12.H11 219.16,95.51 219.53,95.51 219.66,95.38 219.66,95.2 219.53,95.07 218.94,95.07 218.8,94.94 218.8,94.27 218.33,93.81 213.66,93.81 213.01,94.46 213.01,94.85 212.85,95 212.68,95 212.67,95.01
  TOP w0.157: 212.67,95.01 210.26,95.01 210.14,95.13 210.14,96.07 210.01,96.2 209.54,96.2 209.41,96.07 209.41,95.13 209.29,95 208.9,95 208.74,95.16 v1(208.74,95.67) 208.74,96.04 208.59,96.2 204.36,96.2 202.38,94.21 202.38,92.74 202.8,92.32 202.8,90.33 201.74,89.28 201.74,86.67 201.53,86.46 v3(201.53,85.12)
  BOTTOM w0.157: UV1.B20 198.64,82.78 199.03,82.39 200.04,82.39 201.17,83.52 201.71,83.52 201.73,83.53 201.74,83.53 202.02,83.81 202.02,84.36 201.82,84.56 201.82,84.79 201.53,85.07 v3(201.53,85.12)
FBC_MA4_BA2_L: length 33.6
  IN4 w0.112: v3(219.33,93.9) 218.17,92.74 209.65,92.74 207.04,90.13 206.83,90.13 206.52,90.44 206.3,90.44 206.09,90.23 206.09,90.02 206.41,89.7 206.41,89.49 v3(205.46,88.55)
  BOTTOM w0.089: UV13.K11 219.11,95.54 219.6,95.05 219.6,94.17 v3(219.33,93.9)
  BOTTOM w0.157: UV1.A15 199.59,79.16 200.75,79.16 200.93,79.35 201.09,79.35 201.8,80.06 203.31,80.06 v1(204.51,81.25) 205.94,82.68 205.94,88.07 v3(205.46,88.55)
FBC_MA5_BA1_H: length 38.7
  TOP w0.089: 212.67,94.56 212.72,94.56 212.82,94.46 212.82,94.38 213.2,94 213.2,93.95 213.54,93.61 218.41,93.61 218.44,93.64 218.65,93.64 218.8,93.79 218.8,94 219.11,94.31 219.49,94.31 219.63,94.45 219.63,94.64 219.49,94.78 219.13,94.78 UV12.H10
  TOP w0.157: v3(201.53,83.95) 201.75,83.95 202.01,84.22 202.01,86.32 202.19,86.49 202.19,89.1 202.58,89.5 203.06,89.5 203.27,89.7 203.27,94.49 203.47,94.69 204.98,94.69 205.11,94.82 205.11,95.64 205.23,95.76 205.63,95.76 205.75,95.64 205.75,94.69 205.88,94.56 206.2,94.56 206.35,94.72 v1(206.35,95.11) 206.35,95.61 206.51,95.76 206.76,95.76 206.92,95.61 206.92,94.72 207.07,94.56 207.32,94.56 207.48,94.72 207.48,95.61 207.64,95.76 207.89,95.76 208.04,95.61 208.04,94.72 208.2,94.56 212.67,94.56
  BOTTOM w0.157: v3(201.53,83.95) 200.97,83.95 199.79,82.78 UV1.A20
FBC_MA5_BA1_L: length 39.7
  BOTTOM w0.157: UV1.C15 198.04,78.33 200.29,78.33 200.87,78.91 201.27,78.91 201.98,79.62 203.49,79.62 206.37,82.5 206.37,89.19 206.58,89.39 206.58,89.62 206.27,89.92 206.27,90.14 206.45,90.32 206.67,90.32 206.98,90.01 207.2,90.01 207.37,90.19 207.37,90.41 207.07,90.72 207.07,90.94 207.25,91.12 207.47,91.12 207.77,90.81 208,90.81 208.17,90.99 208.17,91.21 207.87,91.52 207.87,91.74 208.04,91.91 208.27,91.91 208.57,91.61 208.79,91.61 208.97,91.79 208.97,92.01 208.66,92.31 208.66,92.54 v1(208.75,92.62) 208.84,92.71 209.06,92.71 209.37,92.41 209.59,92.41 209.77,92.58 209.77,92.81 209.46,93.11 209.46,93.33 209.64,93.51 209.86,93.51 210.17,93.2 210.39,93.2 210.56,93.38 210.56,93.6 210.26,93.91 210.26,94.13 210.44,94.31 210.66,94.31 210.96,94 211.19,94 211.71,94.53 213.03,94.53 213.64,93.92 218.27,93.92 UV13.K10
FBC_MA6_MA11_H: length 39.5
  TOP w0.089: UV12.H5 219.11,90.35 219.21,90.24 219.36,90.24 219.46,90.35 219.46,90.94 219.27,91.12 218.79,91.12 218.09,91.82 214.69,91.82 213.77,91.82 212.87,90.92 212.87,90.72 212.75,90.6 212.67,90.6
  TOP w0.157: 212.67,90.6 211.48,90.6 210.21,89.33 210.21,88.74 209.86,88.38 209.86,86.56 209.74,86.45 209.51,86.45 209.35,86.61 209.35,87.59 209.15,87.8 208.74,87.8 208.54,87.59 208.54,87.47 208.85,87.16 208.85,86.92 208.69,86.76 208.46,86.76 208.14,87.07 207.92,87.07 207.74,86.9 207.74,86.68 208.22,86.19 208.22,85.97 208.05,85.79 207.82,85.79 207.34,86.28 207.12,86.28 206.94,86.1 206.94,85.88 207.43,85.39 207.43,85.17 207.15,84.89 v1(206.68,84.89) 206.36,84.89 206.19,84.72 206.19,84.47 206.01,84.29 205.76,84.29 205.58,84.47 205.58,84.88 205.4,85.05 205.16,85.05 204.99,84.88 204.99,84.44 204.83,84.28 204.58,84.28 204.43,84.44 204.43,85.2 204.26,85.36 204.03,85.36 203.86,85.2 203.86,84.44 203.7,84.28 203.46,84.28 203.3,84.44 203.3,84.86 203.09,85.06 202.75,85.06 v3(202.73,85.04)
  BOTTOM w0.157: v3(202.73,85.04) 202.73,85.65 202.37,86.01 200.9,86.01 200.24,85.34 200.24,85.12 200.41,84.95 200.41,84.72 200.19,84.5 199.97,84.5 199.79,84.68 199.57,84.68 199.4,84.5 199.4,84.18 199.19,83.97 198.8,83.97 UV1.B21
FBC_MA6_MA11_L: length 37.4
  BOTTOM w0.089: UV1.C12 198.02,75.96 198.02,75.48 198.31,75.18 198.69,75.18 198.87,75 199.63,75 199.94,75.31 199.94,75.78 200.81,76.65 201.11,76.65 ; UV13.K5 219.11,91.35
  BOTTOM w0.157: 219.11,91.35 218.11,92.34 213.12,92.34 212.74,91.96 212.24,91.96 208.56,88.29 v1(208.56,83.59) 208.56,81.59 207.34,80.38 205.85,78.88 205.85,77.61 205.67,77.43 204.84,77.43 204.69,77.28 204.69,76.45 204.52,76.29 204.29,76.29 204.12,76.45 204.12,77.28 203.97,77.43 202.88,77.43 202.11,76.65 201.11,76.65
FBC_MA7_MA8_H: length 36.2
  TOP w0.089: 212.67,90.17 213.06,90.56 213.06,90.84 213.85,91.63 214.77,91.63 214.77,91.63 218.01,91.63 218.77,90.88 218.77,90.69 218.54,90.46 218.54,90.26 218.77,90.03 218.77,89.56 218.86,89.46 219.08,89.46 219.23,89.62 219.23,89.83 UV12.H4
  TOP w0.157: 212.67,90.17 211.84,90.17 210.78,89.11 210.78,88.65 210.34,88.2 210.34,87.87 210.79,87.42 211.65,87.42 211.79,87.29 211.79,86.29 211.52,86.02 211.2,86.02 211.04,86.18 211.04,86.67 210.89,86.83 210.64,86.83 210.48,86.67 210.48,86.18 210.32,86.02 209.94,86.02 209.74,85.82 209.52,85.82 209.22,86.12 209,86.12 v1(208.92,86.04) 208.82,85.95 208.82,85.72 209.12,85.42 209.12,85.2 208.94,85.02 208.72,85.02 208.42,85.33 208.2,85.33 208.02,85.15 208.02,84.93 208.32,84.63 208.32,84.4 207.77,83.85 207.31,83.85 207.15,84 207.15,84.3 206.99,84.46 206.75,84.46 206.59,84.3 206.59,84 206.43,83.85 202.55,83.85 202.45,83.95 202.45,84.44 v3(202.51,84.49)
  BOTTOM w0.157: UV1.A21 199.63,83.58 201.11,85.05 201.11,85.32 201.36,85.56 201.71,85.56 202.26,85.01 202.26,84.74 v3(202.51,84.49)
FBC_MA7_MA8_L: length 35.3
  BOTTOM w0.089: 201.11,77.09 201.02,77.09 201.01,77.08 200.83,77.08 199.63,75.88 199.63,75.41 199.46,75.23 199.06,75.23 198.86,75.43 198.86,75.86 199.2,76.2 UV1.A12 ; UV13.K4 219.41,90.26 219.41,91.46 219.12,91.76
  BOTTOM w0.157: 219.12,91.76 218.2,92.67 212.33,92.67 208.12,88.47 208.12,81.77 v1(205.24,78.89) 204.22,77.87 202.7,77.87 201.92,77.09 201.11,77.09
FBC_MA12_RFU_H: length 35.1
  TOP w0.089: UV12.J5 219.91,90.92 219.51,91.32 218.87,91.32 218.17,92.01 214.61,92.01 214.61,92.01 213.65,92.01 212.7,91.07 212.67,91.07
  TOP w0.157: v3(202.71,86.29) 202.65,86.29 202.45,86.08 202.45,85.7 202.65,85.5 203.35,85.5 203.36,85.5 203.54,85.5 203.75,85.7 203.75,85.83 203.86,85.94 204.68,85.94 204.8,85.81 204.8,85.63 204.93,85.5 205.31,85.5 205.44,85.63 205.44,86.53 205.57,86.65 205.83,86.65 205.96,86.53 205.96,85.47 206.08,85.35 206.38,85.35 206.5,85.47 206.5,86.29 206.8,86.58 206.8,86.8 206.69,86.91 206.69,87.13 206.86,87.3 207.09,87.3 207.19,87.2 207.42,87.2 207.59,87.37 207.59,87.6 207.48,87.71 207.48,87.92 207.63,88.07 207.84,88.07 208.06,87.86 208.19,87.86 208.33,88.01 208.33,89.2 208.48,89.35 208.7,89.35 208.85,89.2 208.85,88.4 209.02,88.23 209.25,88.23 209.41,88.4 209.41,89.14 209.54,89.27 v1(209.54,89.41) 209.54,89.54 209.23,89.86 209.23,90.09 209.39,90.26 209.62,90.26 209.96,89.93 210.19,89.93 210.35,90.09 210.35,90.33 210.02,90.66 210.02,90.89 210.19,91.06 210.42,91.06 210.74,90.74 210.96,90.74 211.29,91.07 212.67,91.07
  BOTTOM w0.157: v3(202.71,86.29) 202.53,86.47 200.93,86.47 199.64,85.18 UV1.A23
