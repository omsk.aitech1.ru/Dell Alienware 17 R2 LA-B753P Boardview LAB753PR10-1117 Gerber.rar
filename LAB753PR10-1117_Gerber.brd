# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CS1#: length 43.2
  IN4 w0.091: v3(218.3,31.89) 217.87,31.46 217.87,30.94 216.09,29.16 216.09,27.16 216.89,26.35 221.48,26.35 222.12,25.71 225.82,25.71 226.02,25.5 226.6,25.5 227.41,26.32 231.49,26.32 231.96,25.85 236.9,25.85 v3(237.31,25.44)
  IN6 w0.099: v3(239.16,36.72) 239.34,36.54 239.34,29.73 239.61,29.46 239.61,26.89 238.17,25.44 v3(237.31,25.44)
  BOTTOM w0.089: v3(218.3,31.89) 218.02,31.61 UH1.AL7
  BOTTOM w0.127: v1(236.72,25.1) 236.97,25.1 v3(237.31,25.44) ; RT15.1 239.34,36.54 v3(239.16,36.72)
PCH_SPI_CS1#_T: length 4.2
  BOTTOM w0.127: UT2.22 240.94,36.8 RT15.2 240.16,36.02 v1(238.79,36.02)
PCH_SPI_DO2: length 11.9
  BOTTOM w0.089: UH1.AJ4 218.63,29.96 218.36,29.69 218.36,29.38 218.52,29.22 218.52,28.82 218.32,28.62 218.32,28.21 218.09,27.98 217.92,27.82 217.92,27.37 217.81,27.26 217.81,26.92
  BOTTOM w0.127: 217.81,26.92 216.91,26.02 216.91,23.84 v1(216.83,23.76) 216.83,20.69 217.06,20.46 RPH5.5
PCH_SPI_DO3: length 11.1
  BOTTOM w0.089: UH1.AJ2 218.74,29.43 218.74,28.78 218.51,28.54 218.51,28.08 218.18,27.75
  BOTTOM w0.102: 218.37,26.66 218.37,26.85 218.18,27.04 218.18,27.75
  BOTTOM w0.127: 218.37,26.66 218.37,26.51 217.49,25.63 217.49,24.2 217.76,23.93 217.76,22.31 217.41,21.97 v1(217.41,21.02) 217.41,20.75 217.56,20.6 RPH5.6
PCH_SPI_S0_R: length 29.1
  IN4 w0.091: v3(218.56,17.62) 218.12,17.62 217.56,18.18 v3(209.87,18.18)
  BOTTOM w0.127: RPH5.1 v3(218.56,17.62) ; v3(209.87,18.18) 208.87,18.18 208.74,18.05 208.74,15.6 208.61,15.47 208.17,15.47 208.04,15.6 208.04,17.43 207.91,17.55 207.53,17.55 207.41,17.43 207.41,15.08 207.28,14.95 206.91,14.95 206.78,15.08 206.78,17.44 206.66,17.57 206.31,17.57 206.19,17.44 206.19,15.09 206.06,14.96 205.72,14.96 205.59,15.09 205.59,17.07 205.49,17.17 UH4.2
PCH_SPI_SI: length 12.5
  TOP w0.127: v3(219.22,27.32) 219.22,27.08 218.8,26.66 218.43,26.66 218.15,26.38 RT12.1
  BOTTOM w0.089: UH1.AH1 219.03,27.79 219.22,27.61 v3(219.22,27.32) 219.22,26.82 219.03,26.63
  BOTTOM w0.127: 219.03,26.63 219.03,26.34 218.07,25.39 218.07,24.47 218.35,24.19 v1(218.35,22.47) 218.35,22.08 218,21.73 218,21.11 218.06,21.05 RPH5.7
PCH_SPI_SI_R: length 27.9
  BOTTOM w0.127: RPH5.2 218.06,18.06 217.93,17.94 217.93,17.74 217.81,17.62 216.84,17.62 216.71,17.74 216.71,17.83 216.58,17.96 216.41,17.96 216.28,17.83 216.28,17.36 216.16,17.24 215.9,17.24 215.78,17.36 215.78,17.87 215.65,18 215.36,18 215.23,17.87 215.23,16.79 215.36,16.66 215.84,16.66 215.95,16.55 215.95,15.76 215.84,15.65 214.9,15.65 214.73,15.83 v1(214.73,17.66) 214.73,18.85 214.85,18.98 215.2,18.98 215.33,18.85 215.33,18.76 215.46,18.63 216.03,18.63 216.16,18.76 216.16,19.42 216,19.57 214.33,19.57 214.22,19.46 214.22,16.22 214.11,16.12 213.86,16.12 213.71,16.27 213.71,17.4 213.58,17.52 212.95,17.52 212.82,17.65 212.82,17.91 212.95,18.03 213.58,18.03 213.7,18.16 213.7,19.95 213.58,20.07 213.17,20.07 213.04,19.94 213.04,19.71 212.92,19.59 212.66,19.59 212.54,19.71 UH4.5
PCH_SPI_SI_T: length 38.4
  TOP w0.127: v3(218.67,27.07) 217.91,27.07 RT12.2
  IN4 w0.091: v3(218.67,27.07) 218.51,27.23 218.19,27.23 217.93,27.48 217.93,28.4 219.24,29.71 228.04,29.71 228.11,29.64 229.92,29.64 230.75,30.47 231.08,30.47 232.73,32.12 235.72,32.12 236.04,31.8 239.46,31.8 v3(240.24,31.02)
  IN6 w0.099: v3(240.04,39.09) 240.24,38.89 v3(240.24,31.02)
  BOTTOM w0.127: v3(240.04,39.09) 240.65,39.7 v1(241.1,39.7) 241.53,39.7 241.83,39.4 UT2.26
PCH_SPI_SO: length 12.5
  TOP w0.127: RT13.1 219.02,28.4 v3(219.45,27.97)
  BOTTOM w0.089: 219.61,26.63 219.61,26.99 219.59,27.02 219.59,27.84 v3(219.45,27.97) 219.45,28.11 219.23,28.33 219.23,28.81 219.36,28.94 219.36,29.17 219.03,29.49 UH1.AH3
  BOTTOM w0.127: 219.61,26.63 219.61,26.09 v1(219.05,25.52) 218.66,25.14 218.66,24.72 218.94,24.44 218.94,21.03 218.56,20.65 RPH5.8
PCH_SPI_SO_T: length 36.5
  TOP w0.127: RT13.2 217.72,28.08 218.16,27.64 v3(218.68,27.64)
  IN4 w0.091: v3(240.86,31.02) 240.39,30.55 239.82,30.55 239.05,31.31 236.22,31.31 235.66,31.87 233,31.87 231.25,30.12 230.77,30.12 229.97,29.33 227.92,29.33 227.81,29.43 219.29,29.43 218.2,28.34 218.2,27.64 218.34,27.5 218.53,27.5 v3(218.68,27.64)
  IN6 w0.099: v3(240.86,31.02) 241.96,32.12 241.96,36.73 v3(241.44,37.25)
  BOTTOM w0.127: v3(241.44,37.25) 241.64,37.45 UT2.23 ; v3(240.86,31.02) 240.86,31.01 240.86,31.15 v1(241.16,31.45)
PCH_TD_IREF: length 6.8
  BOTTOM w0.089: 213.2,48.48 213.78,47.89 213.78,47.59 214.16,47.21 UH1.AY43
  BOTTOM w0.127: RH103.1 v3(210.4,50.61) 211.48,49.52 212.16,49.52 213.2,48.48
PCH_THRMTRIP#_R_R: length 11.6
  BOTTOM w0.089: UH1.AV1 214.58,28.69 214.58,28.41
  BOTTOM w0.127: RH124.1 206.85,24.67 v1(206.85,25.48) 207.06,25.69 207.06,26.32 207.28,26.53 207.76,26.53 208,26.29 209.15,26.29 209.3,26.44 212.02,26.44 212.64,27.07 213.29,27.07 213.78,27.56 213.96,27.56 214.58,28.18 214.58,28.41
PCH_TP25: length 21.7
  IN1 w0.099: v3(235.4,21.38) 235.02,21.38 234.62,21.77 234.62,24.21 234.13,24.7 232.86,24.7 231.65,25.91 231.65,27.59 230.23,29 230.23,30.53 229.15,31.61 v3(228.14,31.61)
  BOTTOM w0.089: UH1.F8 228.45,31.92 v3(228.14,31.61)
  BOTTOM w0.127: RH24.1 231.31,18.96 231.4,19.06 v1(233.56,19.06) 233.99,19.06 234.61,19.67 234.61,20.89 235.09,21.38 v3(235.4,21.38)
PCI_PIRQA#: length 6
  TOP w0.089: v3(227.63,36.63) 228.07,36.63 228.55,37.11 v1(228.78,37.11) 228.84,37.17 229.5,37.17 229.87,36.81 231.9,36.81 232.19,37.09
  TOP w0.127: RH62.2 232.19,37.09
  BOTTOM w0.089: UH1.H20 227.63,36.73 v3(227.63,36.63)
PCI_PIRQB#: length 7.1
  TOP w0.089: 229.36,37.43 228.48,37.43 228.04,36.99 226.77,36.99 v3(226.43,36.64)
  TOP w0.127: RH63.2 230.16,38.23 229.36,37.43
  BOTTOM w0.089: UH1.L20 226.06,37 226.42,36.64 v3(226.43,36.64)
PCI_PIRQC#: length 8.3
  TOP w0.089: 231.42,36.58 229.48,36.58 229.16,36.25 227.56,36.25 226.96,35.65 v3(226.96,35.64) 226.58,36.01 225.29,36.01 v1(225.24,35.96)
  TOP w0.102: 231.42,36.58 231.59,36.41 RH64.2
  BOTTOM w0.089: UH1.K17 226.65,36.07 226.96,35.76 v3(226.96,35.64)
PCI_PIRQD#: length 9.5
  TOP w0.089: v3(225.67,37.58) 226.06,37.19 227.83,37.19 228.32,37.68 229.24,37.68
  TOP w0.127: v1(231.26,40.07) 231.31,40.07 RH66.2 231.7,38.56 230.11,38.56 229.24,37.68
  BOTTOM w0.089: v3(225.67,37.58) 225.46,37.37 UH1.M20
PCIE_GEN3#_GEN2: length 53.8
  TOP w0.127: v3(242.75,49.48) 242.19,49.48 241.89,49.18 241.89,47.7 242.74,46.85 242.74,46.43 242.57,46.27 UE6.11
  IN4 w0.091: v3(242.75,49.48) 242.75,47.97 245.84,44.88 245.84,33.76 246.64,32.95 246.98,32.61 254.68,32.61 259.16,28.13 261.54,28.13 263.32,26.34 265.71,26.34 v3(266.54,25.51)
  BOTTOM w0.127: v1(273.05,25.39) 272.56,24.89 271.25,24.89 UE1.18 270.63,25.52 269.79,26.35 268.68,26.35 267.84,25.51 v3(266.54,25.51)
PCIE_PRX_C_DTX_N1: length 2.4
  TOP w0.127: CR11.2 328.93,15.2 328.93,15.78 328.6,16.11 328.6,16.49 328.68,16.57 UR1.8
PCIE_PRX_C_DTX_P1: length 2.4
  TOP w0.127: CR10.2 328.69,15.19 328.69,15.66 v4(328.52,15.83) 328.36,15.99 328.36,16.49 328.28,16.57 UR1.7
PCIE_PRX_CARDTX_N5: length 146.2
  TOP w0.127: v3(306.24,36.09) 306.33,36.01 306.33,27.64 321.48,12.48 328.26,12.48 329.05,13.28 329.05,13.72 CR11.1
  IN5 w0.099: v3(306.24,36.09) 306.52,35.81 306.52,35.72 306.38,35.58 305.64,35.58 304.82,36.4 287.81,36.4 287.03,35.63 281.92,35.63 281.44,35.15 276.33,35.15 275.83,35.64 269.3,35.64 268.7,36.25 261.28,36.25 257.28,40.25 254.77,40.25 251.28,43.74 250.71,43.74 241.34,53.11 235.36,53.11 234.61,53.87 232.29,53.87 230.07,51.64 220.74,51.64 216.94,47.85 216.44,47.85 215.23,46.64 215.23,46.15 214.9,45.83 214.38,45.83 214.03,45.47 214.03,44.22 v3(213.87,44.07)
  BOTTOM w0.089: v3(213.87,44.07) 214.03,44.07 214.14,43.96 214.14,43.73 UH1.AW36
PCIE_PRX_CARDTX_P5: length 146.2
  TOP w0.127: v3(306.95,36.09) 306.82,36.09 306.57,35.84 306.57,27.74 321.58,12.73 328.16,12.73 328.81,13.38 328.81,14.01 328.68,14.14 328.49,14.14 328.36,14.01 CR10.1
  IN5 w0.099: v3(306.95,36.09) 306.7,35.84 306.7,35.64 306.45,35.4 305.56,35.4 304.74,36.22 287.88,36.22 287.11,35.45 281.99,35.45 281.51,34.97 276.25,34.97 275.76,35.46 269.23,35.46 268.62,36.07 261.2,36.07 257.2,40.07 254.7,40.07 251.21,43.56 250.63,43.56 241.26,52.93 235.28,52.93 234.53,53.68 232.36,53.68 230.14,51.46 220.82,51.46 217.02,47.67 216.51,47.67 215.41,46.56 215.41,46.08 214.97,45.65 214.45,45.65 214.21,45.4 214.21,44.39 v3(214.52,44.07)
  BOTTOM w0.089: UH1.AV36 214.73,43.58 214.52,43.79 v3(214.52,44.07)
PCIE_PRX_GLANTX_N3: length 123.3
  TOP w0.127: v3(309.55,33.87) 309.72,34.05 309.72,35.22 310.4,35.89 310.4,35.93 310.77,36.3 310.81,36.3 312.26,37.75 314.73,37.75 315.54,38.56 315.54,40.06 316.08,40.59 316.75,40.59 317.07,40.27 317.07,39.98 CL2.2
  IN5 w0.099: v3(214.52,43.09) 214.3,43.32 214.3,43.39 214.4,43.5 214.81,43.5 215.89,44.58 215.89,46.28 216.54,46.93 217.24,46.93 220.64,50.34 231.31,50.34 232.85,51.87 241.39,51.87 250.36,42.9 250.83,42.9 254.36,39.37 256.44,39.37 260.45,35.36 264.24,35.36 265.31,34.29 287.12,34.29 288.31,35.48 304.4,35.48 305.37,34.51 309.75,34.51 310.01,34.24 310.01,33.77 309.89,33.66 309.77,33.66 v3(309.55,33.87)
  BOTTOM w0.089: v3(214.52,43.09) 214.28,42.85 UH1.AW33
PCIE_PRX_GLANTX_P3: length 123.3
  TOP w0.127: v3(310.44,33.86) 310.44,33.81 310.31,33.68 310.08,33.68 309.97,33.8 309.97,35.12 v4(310.78,35.93) 312.36,37.51 314.83,37.51 315.79,38.46 315.79,39.96 316.18,40.35 316.65,40.35 316.83,40.17 316.83,39.84 316.66,39.68 CL1.2
  IN5 w0.099: v3(310.44,33.86) 310.19,34.11 310.19,34.32 309.82,34.69 305.45,34.69 304.47,35.66 288.24,35.66 287.05,34.47 265.38,34.47 264.31,35.54 260.53,35.54 256.52,39.55 254.43,39.55 250.9,43.08 250.43,43.08 241.46,52.05 232.77,52.05 231.24,50.52 220.57,50.52 217.17,47.11 216.47,47.11 215.71,46.35 215.71,44.65 214.73,43.68 214.33,43.68 214.12,43.47 214.12,43.34 v3(213.87,43.09)
  BOTTOM w0.089: v3(213.87,43.09) 213.87,42.79 UH1.AY33
PCIE_PRX_LANTX_N3_C: length 2.5
  TOP w0.127: CL2.1 316.97,38.36 316.97,37.23 317.05,37.15 UL1.29
PCIE_PRX_LANTX_P3_C: length 2.4
  TOP w0.127: UL1.30 316.65,37.15 316.72,37.21 v4(316.72,37.73) 316.72,38.4 CL1.1
PCIE_PRX_WLANTX_N4: length 73.1
  IN1 w0.099: v3(215.7,43.09) 215.95,42.84 215.95,42.66 215.81,42.52 215.63,42.52 215.47,42.67 212.6,42.67 211.76,43.52 210.91,43.52 210.9,43.52 209.07,43.52 207.86,42.32 206.44,42.32 206.19,42.06 204.76,42.06 202.45,39.76 202.45,34.28 196.26,28.08 196.26,26.72 192.18,22.65 192.18,21.8 191.28,20.89 190.7,20.89 188.98,19.17 183.43,19.17 182.78,18.52 180.2,18.52 179.8,18.92 173.8,18.92 172.7,20.02 168.47,20.02 167.01,21.48 167.01,25.35 167.26,25.6 167.6,25.6 v3(167.83,25.37)
  BOTTOM w0.089: UH1.AT33 215.48,42.87 v3(215.7,43.09)
  BOTTOM w0.127: v3(167.83,25.37) 167.67,25.53 JWLAN1.35
PCIE_PRX_WLANTX_P4: length 73.2
  IN1 w0.099: v3(215.87,42.1) 215.64,42.34 215.55,42.34 215.4,42.49 212.53,42.49 211.68,43.34 210.83,43.34 210.83,43.34 209.14,43.34 207.94,42.14 206.52,42.14 206.26,41.88 204.83,41.88 202.63,39.68 202.63,34.2 196.44,28.01 196.44,26.65 192.36,22.57 192.36,21.72 191.35,20.71 190.78,20.71 189.05,18.99 183.5,18.99 182.85,18.34 180.13,18.34 179.72,18.74 173.72,18.74 172.63,19.84 168.39,19.84 166.83,21.4 166.83,25.42 167.19,25.78 167.65,25.78 v3(167.83,25.96)
  BOTTOM w0.089: UH1.AR33 215.87,42.4 v3(215.87,42.1)
  BOTTOM w0.127: JWLAN1.33 167.05,26.03 167.31,25.78 167.64,25.78 v3(167.83,25.96)
PCIE_PTX_CARDRX_N5: length 151.8
  TOP w0.127: UR1.4 327.08,16.51 326.98,16.41 326.98,15.22 326.01,14.25 321.96,14.25 308.56,27.65 308.56,31.61 308.03,32.15 308.03,36.74 v3(307.91,36.86)
  IN5 w0.099: v3(206.62,46.32) 206.8,46.5 207.79,46.5 210.9,49.61 213.54,49.61 215.45,51.51 218.68,51.51 220.03,52.86 222.74,52.86 224.63,54.75 227.24,54.75 229.39,56.9 233.53,56.9 235.92,54.51 241.91,54.51 251.49,44.93 252.29,44.93 255.75,41.47 257.96,41.47 262,37.43 270.42,37.43 271.01,36.84 286.37,36.84 287.15,37.62 307.59,37.62 308.13,37.08 v3(307.91,36.86)
  BOTTOM w0.127: CH16.1 207.34,46.4 206.7,46.4 v3(206.62,46.32)
PCIE_PTX_CARDRX_N5_C: length 6.4
  BOTTOM w0.089: 210.89,45.31 210.9,45.3 210.91,45.3 211.21,45 211.21,44.35 211.26,44.29 211.26,44.28 211.55,43.99 211.56,43.99 211.58,43.98 211.86,43.98 212.07,43.77 212.35,43.77 212.46,43.87 212.46,43.96 212.36,44.05 UH1.BD37
  BOTTOM w0.127: CH16.2 208.49,46.51 208.62,46.64 209.55,46.64 210.89,45.31
PCIE_PTX_CARDRX_P5: length 151.8
  TOP w0.127: UR1.3 326.68,16.5 326.74,16.45 326.74,15.32 325.91,14.5 322.06,14.5 308.81,27.75 308.81,31.71 308.27,32.25 308.27,36.63 v3(308.49,36.86)
  IN5 w0.099: v3(206.62,46.9) 206.84,46.68 207.71,46.68 210.82,49.79 213.47,49.79 215.37,51.69 218.61,51.69 219.95,53.04 222.67,53.04 224.55,54.93 227.17,54.93 229.32,57.08 233.6,57.08 235.99,54.69 241.99,54.69 251.56,45.12 252.36,45.12 255.83,41.65 258.04,41.65 262.08,37.61 270.5,37.61 271.08,37.03 286.3,37.03 287.07,37.8 307.67,37.8 308.31,37.16 308.31,37.04 v3(308.49,36.86)
  BOTTOM w0.127: CH17.1 207.67,47.01 207.67,46.79 207.53,46.64 206.89,46.64 206.79,46.74 206.78,46.74 v3(206.62,46.9)
PCIE_PTX_CARDRX_P5_C: length 6.4
  BOTTOM w0.089: UH1.BB37 212.97,44.2 212.51,44.2 212.45,44.26 212.44,44.26 212.34,44.36 212.07,44.36 211.89,44.19 211.66,44.19 211.65,44.2 211.64,44.2 211.47,44.36 211.47,44.38 211.42,44.43 211.42,45.08 211.11,45.39 211.11,45.41 211.07,45.45 211.07,45.48 211.06,45.49
  BOTTOM w0.127: CH17.2 208.71,46.89 209.66,46.89 211.06,45.49
PCIE_PTX_GLANRX_N3: length 125.4
  TOP w0.127: v3(314.66,33.43) 314.8,33.57 314.81,33.57 315,33.76 315.21,33.76 315.25,33.8 UL1.36
  IN5 w0.099: v3(314.66,33.43) 314.46,33.63 312.7,33.63 310.57,35.77 307.97,35.77 306.79,36.94 287.49,36.94 286.71,36.16 269.47,36.16 268.9,36.73 261.48,36.73 257.47,40.74 254.98,40.74 251.46,44.26 251.23,44.26 241.69,53.8 235.43,53.8 234.41,54.83 228.69,54.83 227.81,53.95 225.07,53.95 223.3,52.17 220.55,52.17 218.24,49.86 215.83,49.86 212.56,46.6 212.56,45.46 210.5,43.4 208.32,43.4 207.75,42.82 206.95,42.82 v3(206.86,42.74)
  BOTTOM w0.127: v3(206.86,42.74) 207.02,42.9 207.24,42.9 CH12.1
PCIE_PTX_GLANRX_N3_C: length 4.5
  BOTTOM w0.089: 210.89,42.98 210.96,42.98 210.98,42.96 211.32,42.96 211.33,42.96 211.39,42.89 211.39,42.66 211.52,42.53 211.84,42.53 211.94,42.63 211.94,42.76 211.84,42.86 UH1.BE34
  BOTTOM w0.127: 210.89,42.98 210.73,42.98 210.5,43.21 v4(209.59,43.21) 209.3,43.21 209.05,42.96 208.88,42.96 CH12.2
PCIE_PTX_GLANRX_P3: length 125.4
  TOP w0.127: UL1.35 315.3,34.2 315.12,34.01 v3(314.66,34.01)
  IN5 w0.099: v3(206.86,43.32) 207.18,43 207.67,43 208.25,43.58 210.43,43.58 212.38,45.53 212.38,46.68 215.75,50.04 218.17,50.04 220.48,52.35 223.22,52.35 225,54.13 227.74,54.13 228.62,55.01 234.48,55.01 235.51,53.98 241.76,53.98 251.3,44.44 251.54,44.44 255.05,40.92 257.54,40.92 261.56,36.91 268.97,36.91 269.55,36.34 286.63,36.34 287.42,37.12 306.87,37.12 308.05,35.95 310.64,35.95 312.78,33.81 314.45,33.81 v3(314.66,34.01)
  BOTTOM w0.127: v3(206.86,43.32) 207.04,43.14 207.25,43.14 CH13.1
PCIE_PTX_GLANRX_P3_C: length 4.6
  BOTTOM w0.089: UH1.BC34 212.56,42.96 212.1,42.96 211.89,43.16 211.06,43.16 211.04,43.18 211,43.18 210.98,43.2 210.92,43.2 210.9,43.22 210.89,43.22
  BOTTOM w0.127: CH13.2 208.74,43.21 208.95,43.21 209.21,43.46 209.9,43.46 209.91,43.45 210.6,43.45 210.83,43.22 210.89,43.22
PCIE_PTX_WLANRX_N4: length 63.7
  IN1 w0.099: v3(167.84,26.87) 168,27.03 168.04,27.08 168.18,27.08 168.3,26.95 168.3,21.53 169.27,20.56 172.84,20.56 174,19.4 180.07,19.4 180.39,19.08 182.66,19.08 183.23,19.65 188.42,19.65 195.72,26.95 195.72,28.25 201.95,34.47 201.95,40.06 205.17,43.28 205.48,43.28 v3(205.68,43.08)
  BOTTOM w0.127: JWLAN1.29 167.16,27.03 167.22,27.09 167.61,27.09 v3(167.84,26.87) ; CH14.1 207.57,44.97 207.42,44.82 206.48,44.82 205.94,44.28 205.94,43.36 205.84,43.25 205.84,43.25 v3(205.68,43.08)
PCIE_PTX_WLANRX_N4_C: length 5
  BOTTOM w0.089: UH1.BE36 211.63,43.79 211.51,43.79 211.45,43.73 211.45,43.65 211.37,43.57 211.25,43.57 211.1,43.72 211.1,43.86 211.2,43.97 211.2,44.03 211.11,44.12 211.11,44.14 211.07,44.19 211.07,44.21 210.89,44.39
  BOTTOM w0.127: CH14.2 208.29,45.1 208.29,44.92 208.4,44.82 209.61,44.82 209.62,44.83 210.12,44.83 210.13,44.82 210.46,44.82 210.89,44.39
PCIE_PTX_WLANRX_P4: length 63.6
  IN1 w0.099: v3(206.26,43.08) 205.88,43.46 205.87,43.46 205.84,43.49 205.51,43.49 205.48,43.46 205.09,43.46 201.77,40.14 201.77,34.55 195.54,28.32 195.54,27.02 188.35,19.83 183.15,19.83 182.59,19.26 180.47,19.26 180.14,19.58 174.07,19.58 172.92,20.74 169.35,20.74 168.48,21.6 168.48,27.03 168.25,27.26 168.03,27.26 v3(167.84,27.45)
  BOTTOM w0.127: v3(206.26,43.08) 206.19,43.15 206.19,44.16 v4(206.35,44.33) 206.6,44.58 207.34,44.58 CH15.1 ; v3(167.84,27.45) 167.72,27.34 167.28,27.34 167.09,27.53 JWLAN1.27
PCIE_PTX_WLANRX_P4_C: length 5.1
  BOTTOM w0.089: 210.89,44.05 210.9,44.03 210.9,43.62 211.15,43.37 211.9,43.37 212.1,43.57 212.56,43.57 UH1.BC36
  BOTTOM w0.127: CH15.2 208.71,44.58 v4(209.87,44.58) 210.36,44.58 210.89,44.05
PCIE_WAKE#: length 119.8
  TOP w0.127: UL1.3 317.45,30.54 317.01,30.09 316.63,30.09 316.09,29.55 316.09,28.58 315.75,28.23 v3(315.75,27.6) 315.75,27.32 RL1.2 ; UE5.64 276.57,13.45 276.85,13.73 276.85,14.11 276.72,14.25 v3(276.72,15.41) ; v3(233.45,17.23) 233.45,16.22 232.06,14.82 v1(231.7,14.82) 224.73,14.82 224.5,15.05 RH35.2 224.98,15.93 224.98,16.83 224.89,16.92 224.69,16.92 223.97,17.64 223.97,18.12 RH48.2
  IN1 w0.099: v3(284.65,23.24) 284.84,23.43 286.72,23.43 290.19,26.9 301.96,26.9 302.1,27.04 311.67,27.04 312.73,28.09 315.25,28.09 v3(315.75,27.6) ; v3(233.45,17.23) 233.84,16.84 239.53,16.84 240.75,15.62 258.33,15.62 260.5,17.79 268.23,17.79 269.12,16.9 275.23,16.9 v3(276.72,15.41)
  IN4 w0.091: v3(283.9,16.49) 283.22,15.81 278.58,15.81 277.8,15.04 277.09,15.04 v3(276.72,15.41)
  BOTTOM w0.127: v3(283.9,16.49) 283.9,16.84 284.46,17.4 284.46,23.05 v3(284.65,23.24)
PECI_KB9012: length 3.3
  TOP w0.127: RE76.1 291.98,21.04 v1(291.64,21.04) 290.83,21.85 UE5.118
PEG_COMP: length 9.3
  TOP w0.127: v2(132.76,85.14) 131.88,84.27 RC1.2
  TOP w0.305: v3(125.07,83.17) 125.39,83.49 127.47,83.49 127.82,83.84 RC1.2
  BOTTOM w0.305: v3(125.07,83.17) 124.72,83.52 CPU1.AH6
PEG_GTX_HRX_C_N8: length 1.7
  BOTTOM w0.14: CM66.2 159.5,128.36 159.5,129.05 159.35,129.2 UM8.4
PEG_GTX_HRX_C_N9: length 1.8
  BOTTOM w0.14: CM65.2 157.23,128.45 157.23,128.59 157.44,128.8 157.44,129.02 157.35,129.12 UM8.8
PEG_GTX_HRX_C_N10: length 3.5
  BOTTOM w0.14: CM62.2 158.48,126.57 158.48,128.83 158.35,128.96 UM8.6
PEG_GTX_HRX_C_N11: length 2.9
  BOTTOM w0.14: CM69.2 161.88,128.39 161.88,128.48 161.78,128.58 160.76,128.58 160.49,128.85 160.49,129.05 160.35,129.19 UM8.2
PEG_GTX_HRX_C_P8: length 1.7
  BOTTOM w0.14: UM8.3 159.85,129.18 159.74,129.07 159.74,128.37 CM63.2
PEG_GTX_HRX_C_P9: length 1.8
  BOTTOM w0.14: CM64.2 157.47,128.31 157.47,128.49 157.69,128.7 157.69,128.95 157.85,129.11 UM8.7
PEG_GTX_HRX_C_P10: length 3.5
  BOTTOM w0.14: UM8.5 158.85,128.96 158.72,128.83 158.72,126.53 CM68.2
PEG_GTX_HRX_C_P11: length 2.9
  BOTTOM w0.14: UM8.1 160.85,129.17 160.73,129.06 160.73,128.95 160.86,128.82 161.88,128.82 162.12,128.58 162.12,128.37 CM67.2
PEG_GTX_HRX_N0: length 61.2
  TOP w0.14: v3(150.4,82.91) 150.61,83.12 150.61,83.33 150.92,83.63 152.35,83.63 CV62.1
  IN1 w0.089: v3(121.5,99.6) 121.69,99.6 121.82,99.47 121.82,99.32 121.69,99.19 121.31,99.19 121.14,99.37 121.14,99.94 121.02,100.06 121.02,100.36
  IN1 w0.119: 121.02,100.36 121.02,101.12 121.07,101.17 121.07,101.18 121.29,101.4 121.3,101.4 122.18,102.28 122.18,102.86 122.63,103.31 122.63,104.82 124.4,106.59 127.43,106.59 127.44,106.58 128.12,106.58 138.93,95.77 144.24,95.77 146.73,93.29 152.19,93.29 154.43,91.05 154.43,84.22 153.77,83.57 150.92,83.57 150.66,83.31 150.66,83.16 150.41,82.91 v3(150.4,82.91)
  BOTTOM w0.089: v3(121.5,99.6) 121.51,99.6 121.51,99.59 121.53,99.59 CPU1.E10
PEG_GTX_HRX_N0_C: length 13.6
  TOP w0.14: v3(165.2,83.98) 165.38,83.98 165.53,83.82 165.53,83.6 165.36,83.43 v4(159.83,83.43) 154.73,83.43 154.71,83.41 153.78,83.41 153.5,83.7 CV62.2
  BOTTOM w0.101: UV1.BD21 v3(165.2,83.98)
PEG_GTX_HRX_N1: length 53.2
  TOP w0.14: v3(152.68,84.52) 152.87,84.71 152.87,84.94 153.22,85.3 154.22,85.3 154.55,84.97 154.7,84.97 CV60.1
  IN1 w0.119: v3(152.68,84.52) 152.68,84.58 153.05,84.95 153.05,85.24 153.72,85.9 153.72,90.76 151.89,92.58 146.43,92.58 144.98,94.03 139.6,94.03 135.82,97.81 134.51,97.81 133.34,98.98 133.34,99.62 127.08,105.88 124.69,105.88 123.34,104.52 123.34,103.25 122.68,102.6 122.68,101.37 121.83,100.51 121.83,100.23 121.92,100.13 122.07,100.13 v3(122.26,100.32)
  BOTTOM w0.089: v3(122.26,100.32) 121.91,100.67 CPU1.C10
PEG_GTX_HRX_N1_C: length 9.7
  TOP w0.112: 161.84,84.67 162.64,84.67 162.74,84.57 163.87,84.57 163.96,84.48 164.11,84.48 v3(164.4,84.78)
  TOP w0.14: 161.84,84.67 161.73,84.67 161.59,84.53 158.89,84.53 158.56,84.86 v4(157.62,84.86) 156.19,84.86 CV60.2
  BOTTOM w0.101: v3(164.4,84.78) UV1.BE23
PEG_GTX_HRX_N2: length 54
  TOP w0.14: v3(149.84,85.5) 149.99,85.65 149.99,86.04 150.35,86.41 152.15,86.41 152.31,86.57 152.66,86.57 CV63.1
  IN1 w0.119: v3(124.78,104.17) 124.78,104.1 124.6,103.92 124.45,103.92 124.35,104.03 124.35,104.32 124.35,104.32 124.35,104.49 124.78,104.93 127.02,104.93 132.63,99.32 132.63,98.56 134.14,97.05 135.23,97.05 140.03,92.25 144.25,92.25 144.64,91.87 151.6,91.87 152.95,90.51 152.95,87.13 152.15,86.33 150.38,86.33 150.02,85.97 150.02,85.69 149.84,85.51 v3(149.84,85.5)
  BOTTOM w0.089: 121.89,103.22 121.89,103.21 121.91,103.19 121.91,102.86 121.35,102.3 121.35,101.74 121.62,101.48 121.75,101.48 CPU1.B10
  BOTTOM w0.14: 121.89,103.22 121.89,103.52 123.25,104.88 124.19,104.88 124.6,104.48 124.6,104.35 v3(124.78,104.17)
PEG_GTX_HRX_N2_C: length 13.9
  TOP w0.112: 163.3,85.22 163.31,85.2 163.87,85.2 164.16,85.5 165.41,85.5 165.74,85.17 165.74,85.04 v3(166,84.78)
  TOP w0.14: CV63.2 154.06,86.57 156.29,86.57 157.11,85.74 159.02,85.74 159.4,85.36 160.53,85.36 160.55,85.38 161.2,85.38 161.22,85.36 163.16,85.36 163.3,85.22
  BOTTOM w0.101: UV1.BC23 v3(166,84.78)
PEG_GTX_HRX_N3: length 45.5
  TOP w0.14: CV61.1 154.65,87.71 153.43,87.71 153.17,87.96 151.77,87.96 151.51,87.71 151.08,87.71 v3(150.94,87.84)
  IN1 w0.119: v3(150.94,87.84) 150.77,87.68 150.46,87.68 150.37,87.76 150.37,88.38 149.42,89.33 148.56,89.33 147.94,89.94 146.03,89.94 143.23,87.15 139.78,87.15 137.78,89.15 137.1,89.15 129.48,96.78 129.48,99.57 127.39,101.66 123.69,101.66 123.11,101.08 123.11,99.87 122.59,99.36 122.54,99.36 v3(122.28,99.62)
  BOTTOM w0.089: v3(122.28,99.62) 122.62,99.27 CPU1.E9
PEG_GTX_HRX_N3_C: length 12.1
  TOP w0.112: v3(165.2,86.38) 165.52,86.38 165.63,86.26 165.63,86.15 165.47,85.99 164.19,85.99 163.98,86.2 163.25,86.2 163.02,85.97 162.45,85.97 162.14,86.27 161.65,86.27
  TOP w0.14: 161.65,86.27 160.19,86.27 159.91,86.55 159.43,86.55 159.41,86.57 158.78,86.57 158.76,86.55 157.99,86.55 v4(157.39,87.15) 156.92,87.62 156.22,87.62 156.22,87.62 156.19,87.65 CV61.2
  BOTTOM w0.101: UV1.BD24 v3(165.2,86.38)
PEG_GTX_HRX_N4: length 43.2
  TOP w0.14: v3(151.23,89.49) 151.23,89.48 151.86,88.84 152.11,88.84 152.21,88.75 152.83,88.75 CV71.1
  IN1 w0.119: v3(151.23,89.49) 151.39,89.64 151.39,90.2 151.56,90.37 151.56,90.87 151.27,91.16 144.76,91.16 144.22,90.62 139.9,90.62 135.87,94.65 134.83,94.65 130.74,98.74 130.74,100.07 126.98,103.83 126.82,103.83 126.66,103.66 v3(126.66,103.34)
  BOTTOM w0.089: CPU1.D9 122.97,100.6 122.97,100.8 122.81,100.95 122.53,101.09 122.36,101.25 122.36,102.37 122.95,102.96 125.16,102.96 125.33,103.14 125.37,103.14 125.41,103.17 125.44,103.17 125.45,103.18
  BOTTOM w0.14: 125.45,103.18 125.67,103.4 126.59,103.4 v3(126.66,103.34)
PEG_GTX_HRX_N4_C: length 12.2
  TOP w0.112: v3(164.4,86.38) 164.14,86.64 163.15,86.64 162.64,87.15 161.39,87.15 161.37,87.14 161.31,87.14 161.29,87.12 161.28,87.12
  TOP w0.14: CV71.2 154.39,88.86 157.13,88.86 158.87,87.12 v4(160.78,87.12) 161.28,87.12
  BOTTOM w0.089: UV1.BE25 v3(164.4,86.38)
PEG_GTX_HRX_N5: length 42
  TOP w0.14: v3(150.17,90) 150.17,90.17 149.94,90.4 149.94,90.75 150.71,91.52 151.34,91.52 152.3,90.55 154.7,90.55 CV68.1
  IN1 w0.119: v3(150.17,90) 150.17,90.2 150.17,90.2 150.01,90.37 148.56,90.37 148.48,90.44 145.18,90.44 144.62,89.88 137.16,89.88 132.26,94.78 132.26,96.21 130,98.46 130,99.8 127.54,102.26 124.78,102.26 124.43,101.91 123.62,101.91 123.48,102.05 123.3,102.05 123.11,101.87 v3(123.11,101.7)
  BOTTOM w0.089: CPU1.B9 123,101.7 v3(123.11,101.7)
PEG_GTX_HRX_N5_C: length 12.6
  TOP w0.112: v3(166,87.18) 165.81,87.37 165.81,87.56 165.56,87.81 164.01,87.81 163.73,87.54 163.51,87.54 163.14,87.91 162.95,87.91 162.94,87.91 161.86,87.91 161.55,88.23
  TOP w0.14: 161.55,88.23 159.62,88.23 158.25,89.59 158.25,89.62 157.8,90.07 157.77,90.07 157.34,90.5 156.14,90.5 CV68.2
  BOTTOM w0.101: UV1.BC26 v3(166,87.18)
PEG_GTX_HRX_N6: length 47
  TOP w0.14: CV70.1 152.35,91.82 152.11,91.82 151.64,92.29 150.41,92.29 148.29,90.17 148.29,88.37 147.73,87.81 147.73,86.68 v3(147.51,86.45)
  IN1 w0.119: v3(125.1,94.58) 125.1,94.26 125.21,94.15 125.52,94.15 126.31,93.36 130.63,93.36 135.46,88.53 135.46,87.97 138.24,85.19 143.89,85.19 144.14,84.94 144.14,83.26 144.27,83.14 144.69,83.14 144.81,83.26 144.81,85.59 145.06,85.84 145.67,85.84 145.93,85.59 145.93,83.24 146.05,83.11 146.46,83.11 146.59,83.24 146.59,85.54 146.88,85.83 147.52,85.83 147.74,86.05 147.74,86.22 v3(147.51,86.45)
  BOTTOM w0.089: v3(125.1,94.58) 125.42,94.9 CPU1.L5
PEG_GTX_HRX_N6_C: length 15.1
  TOP w0.112: 160.7,89.1 160.72,89.1 160.73,89.09 161.82,89.09 162.51,88.4 163.06,88.4 163.28,88.62 163.98,88.62 164.22,88.38 165.49,88.38 165.6,88.49 165.6,88.7 165.47,88.83 165.25,88.83 v3(165.2,88.78)
  TOP w0.14: CV70.2 153.84,91.72 v4(155.4,91.72) 157.8,91.72 160.42,89.1 160.7,89.1
  BOTTOM w0.089: UV1.BD27 v3(165.2,88.78)
PEG_GTX_HRX_N7: length 36.6
  TOP w0.14: CV66.1 154.7,93.36 154.35,93.36 154.04,93.05 149.97,93.05 147.26,90.35 147.26,88.66 v3(147.12,88.52)
  IN1 w0.119: v3(147.12,88.52) 147.31,88.72 147.31,88.92 147.21,89.02 146.58,89.02 143.74,86.18 139.2,86.18 137.46,87.93 136.77,87.93 130.4,94.3 128.39,94.3 128.13,94.56 128.13,95.04 v3(127.88,95.33)
  BOTTOM w0.089: v3(127.88,95.33) 127.52,94.97 CPU1.L2
PEG_GTX_HRX_N7_C: length 11
  TOP w0.112: v3(164.4,89.58) 164.15,89.32 163.1,89.32 162.75,89.67 162.61,89.82 161.52,89.82 161.51,89.83
  TOP w0.14: CV66.2 156.21,93.23 157.1,93.23 157.12,93.25 157.77,93.25 157.79,93.23 158.11,93.23 161.51,89.83
  BOTTOM w0.101: UV1.BE29 v3(164.4,89.58)
PEG_GTX_HRX_N8: length 64.3
  IN6 w0.119: v3(126.5,93.77) 126.68,93.58 126.68,92.71 127.14,92.26 134.93,92.26 136.59,90.6 140.45,90.6 147.32,97.47 150.22,97.47 156.07,103.32 156.07,115.8 157.96,117.68 157.96,124.44 158.43,124.92 158.43,126 159.02,126.59 159.71,126.59 159.81,126.48 159.81,126.27 v3(159.65,126.11)
  BOTTOM w0.089: CPU1.M4 126.5,93.77 v3(126.5,93.77)
  BOTTOM w0.14: CM66.1 159.55,126.79 159.55,126.64 159.83,126.36 159.83,126.28 v3(159.65,126.11)
PEG_GTX_HRX_N9: length 64.3
  IN6 w0.119: v3(126.47,95.29) 126.41,95.23 126.41,95.09 126.56,94.93 127.24,94.93 127.28,94.9 130.4,94.9 130.99,94.31 141.27,94.31 146.13,99.16 147.4,99.16 149.37,101.13 151.46,101.13 154.32,103.99 154.32,114.8 150.12,119.01 150.12,124.04 153.03,126.95 154.43,126.95 155,126.37 156.23,126.37 v3(156.39,126.54)
  BOTTOM w0.089: CPU1.L4 126.07,95.01 126.07,95.16 126.21,95.29 v3(126.47,95.29)
  BOTTOM w0.14: CM65.1 157.14,126.84 157.14,126.72 156.72,126.3 156.63,126.3 v3(156.39,126.54)
PEG_GTX_HRX_N10: length 65.3
  IN6 w0.119: v3(157.49,125.31) 157.37,125.2 157.03,125.2 156.87,125.04 155.27,125.04 155.03,125.28 152.96,125.28 151.04,123.36 151.04,119.41 155.36,115.08 155.36,103.71 151.84,100.18 149.87,100.18 147.93,98.24 146.51,98.24 140.55,92.28 138.98,92.28 138.22,93.04 128.42,93.04 128.18,93.28 128.18,93.4 128.18,93.49 v3(127.89,93.78)
  BOTTOM w0.089: CPU1.M2 127.73,94.15 127.89,93.98 v3(127.89,93.78)
  BOTTOM w0.14: v3(157.49,125.31) 157.49,125.05 158.13,124.41 158.54,124.41 158.7,124.57 158.7,124.74 CM62.1
PEG_GTX_HRX_N11: length 65.1
  IN6 w0.119: v3(125.06,89.62) 125.27,89.84 125.27,90.06 125.57,90.36 135.54,90.36 135.82,90.08 140.72,90.08 147.59,96.95 150.45,96.95 156.64,103.14 156.64,115.64 158.51,117.51 158.51,123.88 160.23,125.6 160.47,125.6 160.68,125.81 160.68,125.91 160.95,126.18 161.06,126.18 v3(161.31,126.42)
  BOTTOM w0.089: v3(125.06,89.62) 125.42,89.99 CPU1.V5
  BOTTOM w0.14: v3(161.31,126.42) 161.48,126.25 161.65,126.25 161.9,126.51 161.9,126.79 CM69.1
PEG_GTX_HRX_P0: length 61.2
  TOP w0.14: v3(150.99,82.91) 150.85,83.04 150.85,83.23 151.02,83.39 152.49,83.39 152.66,83.23 152.66,83.01 CV57.1
  IN1 w0.089: 120.81,100.26 120.84,100.23 120.84,99.98 120.95,99.87 120.95,99.29 121.23,99.01 121.27,99.01 v3(121.45,98.83)
  IN1 w0.119: v3(150.99,82.91) 150.87,83.03 150.87,83.22 151,83.36 153.86,83.36 154.64,84.13 154.64,91.14 152.28,93.5 146.81,93.5 144.33,95.98 139.01,95.98 128.21,106.79 127.53,106.79 127.52,106.8 124.31,106.8 122.42,104.91 122.42,103.4 121.97,102.94 121.97,102.36 121.21,101.61 121.2,101.61 120.86,101.26 120.86,101.26 120.81,101.2 120.81,100.26
  BOTTOM w0.089: v3(121.45,98.83) 121.59,98.83 CPU1.F10
PEG_GTX_HRX_P0_C: length 13.7
  TOP w0.14: v3(166,83.98) 165.78,83.75 165.78,83.5 165.46,83.19 160.24,83.19 160.22,83.17 159.46,83.17 159.44,83.19 155.46,83.19 155.44,83.17 v4(155.08,83.17) 153.73,83.17 CV57.2
  BOTTOM w0.101: UV1.BC21 v3(166,83.98)
PEG_GTX_HRX_P1: length 53.1
  TOP w0.14: CV59.1 155.01,84.34 155.01,84.6 154.88,84.72 154.45,84.72 154.12,85.05 153.32,85.05 153.11,84.84 153.11,84.67 v3(153.26,84.52)
  IN1 w0.119: v3(153.26,84.52) 153.26,85.15 153.93,85.82 153.93,90.84 151.98,92.79 146.52,92.79 145.06,94.24 139.69,94.24 135.91,98.03 134.59,98.03 133.55,99.07 133.55,99.7 127.17,106.09 124.6,106.09 123.13,104.61 123.13,103.34 122.47,102.69 122.47,101.46 121.61,100.6 121.61,100.49 v3(121.45,100.32)
  BOTTOM w0.089: v3(121.45,100.32) 121.8,99.97 CPU1.D10
PEG_GTX_HRX_P1_C: length 9.7
  TOP w0.112: v3(164.4,83.98) 164.11,84.27 163.87,84.27 163.78,84.36 162.65,84.36 162.55,84.46 161.94,84.46 161.93,84.45 161.86,84.45 161.85,84.43 161.84,84.43
  TOP w0.14: CV59.2 156.2,84.62 157.27,84.62 157.29,84.6 157.97,84.6 157.99,84.62 158.46,84.62 158.79,84.29 161.69,84.29 161.83,84.43 161.84,84.43
  BOTTOM w0.101: v3(164.4,83.98) UV1.BE22
PEG_GTX_HRX_P2: length 54
  TOP w0.14: CV58.1 152.97,85.94 152.97,86.2 152.86,86.32 152.41,86.32 152.25,86.17 150.45,86.17 150.23,85.94 150.23,85.69 v3(150.42,85.5)
  IN1 w0.119: v3(150.42,85.5) 150.23,85.69 150.23,85.88 150.47,86.12 152.24,86.12 153.16,87.04 153.16,90.6 151.69,92.08 144.72,92.08 144.34,92.46 140.12,92.46 135.32,97.26 134.22,97.26 132.84,98.65 132.84,99.41 127.11,105.14 124.69,105.14 124.13,104.58 124.13,104.35 v3(123.93,104.15)
  BOTTOM w0.089: CPU1.A10 121.9,102.07 121.98,101.99 121.98,101.75 121.9,101.67 121.7,101.67 121.54,101.82 121.54,102.23 121.94,102.62 122.13,102.81 122.13,103.22
  BOTTOM w0.14: 122.13,103.22 122.13,103.42 123.35,104.64 124.09,104.64 124.36,104.38 124.36,104.07 124.25,103.96 124.11,103.96 v3(123.93,104.15)
PEG_GTX_HRX_P2_C: length 13.9
  TOP w0.112: 163.19,84.99 163.96,84.99 164.25,85.28 165.33,85.28 165.53,85.08 165.53,84.91 165.4,84.78 v3(165.2,84.78)
  TOP w0.14: CV58.2 153.82,86.15 153.99,86.32 156.19,86.32 157.01,85.5 158.92,85.5 159.3,85.12 v4(160.82,85.12) 163.06,85.12 163.19,84.99
  BOTTOM w0.089: UV1.BD23 v3(165.2,84.78)
PEG_GTX_HRX_P3: length 45.6
  TOP w0.14: v3(150.94,87.26) 151.15,87.47 151.61,87.47 151.87,87.72 153.07,87.72 153.33,87.47 154.57,87.47 CV64.1
  IN1 w0.119: v3(150.94,87.26) 150.74,87.46 150.37,87.46 150.16,87.67 150.16,88.29 149.34,89.12 148.47,89.12 147.86,89.73 146.11,89.73 143.32,86.94 139.69,86.94 137.69,88.94 137.02,88.94 129.27,96.69 129.27,99.48 127.3,101.45 123.77,101.45 123.32,100.99 123.32,99.79 122.68,99.15 122.54,99.15 v3(122.28,98.88)
  BOTTOM w0.089: v3(122.28,98.88) 122.59,98.57 CPU1.F9
PEG_GTX_HRX_P3_C: length 12.1
  TOP w0.112: 161.65,86.03 161.66,86.03 161.68,86.05 161.74,86.05 161.76,86.06 162.05,86.06 162.36,85.75 163.11,85.75 163.34,85.98 163.89,85.98 164.1,85.77 165.56,85.77 165.79,86 165.86,86.07 165.86,86.23 v3(166,86.38)
  TOP w0.14: CV64.2 156.12,87.38 156.82,87.38 156.98,87.22 156.98,87.19 157.42,86.76 157.45,86.76 157.89,86.31 v4(159.09,86.31) 159.81,86.31 160.09,86.03 161.65,86.03
  BOTTOM w0.101: UV1.BC24 v3(166,86.38)
PEG_GTX_HRX_P4: length 43.3
  TOP w0.14: CV67.1 153.22,89.34 153.22,89.17 153.05,89.01 152.29,89.01 152.21,89.09 151.96,89.09 151.77,89.28 151.77,89.55 v3(151.82,89.6)
  IN1 w0.119: v3(151.82,89.6) 151.6,89.83 151.6,90.11 151.77,90.28 151.77,90.96 151.36,91.37 144.67,91.37 144.14,90.83 139.99,90.83 135.96,94.86 134.91,94.86 130.95,98.83 130.95,100.16 127.07,104.04 126.47,104.04 v3(126.46,104.06)
  BOTTOM w0.089: 125.28,103.35 125.08,103.15 122.87,103.15 122.17,102.45 122.17,101.17 122.37,100.97 122.37,100.73 122.49,100.61 122.6,100.61 CPU1.C9
  BOTTOM w0.14: 125.28,103.35 125.57,103.64 126.41,103.64 126.59,103.82 126.59,103.93 v3(126.46,104.06)
PEG_GTX_HRX_P4_C: length 12.2
  TOP w0.112: 161.28,87.37 162.73,87.37 163.24,86.85 164.07,86.85 v3(164.4,87.18)
  TOP w0.14: 161.28,87.37 161.1,87.37 161.08,87.38 160.43,87.38 160.42,87.37 158.97,87.37 157.23,89.11 154.37,89.11 CV67.2
  BOTTOM w0.089: UV1.BE26 v3(164.4,87.18)
PEG_GTX_HRX_P5: length 42
  TOP w0.14: v3(150.59,90.41) 150.28,90.41 150.18,90.5 150.18,90.65 150.81,91.28 151.24,91.28 152.2,90.31 155,90.31 155.12,90.2 155.12,90.04 154.94,89.86 CV69.1
  IN1 w0.119: v3(123.11,102.43) 123.28,102.27 123.57,102.27 123.71,102.12 124.35,102.12 124.69,102.47 127.63,102.47 130.22,99.89 130.22,98.55 132.47,96.3 132.47,94.87 137.25,90.09 144.53,90.09 145.09,90.65 148.57,90.65 148.64,90.58 150.09,90.58 150.26,90.41 v3(150.59,90.41)
  BOTTOM w0.089: v3(123.11,102.43) 122.76,102.07 CPU1.A9
PEG_GTX_HRX_P5_C: length 12.5
  TOP w0.112: v3(165.2,87.18) 165.52,87.18 165.6,87.26 165.6,87.47 165.47,87.6 164.1,87.6 163.82,87.32 163.42,87.32 163.05,87.69 162.86,87.69 162.86,87.7 161.77,87.7 161.49,87.99 161.47,87.99
  TOP w0.14: 161.47,87.99 159.52,87.99 v4(157.83,89.67) 157.24,90.26 156.25,90.26 CV69.2
  BOTTOM w0.101: UV1.BD26 v3(165.2,87.18)
PEG_GTX_HRX_P6: length 46.9
  TOP w0.14: v3(148.11,86.45) 147.97,86.58 147.97,87.71 148.53,88.27 148.53,90.07 150.51,92.05 151.54,92.05 152.01,91.58 152.54,91.58 152.65,91.47 152.65,91.2 CV65.1
  IN1 w0.119: v3(125.1,93.78) 125.26,93.94 125.44,93.94 126.23,93.15 130.54,93.15 135.25,88.45 135.25,87.89 138.15,84.98 143.8,84.98 143.93,84.86 143.93,83.18 144.18,82.93 144.77,82.93 145.02,83.18 145.02,85.5 145.15,85.63 145.59,85.63 145.71,85.5 145.71,83.15 145.96,82.9 146.55,82.9 146.8,83.15 146.8,85.45 146.96,85.62 147.61,85.62 147.95,85.96 147.95,86.3 v3(148.11,86.45)
  BOTTOM w0.089: v3(125.1,93.78) 125.1,93.82 CPU1.M5
PEG_GTX_HRX_P6_C: length 15.2
  TOP w0.112: 160.7,88.86 160.72,88.86 160.73,88.88 161.73,88.88 162.42,88.19 163.15,88.19 163.37,88.41 163.89,88.41 164.13,88.17 165.58,88.17 165.83,88.41 165.83,88.6 v3(166,88.78)
  TOP w0.14: CV65.2 153.85,91.48 155.02,91.48 155.04,91.46 155.76,91.46 155.78,91.48 157.7,91.48 160.32,88.86 160.7,88.86
  BOTTOM w0.089: UV1.BC27 v3(166,88.78)
PEG_GTX_HRX_P7: length 36.6
  TOP w0.14: v3(147.71,88.52) 147.51,88.72 147.51,90.26 150.07,92.81 154.14,92.81 154.45,93.12 154.86,93.12 155,92.98 155,92.73 CV72.1
  IN1 w0.119: v3(128.65,95.27) 128.35,95.01 128.34,95 128.34,94.64 128.47,94.51 130.49,94.51 136.86,88.14 137.54,88.14 139.29,86.4 143.65,86.4 146.49,89.23 147.3,89.23 147.53,89 147.53,88.7 v3(147.71,88.52)
  BOTTOM w0.089: v3(128.65,95.27) 128.54,95.27 CPU1.L1
PEG_GTX_HRX_P7_C: length 11
  TOP w0.112: v3(164.4,88.78) 164.07,89.11 163.01,89.11 162.6,89.52 162.52,89.6 161.6,89.6 161.42,89.6 161.37,89.65 161.35,89.65 161.34,89.66
  TOP w0.14: 161.34,89.66 158.01,92.99 v4(157.49,92.99) 156.17,92.99 CV72.2
  BOTTOM w0.101: UV1.BE28 v3(164.4,88.78)
PEG_GTX_HRX_P8: length 64.5
  IN6 w0.119: v3(127.19,93.77) 126.9,93.47 126.9,92.8 127.22,92.47 135.02,92.47 136.68,90.81 140.37,90.81 147.24,97.68 150.14,97.68 155.86,103.41 155.86,115.88 157.75,117.77 157.75,124.53 158.22,125.01 158.22,126.09 158.94,126.8 159.79,126.8 160.02,126.57 160.02,126.33 v3(160.24,126.11)
  BOTTOM w0.089: CPU1.M3 126.82,93.96 127.02,93.77 v3(127.19,93.77)
  BOTTOM w0.14: CM63.1 159.79,126.88 159.79,126.74 160.07,126.46 160.07,126.28 v3(160.24,126.11)
PEG_GTX_HRX_P9: length 64.3
  IN6 w0.119: v3(156.38,125.91) 156.12,126.16 154.92,126.16 154.35,126.74 153.11,126.74 150.33,123.95 150.33,119.1 154.54,114.89 154.54,103.91 151.55,100.92 149.45,100.92 147.49,98.95 146.21,98.95 141.36,94.1 130.9,94.1 130.31,94.69 127.19,94.69 127.15,94.72 126.6,94.72 v3(126.43,94.56)
  BOTTOM w0.089: CPU1.L3 126.82,94.95 v3(126.43,94.56)
  BOTTOM w0.14: v3(156.38,125.91) 156.53,126.06 156.82,126.06 157.38,126.62 157.38,126.8 CM64.1
PEG_GTX_HRX_P10: length 65.6
  IN6 w0.119: v3(156.99,125.63) 156.99,125.46 156.78,125.25 155.36,125.25 155.12,125.49 152.87,125.49 150.83,123.45 150.83,119.32 155.15,114.99 155.15,103.79 151.75,100.4 149.79,100.4 147.84,98.45 146.42,98.45 140.46,92.49 139.07,92.49 138.3,93.25 128.51,93.25 128.39,93.37 128.39,93.49 v3(128.68,93.78)
  BOTTOM w0.089: CPU1.M1 128.59,93.78 v3(128.68,93.78)
  BOTTOM w0.14: CM68.1 159.02,124.55 158.61,124.14 v4(158.32,124.14) 158.05,124.14 156.99,125.2 v3(156.99,125.63)
PEG_GTX_HRX_P11: length 65.2
  IN6 w0.119: v3(125.79,89.62) 125.7,89.62 125.49,89.83 125.49,89.97 125.66,90.15 135.45,90.15 135.73,89.87 140.81,89.87 147.68,96.74 150.54,96.74 156.85,103.06 156.85,115.55 158.72,117.42 158.72,123.8 160.31,125.39 160.56,125.39 160.89,125.73 160.89,125.82 161.04,125.97 161.18,125.97 v3(161.31,125.84)
  BOTTOM w0.089: v3(125.79,89.62) 125.59,89.62 125.42,89.46 CPU1.Y5
  BOTTOM w0.14: v3(161.31,125.84) 161.48,126.01 161.75,126.01 162.14,126.41 162.14,126.85 CM67.1
PEG_HTX_C_GRX_N0: length 7.8
  BOTTOM w0.14: 158.39,82.85 v4(158.39,82.86) ; 158.39,82.85 159.77,84.23 161.08,84.23 161.34,83.97 161.8,83.97 162.2,83.58 UV1.BG21 ; 158.39,82.85 157.71,82.17 157.16,82.17 157.14,82.19 156.6,82.19 156.58,82.17 156.11,82.17 CC1.2
PEG_HTX_C_GRX_N1: length 9.9
  BOTTOM w0.14: UV1.BH23 161.6,85.38 161.48,85.5 161.31,85.5 161.19,85.38 161.19,84.93 161.08,84.82 160.64,84.82 160.53,84.93 159.51,84.93 159.12,84.54 v4(158.54,84.54) 157.68,84.54 157.03,83.89 157,83.89 156.62,83.51 156.62,83.49 156.56,83.42 153.72,83.42 153.5,83.64 CC2.2
PEG_HTX_C_GRX_N2: length 5.6
  BOTTOM w0.14: UV1.BJ24 160.51,85.69 159.18,85.69 159.13,85.64 157.15,85.64 157.07,85.56 157.04,85.56 156.58,85.09 156.58,85.07 156.38,84.86 156.19,84.86 CC3.2
PEG_HTX_C_GRX_N3: length 9.1
  BOTTOM w0.14: CC4.2 154.06,86.57 154.5,86.57 154.71,86.35 155.11,86.35 155.13,86.37 155.67,86.37 155.69,86.35 156.34,86.35 156.44,86.45 v4(158.56,86.45) 159.86,86.45 159.99,86.58 161.17,86.58 161.38,86.37 161.8,86.37 162.04,86.12 162.26,86.12 UV1.BG24
PEG_HTX_C_GRX_N4: length 7
  BOTTOM w0.14: CC5.2 155.74,87.9 155.74,87.75 155.93,87.56 v4(157.48,87.56) 158.28,87.56 158.63,87.21 161.1,87.21 161.17,87.28 161.17,87.66 161.29,87.78 161.55,87.78 161.6,87.73 UV1.BH26
PEG_HTX_C_GRX_N5: length 7.5
  BOTTOM w0.14: UV1.BJ27 160.53,88.1 158.92,88.1 157.91,89.11 156.96,89.11 156.94,89.13 156.4,89.13 156.38,89.11 154.36,89.11 CC6.2
PEG_HTX_C_GRX_N6: length 7.6
  BOTTOM w0.14: UV1.BG27 162.04,88.74 161.39,88.74 161.03,89.09 159.23,89.09 158.82,89.5 158.82,89.53 158.44,89.91 158.41,89.91 157.75,90.58 v4(156.89,90.58) 156.06,90.58 CC7.2
PEG_HTX_C_GRX_N7: length 10.4
  BOTTOM w0.14: UV1.BH29 161.6,90.29 161.47,90.41 161.29,90.41 161.17,90.29 161.17,89.77 161.02,89.63 159.88,89.63 v4(158.4,91.11) 157.56,91.95 155.74,91.95 155.72,91.97 155,91.97 154.98,91.95 154.5,91.95 154.19,91.65 153.91,91.65 CC8.2
PEG_HTX_C_GRX_N8: length 7.2
  BOTTOM w0.14: JCDRA.4 171.9,142.33 171.82,142.25 171.82,142.1 170.89,141.18 168.72,141.18 168.23,140.68 168.23,140.45 168.25,140.43 168.25,139.89 168.23,139.87 168.23,139.26 CC9.2
PEG_HTX_C_GRX_N9: length 5.3
  BOTTOM w0.14: JCDRA.7 173.1,142.3 172.99,142.19 172.99,142.04 171.36,140.41 170.17,140.41 170.11,140.35 170.11,140.28 170.44,139.94 CC10.2
PEG_HTX_C_GRX_N10: length 5.7
  BOTTOM w0.14: JCDRA.10 174.3,142.3 174.22,142.22 174.22,141.76 173.52,141.06 173.14,141.06 172.47,140.39 172.47,140.37 171.99,139.88 171.99,139.22 CC11.2
PEG_HTX_C_GRX_N11: length 4
  BOTTOM w0.14: CC12.2 174.08,140.44 174.08,140.54 174.68,141.14 175.06,141.14 175.44,141.52 175.44,142.25 175.5,142.31 JCDRA.13
PEG_HTX_C_GRX_P0: length 7.8
  BOTTOM w0.14: UV1.BH21 161.6,83.53 161.47,83.4 161.29,83.4 161.17,83.53 161.17,83.81 160.98,83.99 159.87,83.99 158.76,82.87 158.76,82.86 158.39,82.49 158.38,82.49 157.81,81.93 v4(156.87,81.93) 155.74,81.93 155.66,81.85 155.66,81.69 CC13.2
PEG_HTX_C_GRX_P1: length 9.9
  BOTTOM w0.14: CC14.2 153.73,83.18 156.66,83.18 v4(157,83.52) 157.78,84.3 158.23,84.3 158.26,84.27 158.83,84.27 158.85,84.3 159.22,84.3 159.61,84.69 160.43,84.69 160.54,84.58 161.18,84.58 161.38,84.77 161.69,84.77 UV1.BG23
PEG_HTX_C_GRX_P2: length 5.6
  BOTTOM w0.14: UV1.BJ23 160.53,85.45 159.28,85.45 159.23,85.4 157.25,85.4 v4(156.98,85.12) 156.48,84.62 156.2,84.62 CC15.2
PEG_HTX_C_GRX_P3: length 9.1
  BOTTOM w0.14: UV1.BH24 161.6,85.89 161.5,85.79 161.29,85.79 161.23,85.86 161.23,86.18 161.07,86.34 160.09,86.34 159.96,86.21 158.87,86.21 158.84,86.18 158.26,86.18 158.23,86.21 156.54,86.21 156.44,86.11 v4(155.4,86.11) 154.61,86.11 154.4,86.32 153.76,86.32 153.66,86.22 153.66,86.03 CC16.2
PEG_HTX_C_GRX_P4: length 7.1
  BOTTOM w0.14: UV1.BG26 162.22,87.58 161.82,87.18 161.41,87.18 161.2,86.97 158.52,86.97 158.18,87.32 157.77,87.32 157.75,87.3 157.21,87.3 157.19,87.32 156.08,87.32 CC17.2
PEG_HTX_C_GRX_P5: length 7.5
  BOTTOM w0.14: UV1.BJ26 160.52,87.86 158.82,87.86 157.81,88.87 v4(156.67,88.87) 154.4,88.87 CC18.2
PEG_HTX_C_GRX_P6: length 7.5
  BOTTOM w0.14: UV1.BH27 161.67,88.31 161.67,88.15 161.55,88.03 161.33,88.03 161.21,88.15 161.21,88.58 160.93,88.85 159.13,88.85 v4(158.45,89.54) 157.65,90.34 157.22,90.34 157.2,90.32 156.6,90.32 156.58,90.34 156.32,90.34 CC19.2
PEG_HTX_C_GRX_P7: length 10.4
  BOTTOM w0.14: CC20.2 153.77,91.4 154.29,91.4 154.6,91.71 v4(155.4,91.71) 157.46,91.71 158.01,91.16 158.01,91.13 158.51,90.63 158.54,90.63 159.78,89.38 161.12,89.38 161.36,89.63 161.87,89.63 162.22,89.98 UV1.BG29
PEG_HTX_C_GRX_P8: length 7.2
  BOTTOM w0.14: JCDRA.3 171.5,142.36 171.58,142.28 171.58,142.2 170.79,141.42 168.62,141.42 167.98,140.78 v4(167.98,140.16) 167.98,139.32 CC21.2
PEG_HTX_C_GRX_P9: length 5.3
  BOTTOM w0.14: JCDRA.6 172.7,142.31 172.75,142.27 172.75,142.14 171.26,140.65 170.07,140.65 169.86,140.45 169.86,140.26 CC22.2
PEG_HTX_C_GRX_P10: length 5.6
  BOTTOM w0.14: JCDRA.9 173.9,142.32 173.98,142.24 173.98,141.86 173.42,141.3 173.04,141.3 v4(172.03,140.29) 171.74,140.01 171.74,139.11 CC23.2
PEG_HTX_C_GRX_P11: length 4
  BOTTOM w0.14: CC24.2 173.84,140.5 173.84,140.64 174.58,141.38 174.96,141.38 175.2,141.62 175.2,142.22 175.1,142.32 JCDRA.12
PEG_HTX_GRX_N0: length 50
  IN4 w0.112: v3(153.77,82.01) 153.59,82.19 153.59,82.69 153.85,82.94 154.29,82.94 155.21,83.87 155.21,90.67 152.42,93.45 144.7,93.45 140.49,97.67 136.83,97.67 136.54,97.96 134.12,97.96 133.41,98.68 133.41,99.7 130.76,102.35 125.08,102.35 124.13,101.4 124.13,101.26 v3(123.89,101.02)
  BOTTOM w0.089: CPU1.B6 124.24,101.37 v3(123.89,101.02)
  BOTTOM w0.14: CC1.1 155.01,82.36 155.01,82.11 154.88,81.98 154.42,81.98 154,81.56 153.75,81.56 153.6,81.71 153.6,81.84 153.76,82.01 v3(153.77,82.01)
PEG_HTX_GRX_N1: length 48.5
  IN4 w0.112: v3(151.64,82.01) 151.86,82.22 151.86,82.8 153.04,83.97 154.04,83.97 154.28,84.22 154.28,90.31 152.08,92.51 144.16,92.51 140.85,95.82 137.11,95.82 136.02,96.91 133.79,96.91 132.5,98.2 132.5,99.33 130.39,101.44 125.5,101.44 125.28,101.23 125.28,101.04 124.72,100.48 v3(124.72,100.32)
  BOTTOM w0.089: CPU1.C5 125.07,100.67 v3(124.72,100.32)
  BOTTOM w0.14: CC2.1 152.35,83.63 152.06,83.63 151.78,83.35 151.78,82.14 v3(151.64,82.01)
PEG_HTX_GRX_N2: length 44.2
  IN4 w0.089: 124.33,98.55 124.34,98.56 124.34,98.57 124.38,98.61 124.38,98.78 124.38,98.78 124.38,99.16 124.26,99.27 124.26,99.72 124.39,99.85 124.56,99.85 124.69,99.72 v3(124.69,99.66)
  IN4 w0.112: v3(150.83,84.41) 151.08,84.16 151.08,84 150.95,83.87 150.64,83.87 148.52,85.99 145.99,85.99 145.62,86.36 139.91,86.36 137.06,89.21 135.17,89.21 131.15,93.22 124.39,93.22 123.78,93.84 123.78,98 124.33,98.55
  BOTTOM w0.089: v3(124.69,99.66) 124.68,99.66 CPU1.E6
  BOTTOM w0.14: v3(150.83,84.41) 150.83,84.43 151.03,84.63 151.03,84.85 151.27,85.09 151.81,85.09 151.83,85.12 152.3,85.12 152.54,85.35 154.16,85.35 154.55,84.97 154.7,84.97 CC3.1
PEG_HTX_GRX_N3: length 44.2
  IN4 w0.089: 126.21,100.52 125.61,100.52 125.26,100.18 125.26,100.09 125.23,100.06 125.23,99.27 125.44,99.07 125.77,99.07 125.87,99.16 125.87,99.4 125.7,99.57 v3(125.62,99.57)
  IN4 w0.112: v3(151,85.61) 151,85.62 151.38,86.01 151.38,86.03 151.61,86.26 152.3,86.26 153.57,87.52 153.57,90.04 151.79,91.82 143.84,91.82 141.62,94.03 135.51,94.03 128.81,100.73 126.42,100.73 126.21,100.52
  BOTTOM w0.089: v3(125.62,99.57) 125.86,99.57 CPU1.D4
  BOTTOM w0.14: CC4.1 152.66,86.57 152.4,86.57 152.14,86.31 151.51,86.31 151.17,85.97 151.17,85.78 v3(151,85.61)
PEG_HTX_GRX_N4: length 42.3
  IN4 w0.089: v3(126.49,97.86) 126.3,97.67 126.13,97.67 126.02,97.78 126.02,98.32 126.17,98.46 126.17,98.76 126.24,98.83 126.24,99.68 126.25,99.69
  IN4 w0.112: v3(151.34,86.83) 151.59,87.08 151.59,87.52 151.91,87.84 152.06,87.84 152.85,88.62 152.85,89.77 151.5,91.12 143.4,91.12 142.25,92.27 139.45,92.27 138.52,93.19 135.33,93.19 128.96,99.57 127.75,99.57 127.37,99.96 126.52,99.96 126.25,99.69
  BOTTOM w0.089: CPU1.G4 126.12,97.49 v3(126.49,97.86)
  BOTTOM w0.14: v3(151.34,86.83) 151.48,86.97 151.48,87.39 152.02,87.94 153.14,87.94 153.3,87.78 154.7,87.78 CC5.1
PEG_HTX_GRX_N5: length 32.5
  IN4 w0.112: v3(151.35,88.42) 151.58,88.65 151.58,88.76 151.49,88.85 150.98,88.85 150.92,88.91 150.57,88.91 150.46,88.8 149.84,88.8 148.35,90.28 143.25,90.28 142.91,90.62 138.79,90.62 138,91.4 135.83,91.4 131.73,95.5 131.38,95.5 127.86,99.02 127.38,99.02 127.2,98.84 v3(127.2,98.57)
  BOTTOM w0.089: v3(127.2,98.57) 127.2,98.64 CPU1.E3
  BOTTOM w0.14: CC6.1 152.8,89.18 151.83,89.18 151.5,88.85 151.5,88.57 v3(151.35,88.42)
PEG_HTX_GRX_N6: length 38.3
  IN4 w0.112: v3(125.11,96.15) 124.92,96.15 124.72,95.95 124.72,95.88 125.13,95.46 125.73,95.46 126.18,95.91 126.88,95.91 127.38,95.41 127.38,95.09 127.6,94.87 129.8,94.87 130.56,94.11 131.3,94.11 135.45,89.97 137.42,89.97 140.28,87.11 149.08,87.11 v3(149.32,87.34)
  BOTTOM w0.089: CPU1.J5 125.36,96.58 125.11,96.34 v3(125.11,96.15)
  BOTTOM w0.14: v3(149.32,87.34) 149.46,87.2 149.83,87.2 150.1,87.47 150.1,88.78 150.56,89.23 150.56,89.79 151.04,90.27 152.16,90.27 152.34,90.45 154.6,90.45 154.66,90.51 154.66,90.51 CC7.1
PEG_HTX_GRX_N7: length 33.6
  IN4 w0.112: v3(127.13,96.97) 127.13,97.31 127.27,97.45 127.94,97.45 130.74,94.65 131.5,94.65 135.55,90.6 137.78,90.6 138.5,89.89 142.65,89.89 143.15,89.39 148.18,89.39 148.96,88.61 148.96,88.08 v3(148.87,87.99)
  BOTTOM w0.089: CPU1.G3 127.02,97.4 127.15,97.26 127.15,97 v3(127.13,96.97)
  BOTTOM w0.14: v3(148.87,87.99) 149.07,88.2 149.07,88.84 149.44,89.21 149.44,90.28 150.98,91.82 152.35,91.82 CC8.1
PEG_HTX_GRX_N8: length 82.5
  IN6 w0.119: v3(168.37,137.33) 168.24,137.21 168.24,136.91 167.89,136.57 165.86,136.57 164.52,135.24 162.97,135.24 162.68,134.94 161.74,134.94 161.15,134.35 154.69,134.35 153.37,133.02 153.18,133.02 147.26,127.1 147.26,118.05 151.6,113.71 151.6,104.99 150.43,103.83 147,103.83 141.8,98.64 137.31,98.64 136.71,98.04 135.01,98.04 134.78,98.27 134.78,98.49 v3(134.57,98.69)
  BOTTOM w0.089: 129.8,96.18 129.78,96.18 129.76,96.16 129.71,96.16 129.69,96.14 128.93,96.14 128.79,96.29 126.55,96.29 126.43,96.4 126.43,96.71 126.53,96.81 126.68,96.81 126.82,96.68 CPU1.J3
  BOTTOM w0.14: v3(168.37,137.33) 168.16,137.54 168.16,137.67 CC9.1 ; v3(134.57,98.69) 134.82,98.44 134.82,97.28 133.23,95.69 133.06,95.69 133.04,95.71 132.5,95.71 132.48,95.69 131.34,95.69 130.85,96.18 129.8,96.18
PEG_HTX_GRX_N9: length 83.3
  IN6 w0.119: v3(132.06,98.38) 132.25,98.57 133.07,98.57 134.31,97.33 137.15,97.33 137.73,97.91 142.09,97.91 147.29,103.12 150.73,103.12 152.31,104.7 152.31,114 148.08,118.23 148.08,126.54 153.23,131.69 153.5,131.69 154.67,132.86 160.8,132.86 161.78,133.85 165.68,133.85 166.86,135.03 168.2,135.03 168.53,135.36 168.53,136 168.74,136.21 169.33,136.21 169.64,136.51 169.64,137.21 v3(169.77,137.34)
  BOTTOM w0.14: CC10.1 170.09,138.68 170.09,138.42 169.59,137.91 169.59,137.52 v3(169.77,137.34) ; v3(132.06,98.38) 132.28,98.6 132.52,98.6 132.63,98.49 132.63,98.22 131.46,97.06 127.99,97.06 CPU1.J2
PEG_HTX_GRX_N10: length 89.8
  IN6 w0.119: v3(125.06,92.07) 125.15,91.98 125.15,91.75 125.06,91.65 124.78,91.65 124.61,91.83 124.61,92.4 125.82,93.61 125.82,95.23 126.46,95.87 130.62,95.87 130.99,95.51 132.51,95.51 133.62,96.62 137.49,96.62 138.07,97.2 142.38,97.2 147.59,102.41 151.02,102.41 153.02,104.41 153.02,114.3 148.82,118.5 148.82,124.61 150.13,125.92 150.13,126.51 151.97,128.35 151.97,128.93 153.2,130.15 153.55,130.15 155.1,131.7 160.67,131.7 161.94,132.97 165.9,132.97 167.16,134.23 168.47,134.23 168.77,134.53 171.17,134.53 172.02,135.38 172.02,136.63 v3(172.2,136.81)
  BOTTOM w0.089: v3(125.06,92.07) 124.72,91.73 CPU1.T6
  BOTTOM w0.14: v3(172.2,136.81) 172.05,136.96 172.05,137.61 CC11.1
PEG_HTX_GRX_N11: length 90.2
  IN6 w0.119: v3(134.77,95.66) 134.98,95.45 134.98,95.15 135.23,94.9 138.8,94.9 139.69,95.79 141.98,95.79 147.88,101.7 151.32,101.7 153.8,104.18 153.8,114.52 149.57,118.75 149.57,124.32 155.4,130.15 160.95,130.15 161.96,131.16 165.36,131.16 165.6,131.39 166.65,131.39 168.56,133.31 171.24,133.31 174.07,136.13 174.07,137.47 v3(174.17,137.57)
  BOTTOM w0.089: CPU1.R6 124.87,92.52 125.03,92.68 125.03,92.81 125.24,93.02 129.36,93.02 129.42,92.97 ; 129.78,92.97 129.8,92.97
  BOTTOM w0.14: v3(134.77,95.66) 134.85,95.66 135.07,95.44 135.07,95.2 134.77,94.9 134.54,94.9 v4(133.21,93.57) 132.61,92.97 129.8,92.97 ; CC12.1 174,138.84 174,137.74 v3(174.17,137.57) ; 129.42,92.97 129.78,92.97
PEG_HTX_GRX_P0: length 50.2
  IN4 w0.112: v3(123.89,100.32) 124.34,100.77 124.34,101.31 125.17,102.14 130.68,102.14 133.2,99.62 133.2,98.59 134.04,97.75 136.45,97.75 136.74,97.46 140.4,97.46 144.62,93.25 152.34,93.25 155,90.58 155,83.95 154.2,83.15 153.76,83.15 153.38,82.77 153.38,82.2 v3(153.18,82.01)
  BOTTOM w0.089: v3(123.89,100.32) 124.24,100.67 CPU1.C6
  BOTTOM w0.14: CC13.1 154.7,81.74 154.52,81.74 154.1,81.32 153.65,81.32 153.35,81.61 153.35,81.84 v3(153.18,82.01)
