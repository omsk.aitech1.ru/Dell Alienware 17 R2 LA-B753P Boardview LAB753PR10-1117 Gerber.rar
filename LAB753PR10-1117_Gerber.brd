# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PROCHOT#: length 379
  TOP w0.127: v3(42.46,32.26) 42.21,32.51 PR724.1 ; PQ8.1 71.42,20.74 71.62,20.93 71.87,20.93 v3(72.05,20.75) ; RE78.1 v3(296.01,21.06) 296.45,20.63 296.45,19.86 CE51.1 295.89,17.99 v2(295.77,17.87) 295.45,17.55 294.11,17.55 294,17.44 UE7.4
  IN1 w0.099: v3(87.22,101.81) 86.87,101.46 86.87,94.62 74.49,82.24 74.49,65.05 70.88,61.45 70.88,54.87 74.53,51.23 74.53,45.37 73,43.84 73,31.82 74.24,30.58 74.24,26.93 73.76,26.46 73.76,23.36 72.05,21.64 v3(72.05,20.75)
  IN4 w0.091: v3(72.05,20.75) 72.71,20.09 73.98,20.09 76.52,17.55 98.33,17.55 98.82,18.04 130.03,18.04 130.36,18.37 146.71,18.37 146.93,18.58 152.77,18.58 153.33,18.03 155.72,18.03 158.08,15.67 158.85,15.67 159.83,14.68 162.82,14.68 163.5,15.36 167.31,15.36 167.74,14.92 169.23,14.92 169.33,15.01 173.64,15.01 173.92,15.29 179.66,15.29 180.16,15.79 191.68,15.79 192.26,16.37 193.71,16.37 194.88,17.53 200.35,17.53 200.99,18.17 205.93,18.17 206.54,17.56 207.13,17.56 207.75,16.94 217.15,16.94 217.65,16.44 228.74,16.44 229.71,17.4 232.26,17.4 233.16,18.3 236.75,18.3 237.44,17.62 240.47,17.62 241.39,16.69 249.66,16.69 250.09,17.13 257.35,17.13 260.61,20.39 284.96,20.39 285.29,20.06 286.92,20.06 287.17,19.8 290.08,19.8 291.81,21.53 295.54,21.53 v3(296.01,21.06)
  IN6 w0.099: v3(72.05,20.75) 69.35,20.75 67.99,19.39 56.52,19.39 55.87,18.75 45.74,18.75 45.15,19.34 45.15,22 45.52,22.37 45.52,30.99 44.85,31.66 43.06,31.66 v3(42.46,32.26)
  BOTTOM w0.127: v3(87.22,101.81) 87.28,101.88 R2.1 RC11.2
H_PROCHOT#_R: length 8.8
  TOP w0.127: v3(90.36,100.28) v2(90.36,100.98)
  IN6 w0.089: v3(95.12,98.9) 92.71,98.9 91.82,99.79 90.86,99.79 90.81,99.84
  IN6 w0.099: v3(90.36,100.28) 90.81,99.84
  BOTTOM w0.089: v3(95.12,98.9) 95.12,98.9 CPU1.E50
  BOTTOM w0.127: R2.2 90.36,100.37 v3(90.36,100.28)
H_THERMTRIP#: length 228.1
  TOP w0.127: v2(77.59,51.2) 77.28,50.89 v3(77.28,50.64)
  IN1 w0.089: 90.81,100.05 v3(91,100.25)
  IN1 w0.099: v3(77.28,50.64) 78.09,51.45 78.09,67.86 77.09,68.86 77.09,76.7 80.65,80.25 80.65,86.44 90.36,96.16 90.36,99.61 90.81,100.05
  IN6 w0.099: v3(77.28,50.64) 76.53,49.89 76.53,47.59 74.18,45.24 74.18,37.65 72.81,36.28 72.81,30.13 74.46,28.48 75.15,28.48 77.24,26.39 79.58,26.39 81.47,24.5 81.47,19.25 82.63,18.09 140.56,18.09 141.79,19.32 155.2,19.32 157,17.51 168.77,17.51 170.67,19.41 175.36,19.41 175.73,19.05 182.67,19.05 183.32,19.7 190.66,19.7 190.98,20.01 191.54,20.01 192.88,21.35 198.68,21.35 199.55,22.21 201.29,22.21 201.97,22.89 v3(206.99,22.89)
  BOTTOM w0.089: v3(91,100.25) 92.73,100.25 CPU1.D53
  BOTTOM w0.127: v3(206.99,22.89) 206.89,22.99 206.89,23.28 RH124.2
HDA_SPKR: length 38.8
  TOP w0.127: RH5.2 211.05,28.07 211.05,28.37 211.68,29 215.08,29 215.76,29.68 215.76,30.53 216.03,30.8 216.34,30.8 216.68,31.14 216.68,32.35 v3(217.39,33.06)
  IN1 w0.099: v3(217.39,33.06) 216.92,32.58 216.92,30.38 216.5,29.96 216.5,28.26 215.62,27.38 215.62,24.64 215.15,24.17 215.15,22.7 215.47,22.38 215.47,21.17 214.89,20.59 214.89,15.64 215.58,14.95 220.98,14.95 v3(221.49,14.44)
  BOTTOM w0.089: v3(217.39,33.06) 217.65,32.8 UH1.AL10
  BOTTOM w0.127: CA68.1 222.19,15.14 v3(221.49,14.44)
HDD_A0_PRE0: length 3.4
  TOP w0.127: UN1.9 161.05,19.59 v1(160.77,19.86) 160.21,20.42 RN10.2 RN22.1
HDD_A0_PRE1: length 3.5
  TOP w0.127: UN1.19 162.05,14.21 162.6,13.65 v1(162.6,13.54) 162.6,12.78 RN21.1 RN14.2
HDD_B: length 25.2
  TOP w0.127: v2(166.71,141.04) v3(166.71,140.29) ; JPWR1.16 v3(180.65,146.97)
  IN2 w0.099: v3(166.71,140.29) 167.03,140.6 167.03,144.16 170.49,147.61 180,147.61 v3(180.65,146.97)
  BOTTOM w0.127: v3(166.71,140.29) 165.89,139.46 164.54,139.46 163.87,138.79 QE13.3
HDD_B0_PRE0: length 5.3
  TOP w0.127: v1(162.46,22.67) 162.46,21.25 RN19.1 RN11.2 161.1,20.14 161.55,19.7 UN1.8
HDD_B0_PRE1: length 6.1
  TOP w0.127: v1(159.22,10.39) 159.22,12.08 RN20.1 RN13.2 161.05,13.89 UN1.17
HDD_B_7313#: length 71.5
  TOP w0.127: UE3.21 218.18,113.62 217.53,112.97 213.99,112.97 213.58,113.38 v3(213.58,114.04)
  IN6 w0.099: v3(171.63,132.74) 172.33,132.04 175.71,132.04 177.1,130.65 186.57,130.65 187.21,130.02 189.25,130.02 189.93,130.7 195.72,130.7 197.97,128.45 197.97,125.5 199.14,124.33 199.14,120.08 202.5,116.71 210.76,116.71 213.44,114.04 v3(213.58,114.04)
  BOTTOM w0.127: QE13.4 165.99,138.79 166.75,138.03 166.75,137.33 167.73,136.35 168.14,136.35 v1(168.29,136.2) 168.29,135.48 168.81,134.96 170.51,134.96 171.63,133.84 v3(171.63,132.74)
HDD_DET#: length 79.4
  TOP w0.089: 222.51,33.45 222.51,32.45 222.71,32.25 222.93,32.25 223.12,32.07 223.12,30.29
  TOP w0.127: RH123.1 218.51,24.39 v3(219.08,24.96) 219.08,25.71 220.58,27.21 v1(220.58,27.79) 220.58,28.27 222.15,29.85 222.67,29.85 223.12,30.29 ; 222.51,33.45 v3(222.88,33.83)
  IN4 w0.122: v3(159.88,25.1) 162.02,22.96 165.16,22.96 167.16,20.96 168.86,20.96 169.47,21.56 174.15,21.56 174.83,20.88 179.79,20.88 180.37,21.46 183.2,21.46 183.77,20.88 191.56,20.88 192.22,21.54 196.95,21.54 198.28,22.87 203.82,22.87 205.75,24.81 208.6,24.81 208.85,24.55 218.67,24.55 v3(219.08,24.96)
  BOTTOM w0.089: v3(222.88,33.83) 223.05,33.99 UH1.U12
  BOTTOM w0.127: v3(159.88,25.1) 160.81,26.03 JHDD1.12
HDD_G: length 27
  TOP w0.127: JPWR1.15 180.15,146.71 181.13,145.73 181.13,145.23 v3(180.68,144.78) ; v3(166.32,137.8) 166.89,138.37 v1(166.89,138.42)
  IN1 w0.099: v3(180.68,144.78) 180.49,144.97 177.6,144.97 175.59,142.96 175.59,141.72 173.49,139.61 168.14,139.61 v3(166.32,137.8)
  BOTTOM w0.127: QE12.3 166.01,135.09 165.54,135.56 165.54,137.01 v3(166.32,137.8)
HDD_G_7313#: length 68.8
  TOP w0.127: v3(214.02,113.53) 214.23,113.32 217.21,113.32 217.68,113.8 UE3.20
  IN6 w0.099: v3(214.02,113.53) 213.51,113.53 210.55,116.49 202.41,116.49 198.91,119.99 198.91,124.24 197.74,125.4 197.74,128.36 195.63,130.48 190.03,130.48 189.34,129.79 187.04,129.79 186.41,130.42 176.93,130.42 175.56,131.79 171.93,131.79 v3(171.02,132.7)
  BOTTOM w0.127: v3(171.02,132.7) 171.02,132.96 171.29,133.22 v1(171.29,133.63) 171.29,133.82 170.4,134.71 168.7,134.71 168.17,135.24 167.81,135.24 167.22,134.66 165.88,134.66 165.45,135.09 QE12.4
HDD_R: length 23.6
  TOP w0.127: JPWR1.14 179.65,146.81 180.68,145.77 v3(180.68,145.38) ; v1(165.08,138.46) 165.11,138.46 165.72,137.85 v3(165.72,137.8)
  IN1 w0.099: v3(180.68,145.38) 180.53,145.23 177.51,145.23 175.35,143.07 175.35,141.8 173.4,139.84 168,139.84 166.51,138.36 166.28,138.36 v3(165.72,137.8)
  BOTTOM w0.127: QE13.6 165.42,137.49 v3(165.72,137.8)
HDD_R_7313#: length 72.4
  TOP w0.127: UE3.19 217.18,113.97 216.98,113.77 215.89,113.77 v3(215.58,114.07)
  IN6 w0.099: v3(172.26,132.74) 172.71,132.3 175.83,132.3 177.19,130.94 186.6,130.94 187.3,130.24 189.15,130.24 189.84,130.93 195.81,130.93 198.2,128.55 198.2,125.59 199.36,124.43 199.36,120.18 202.6,116.94 210.86,116.94 213.21,114.58 215.07,114.58 v3(215.58,114.07)
  BOTTOM w0.127: v3(172.26,132.74) 171.88,133.12 171.88,133.94 170.51,135.32 v1(170.12,135.32) 168.81,135.32 168.7,135.43 168.7,136.31 168.4,136.6 167.84,136.6 167.01,137.43 167.01,138.13 165.93,139.21 164.65,139.21 164.25,138.8 164.25,138.12 163.61,137.49 QE13.1
HDD_REXT_SATA0:
  vias: v1(164.06,13.53)
HDMI_BUF: length 7.2
  TOP w0.127: v3(102.67,141.1) 102.88,141.31 103.35,141.31 104.82,139.85 v1(105.96,139.85) 106.87,139.85 106.91,139.9 UV4.14
  BOTTOM w0.127: RV301.1 102.12,141.1 v3(102.67,141.1) 103.37,141.1 RV300.2
HDMI_CFG: length 1.6
  TOP w0.127: v3(109.07,135.92) UV4.23
  BOTTOM w0.127: RV302.2 109.11,135.92 v3(109.07,135.92)
HDMI_DCIN_EN: length 3.1
  TOP w0.127: UV4.13 106.54,140.3 v3(106.53,140.29)
  BOTTOM w0.127: v3(106.53,140.29) 106.99,140.74 RV303.2 107.85,140.74 v1(108.28,140.31)
HDMI_EQ: length 7.6
  TOP w0.127: UV4.17 107.03,138.7 106.92,138.58 103.24,138.58 v3(102.72,139.11)
  BOTTOM w0.127: v1(101.74,138.14) 102.01,138.41 RV299.1 v3(102.72,139.11) 103.44,139.11 RV298.2
HDMI_HPLUG: length 23.4
  TOP w0.127: UV4.28 v3(111.07,135.91)
  IN1 w0.099: v3(111.07,135.91) 112.84,135.91 113.2,136.27 113.97,136.27 114.46,136.77 127.32,136.77 128.79,138.24 128.79,140.08 JHDMI1.19
  BOTTOM w0.127: RV41.2 111.02,135.91 v3(111.07,135.91) 111.11,135.96 RV545.1
HDMI_ISET: length 4.2
  TOP w0.127: v3(114.11,139.19) 113.71,138.79 113.2,138.79 113.1,138.7 UV4.34
  BOTTOM w0.127: v3(114.11,139.19) 113.68,139.63 113.18,139.63 RV294.2 RV295.1
HDMI_PD#: length 7.3
  TOP w0.127: UV4.36 113.18,139.5 113.31,139.63 114.33,139.63 114.53,139.42 v1(114.53,137.94) 114.53,137.49 v3(114.1,137.06)
  BOTTOM w0.127: RV546.1 RV545.2 112.99,135.96 v3(114.1,137.06)
HDMI_PRE: length 6.3
  TOP w0.127: UV4.16 107.07,139.1 106.87,138.9 105.97,138.9 v3(105.79,139.08)
  BOTTOM w0.127: RV297.1 RV296.2 103.98,139.55 104.97,139.55 105.06,139.64 v1(105.41,139.64) 105.79,139.26 v3(105.79,139.08)
HP2_D_L1: length 13.5
  TOP w0.203: v3(17.9,10.54) 17.9,10.59 18.53,11.21 UA1.33
  IN4 w0.254: v3(17.9,10.54) 17.9,10.4 17.19,9.69 16.59,9.69 15.41,8.51 12.4,8.51 12,8.9 8.8,8.9 v3(8.31,8.41)
  BOTTOM w0.254: v3(8.31,8.41) 8.63,8.73 CA89.1
HP2_D_L2: length 29.1
  TOP w0.203: UA6.11 27.31,8.22 27.9,7.62 27.9,7.22 v3(28.64,6.48)
  IN6 w0.254: v3(28.64,6.48) 27.96,7.16 24.61,7.16 24.37,6.93 20.47,6.93 17.77,9.63 16.26,9.63 15.28,8.65 9.98,8.65 9.17,7.84 8.02,7.84 v3(7.86,7.99)
  BOTTOM w0.254: RA107.1 7,8.41 7.44,8.41 v3(7.86,7.99) 8.63,7.23 CA89.2
HP2_D_R1: length 8.9
  TOP w0.203: v3(17.32,10.54) 17.32,10.61 17.73,11.01 UA1.31
  IN4 w0.254: v3(17.32,10.54) 16.85,10.07 16.32,10.07 15.23,8.98 12.68,8.98 v3(11.88,9.78)
  BOTTOM w0.254: v3(11.88,9.78) CA90.1
HP2_D_R2: length 25
  TOP w0.203: UA6.9 27.16,7.42 27.23,7.34 27.23,5.98 v3(27.27,5.95)
  IN6 w0.254: v3(10.16,8.13) 10.17,8.14 15.37,8.14 16.47,9.25 17.55,9.25 20.26,6.54 24.53,6.54 24.77,6.78 26.43,6.78 v3(27.27,5.95)
  BOTTOM w0.254: RA108.1 14.02,8.19 CA90.2 10.22,8.19 v3(10.16,8.13)
HP_MIC_LINE_IN_L: length 18.9
  TOP w0.203: v3(24.11,8.42) 24.32,8.22 UA6.2
  TOP w0.254: v3(13.7,15.48) 13.53,15.65 v1(13.53,15.98) 13.53,17.02 13.02,17.53 JIO.32
  IN4 w0.254: v3(24.11,8.42) 22.66,9.87 21.78,9.87 21.45,10.2 20.7,10.2 19.1,11.8 16.38,11.8 13.64,14.53 13.64,15.43 v3(13.7,15.48)
HP_MIC_LINE_IN_R: length 20.6
  TOP w0.203: UA6.3 23.9,7.82 v3(23.75,7.96)
  TOP w0.254: v3(13.75,17.49) 13.38,17.87 v1(13.38,17.86) 13.21,18.03 JIO.31
  IN4 w0.254: v3(23.75,7.96) 22.86,8.85 21.88,8.85 21.54,9.2 21.54,9.53 21.25,9.82 20.54,9.82 18.94,11.42 16.22,11.42 13.21,14.42 13.21,15.7 13.75,16.24 v3(13.75,17.49)
HPOUT-L: length 5.9
  TOP w0.203: UA1.28 15.18,12.6
  TOP w0.254: JIO.36 11.86,15.53 v1(12.57,14.82) 14.78,12.6 15.18,12.6
HPOUT-R: length 6.4
  TOP w0.203: JIO.34 12.03,16.53 12.79,15.76 12.79,15.31 v1(14.65,13.45) 14.86,13.24 15.36,13.24 15.52,13.4 UA1.26
I2C_CLK: length 189
  TOP w0.127: UE3.25 220.99,115.24 221.08,115.16 221.08,115.02 220.51,114.46 220.51,113.97 220.94,113.54 221.16,113.54 v3(221.34,113.36) 221.48,113.5 222.47,113.5 223.09,112.88 223.09,111.84 222.82,111.57 QE16.6 ; CE58.1 260.68,22.61 v3(261.38,23.32) ; v3(308.74,14.47) 308.91,14.64 308.91,15.52 308.71,15.72 308.35,15.72 RM46.2
  IN1 w0.099: v3(244.29,44.05) 244.48,44.23 244.48,45.44 243.88,46.04 242.84,46.04 239.86,49.01 239.38,49.01 238.53,49.86 235.96,49.86 235.42,50.4 235.42,56.67 234.24,57.85 234.24,65.13 234.68,65.56 234.68,69.22 235.42,69.97 235.42,100.09 233.2,102.32 230.1,102.32 224.84,107.57 223.55,107.57 222.7,108.42 222.7,113 222.16,113.54 221.52,113.54 v3(221.34,113.36) ; v3(261.38,23.32) 261.05,23.32 260.87,23.14 260.87,22.89 261.56,22.2 262.14,22.2 264.11,20.23 276.14,20.23 276.33,20.42 281.08,20.42 281.4,20.74 283.02,20.74 285.99,17.77 289.7,17.77 291.23,16.25 296.78,16.25 301.6,11.42 305.31,11.42 307.27,13.38 308.66,13.38 308.93,13.64 308.93,14.28 v3(308.74,14.47)
  IN6 w0.099: v3(261.38,23.32) 261.38,23.57 261.62,23.81 261.62,24.47 259.36,26.74 258.82,26.74 251.25,34.3 246.55,34.3 245.37,35.49 245.37,36.48 244.68,37.16 244.68,40.25 245.81,41.38 245.81,44.12 245.15,44.78 244.71,44.78 244.48,44.55 244.48,44.23 v3(244.29,44.05)
  BOTTOM w0.127: UE1.29 262.24,23.81 261.88,23.81 v3(261.38,23.32) 261.01,23.32 260.69,22.99 RE2.2
I2C_CLK_347: length 337.9
  TOP w0.127: QE16.1 224.93,111.57 RE46.2 225.02,111.44 224.53,110.95 222.11,110.95 v3(221.01,109.85) ; UE4.25 152.98,16.76 153.1,16.88 153.23,16.88 153.39,16.71 153.39,13.87 153.08,13.55 153.08,11.84 152.58,11.35 152.58,11.05 v3(152.41,10.89) ; v3(266.21,14.38) 266.05,14.54 266.05,15.8 268.49,18.24 268.49,25.87 271.06,28.44 273.61,28.44 275.03,29.86 275.03,34.83 v3(275.2,34.99)
  IN1 w0.099: v3(221.01,109.85) 220.84,110.02 220.84,110.74 219.29,112.28 218.05,112.28 217.21,113.12 213.12,113.12 211.29,114.95 211.29,124.61 200.56,135.35 200.32,135.35 195.38,140.29 185.57,140.29 184.23,138.94 183,138.94 v3(182.78,139.16) ; v3(152.41,10.89) 152.53,10.77 152.53,10.77 152.56,10.74 152.56,7.15 152.96,6.75 192.77,6.75 195.99,9.97 196.32,9.97 197.62,11.27 202.99,11.27 205.02,9.24 221.64,9.24 221.82,9.41 251.61,9.41 254.5,12.3 260.25,12.3 261.43,13.48 265.76,13.48 266.04,13.75 266.04,14.2 v3(266.21,14.38)
  IN4 w0.091: v3(275.2,34.99) 275,35.19 275,35.68 274.6,36.07 269.61,36.07 268.69,36.99 261.73,36.99 257.31,41.41 254.59,41.41 242.58,53.42 234.84,53.42 231.21,57.05 231.21,57.7 231.46,57.96 v3(231.72,57.96)
  BOTTOM w0.127: v3(221.01,109.85) 220.84,109.68 220.84,109.22 221.44,108.63 224.09,108.63 229.71,103 232.94,103 235.59,100.35 235.59,69.96 235.04,69.42 235.04,66.32 234.44,65.72 234.44,60.91 231.72,58.19 v3(231.72,57.96) ; v3(182.78,139.16) 182.63,139 UE8.25
I2C_CTL_EN: length 3.4
  TOP w0.203: UV4.8 v3(109.07,142.91)
  BOTTOM w0.127: v3(109.07,142.91) v1(109.07,143.54)
  BOTTOM w0.254: v3(109.07,142.91) 109.3,142.69 RV305.1 108.56,142.25 RV306.2
I2C_DAT: length 188
  TOP w0.127: RM45.2 308.35,15.97 308.82,15.97 309.17,15.63 309.17,14.63 v3(309.32,14.47) ; QE16.3 223.51,112.87 222.61,113.77 221.52,113.77 v3(221.34,113.95) 221.21,113.82 221.02,113.82 220.77,114.07 220.77,114.35 221.34,114.92 221.34,115.51 221.1,115.74 UE3.26
  IN1 w0.099: v3(260.98,23.78) 260.98,23.57 260.65,23.24 260.65,22.79 261.46,21.98 262.05,21.98 264.02,20.01 276.23,20.01 276.42,20.2 281.17,20.2 281.49,20.52 282.93,20.52 285.9,17.54 289.61,17.54 291.13,16.02 296.68,16.02 301.51,11.19 305.4,11.19 307.36,13.15 308.76,13.15 309.16,13.55 309.16,14.31 v3(309.32,14.47) ; v3(221.34,113.95) 221.52,113.77 222.25,113.77 222.93,113.1 222.93,108.51 223.64,107.8 224.94,107.8 230.19,102.54 233.29,102.54 235.65,100.18 235.65,69.88 234.9,69.13 234.9,65.47 234.47,65.04 234.47,57.94 235.65,56.76 235.65,50.5 236.06,50.09 238.62,50.09 239.48,49.24 239.96,49.24 242.93,46.27 243.97,46.27 244.7,45.54 244.7,44.22 v3(244.88,44.05)
  IN6 w0.099: v3(244.88,44.05) 244.71,44.22 244.71,44.45 244.81,44.55 245.06,44.55 245.58,44.03 245.58,41.47 244.45,40.34 244.45,37.07 245.14,36.38 245.14,35.39 246.45,34.08 251.15,34.08 258.72,26.51 259.27,26.51 261.4,24.38 261.4,23.93 261.24,23.78 v3(260.98,23.78)
  BOTTOM w0.127: RE1.2 260.59,23.26 260.98,23.66 v3(260.98,23.78) 261.45,23.78 261.58,23.91 261.58,24.29 UE1.30
I2C_DAT_347: length 335.5
  TOP w0.127: v3(153,10.89) 152.83,11.05 152.83,11.24 153.33,11.74 153.33,13.45 153.65,13.77 153.65,16.82 153.33,17.13 153.1,17.13 152.98,17.26 UE4.26 ; v3(265.63,14.38) 265.8,14.55 265.8,15.91 268.24,18.34 268.24,25.98 270.95,28.69 273.51,28.69 274.78,29.97 274.78,34.83 v3(274.61,34.99) ; v3(220.43,109.85) 220.35,109.92 220.35,111.43 RE47.2 221.13,112.22 221.41,112.22 221.78,112.59 221.78,112.78 221.87,112.87 QE16.4
  IN1 w0.099: v3(265.63,14.38) 265.81,14.2 265.81,13.84 265.67,13.7 261.34,13.7 260.16,12.52 254.4,12.52 251.52,9.64 221.72,9.64 221.55,9.46 205.11,9.46 203.08,11.49 197.52,11.49 196.23,10.2 195.9,10.2 192.67,6.97 153.05,6.97 152.78,7.24 152.78,10.67 v3(153,10.89) ; v3(182.78,138.57) 182.92,138.71 184.32,138.71 185.67,140.06 195.29,140.06 200.23,135.12 200.47,135.12 211.07,124.52 211.07,114.86 213.03,112.89 217.12,112.89 217.95,112.06 219.2,112.06 220.61,110.64 220.61,110.03 v3(220.43,109.85)
  IN4 w0.091: v3(231.31,58.37) 231.31,58.11 230.99,57.79 230.99,56.96 234.75,53.2 242.49,53.2 254.5,41.19 257.22,41.19 261.63,36.77 268.6,36.77 269.52,35.85 274.51,35.85 274.78,35.59 274.78,35.15 v3(274.61,34.99)
  BOTTOM w0.127: v3(220.43,109.85) 220.59,109.68 220.59,109.11 221.33,108.37 223.98,108.37 229.61,102.75 232.83,102.75 235.33,100.24 235.33,70.07 234.79,69.52 234.79,66.43 234.19,65.83 234.19,61.02 231.54,58.37 v3(231.31,58.37) ; v3(182.78,138.57) 182.71,138.5 UE8.26
I2CC_SCL: length 25.3
  TOP w0.127: UV20.6 158.25,37.56 158.05,37.37 v1(157.7,37.37) v3(157.01,37.37)
  BOTTOM w0.127: QV89.3 161.05,54.56 161.19,54.7 161.58,54.7 161.76,54.52 161.76,54.17 RV551.2 162.75,53.18 162.75,50.98 162.5,50.73 159.53,50.73 158.74,49.94 158.74,47.87 157.22,46.34 157.22,37.57 v3(157.01,37.37)
I2CC_SCL_R: length 27
  IN1 w0.099: v3(159.58,54.87) 159.58,52.31 159.84,52.05 v3(161.63,52.05)
  BOTTOM w0.127: QV89.4 161.05,51.45 161.2,51.3 161.76,51.3 RV548.2 162.05,52.05 v3(161.63,52.05) ; v3(159.58,54.87) 159.58,55.76 159.25,56.1 157.44,57.9 v1(157.44,58.45) 157.44,61.14 157.9,61.6 157.9,61.95 160.27,64.31 163.02,64.31 165.19,66.49 165.19,67.99 UV1.BD2
I2CC_SDA: length 20.7
  TOP w0.127: UV20.7 156.85,36.91 v3(156.4,37.37) 156.4,38.36 v1(156.57,38.52)
  BOTTOM w0.127: v3(156.4,37.37) 156.89,37.85 156.89,46.38 158.43,47.93 158.43,51.04 RV552.2 159.16,51.35 159.29,51.22 159.59,51.22 159.75,51.38 QV89.6
I2CC_SDA_R: length 21.6
  BOTTOM w0.127: QV89.1 159.75,53.15 159.67,53.06 159.48,53.06 158.69,53.85 RV547.2 159.16,54.79 159.16,55.81 157.09,57.88 v1(157.09,60.48) 157.09,61.15 157.65,61.71 157.65,62.05 160.17,64.57 162.87,64.57 164.8,66.5 UV1.BD1
ICLK_IREF: length 6.1
  BOTTOM w0.254: UH1.AM45 217.41,48.59 217.59,48.77 217.59,49.32 v1(217.4,49.51) 216.99,49.91 215.18,49.91 214.31,50.78 RH91.2
IMON: length 5.4
  TOP w0.127: v1(139.69,131.89) 139.69,129.97 PC500.2
  TOP w0.254: v3(139.51,128.91) 139.51,128.91 139.51,129.36 139.9,129.75 PC500.2 140.55,129.11 PR521.1
  BOTTOM w0.203: 138.75,128 139.51,128.76 139.51,128.9 v3(139.51,128.91)
IMVP_PWRGD: length 311.8
  TOP w0.127: v3(209.09,21.43) 209.4,21.43 211.05,19.78 212.79,19.78 214.06,21.05 UH2.2 ; v3(85.79,95.85) 87.76,97.82 87.76,109 v2(91.91,113.16) 98.4,119.65 v3(98.5,119.65)
  IN1 w0.099: v3(85.79,95.85) 85.79,94.79 73.6,82.61 73.6,65.42 70,61.81 70,54.43 71.76,52.67 71.76,44.21 72.11,43.86 72.11,31.18 v3(71.82,30.89)
  IN4 w0.091: v3(141.16,130.85) 140.7,130.39 133.61,130.39 132.97,129.76 107.01,129.76 101.18,123.93 101.18,120.42 100.41,119.65 v3(98.5,119.65)
  IN6 w0.099: v3(71.82,30.89) 71.82,29.15 73.39,27.59 74.79,27.59 77.72,24.66 79.51,24.66 80.05,24.12 80.05,18.39 81.24,17.2 140.93,17.2 142.16,18.43 152.38,18.43 153.1,17.72 154.48,17.72 155.97,16.23 159.76,16.23 160.34,15.65 165.5,15.65 166.33,16.48 169.09,16.48 171.14,18.53 174.91,18.53 175.27,18.16 183.04,18.16 183.68,18.81 191.03,18.81 191.35,19.13 191.91,19.13 193.21,20.42 199.01,20.42 199.91,21.33 201.66,21.33 202.24,21.91 208.61,21.91 v3(209.09,21.43)
  BOTTOM w0.127: v3(141.16,130.85) 140.54,130.23 PR522.1 139.96,130.1 139.93,130.08 PR519.1
IMVP_VR_ON: length 264.8
  TOP w0.127: UE5.121 293.63,23.05 v3(294.05,22.63) 294.06,22.62 294.18,22.62 294.64,23.07 DE2.3 294.64,24.1 CE38.1 RE72.2 295.14,26.19 v1(295.66,26.71)
  IN2 w0.099: v3(139.07,132.45) 144.08,137.47 149.16,137.47 150.37,138.67 150.37,140.15 151.76,141.54 153.36,141.54 153.96,142.14 157.9,142.14 158.56,141.48 160.86,141.48 162.14,140.2 164.59,140.2 166.78,142.39 166.78,144.27 170.35,147.84 186.51,147.84 189.89,144.46 189.89,143.91 193.62,140.18 194.12,140.18 194.41,139.89 195.49,139.89 200.13,135.24 200.68,135.24 202.7,133.22 202.7,132.37 207.91,127.16 218.06,127.16 220.84,124.38 220.84,121.88 222.82,119.89 222.82,107.7 229,101.51 230.83,101.51 232.05,100.29 233.64,100.29 v3(233.91,100.56)
  IN6 w0.099: v3(294.05,22.63) 292.71,23.97 284.74,23.97 283.4,25.3 274.46,25.3 266.34,33.42 264.62,33.42 253.01,45.02 251.82,45.02 242.01,54.84 236.12,54.84 232.53,58.43 232.53,63.74 233.89,65.1 233.89,66.26 234.24,66.6 234.24,70.79 234.91,71.46 234.91,97.33 233.19,99.06 233.19,99.84 v3(233.91,100.56)
  BOTTOM w0.254: PR511.1 139.07,131.56 v3(139.07,132.45)
INTRUDER#: length 9
  BOTTOM w0.089: 231.59,30 231.59,30.32 231.48,30.42 231.48,31.57 230.76,32.29 UH1.A8
  BOTTOM w0.127: 231.59,30 231.59,29.8 RH12.2 234.53,26.85 v1(236.13,26.85)
ISEN1: length 16.6
  TOP w0.254: v3(140.12,124.23) 140.35,124.23 140.91,123.66
  IN1 w0.254: v3(143.77,120.93) 143.32,120.93 141.8,122.46 141.8,122.55 v3(140.12,124.23)
  BOTTOM w0.203: PU500.12 139.9,124.25
  BOTTOM w0.254: PR555.1 145.19,124.31 145.72,123.78 v1(145.72,121.87) 144.93,121.08 143.92,121.08 v3(143.77,120.93) 143.77,120.19 143.36,119.79 141.97,119.79 PR557.1 ; PC539.2 140.5,123.85 v3(140.12,124.23) 140.1,124.25 139.9,124.25
ISEN2: length 20.4
  TOP w0.127: v3(144.97,122.26) v1(144.97,121.58)
  TOP w0.254: v3(144.74,126.48) 144.27,126.01 144.27,125.22 144.46,125.03 PR538.2 144.43,124.53 140.71,124.53 v3(140.54,124.69)
  IN1 w0.254: v3(144.74,126.48) 144.08,125.82 144.08,123.15 v3(144.97,122.26) 144.97,121.38 142.9,119.31 v3(141.92,119.31)
  BOTTOM w0.203: v3(140.54,124.69) 140.48,124.75 139.96,124.75 PU500.11
  BOTTOM w0.254: v3(141.92,119.31) 141.88,119.35 PR547.1 ; v3(140.54,124.69) 140.9,124.33 141.11,124.33 ; PR546.1 144.97,122.89 v3(144.97,122.26)
ISEN3: length 14.7
  TOP w0.254: PR510.1 141.41,119.81 144.06,119.81 v1(144.08,119.79) 144.11,119.81 144.13,119.81 144.49,120.17 v3(144.49,121.88)
  IN1 w0.254: v3(144.49,121.88) 144.19,121.88 140.91,125.17 140.56,125.17 v3(140.46,125.27)
  BOTTOM w0.203: PC544.2 141.41,125.27 v3(140.46,125.27) 140.01,125.27 PU500.10
  BOTTOM w0.254: PR516.2 144.49,122.14 v3(144.49,121.88) ; PR518.2 142,125.34 142,125.25 PC544.2
IST_TRIGGER: length 1.2
  TOP w0.089: v3(95.49,90.01) 95.87,90.39 T63.1
  BOTTOM w0.089: v3(95.49,90.01) CPU1.W49
ISUMN: length 31.5
  TOP w0.254: v3(141.61,121.82) 141.73,121.95 141.73,122.46 141.42,122.77 140.53,122.77 140.13,123.17 139.62,123.17 139.22,123.57 139.22,123.69 PC547.1 137.27,124.41 PR549.1
  IN6 w0.254: v3(141.61,121.82) 140.91,121.12 138.85,121.12 137.35,119.63 137.35,118.39 133.42,114.45 133.03,114.45 v3(132.97,114.52)
  BOTTOM w0.254: 142.34,121.78 142.31,121.82 v3(141.61,121.82) 141.52,121.73 141.04,121.73 PR535.2 140.53,121.2 PR545.1 139.34,120 PR515.1 138.69,120.57 PC528.1 ; 142.34,121.78 142.34,123.05 PR556.2 ; 142.34,121.78 PR548.1 ; PR556.2 142.69,123.42 142.69,123.46 PR544.2 142.64,124 142.64,124.05 PC544.1 ; PR556.2 141.97,123.43 141.97,123.48 PC540.1 PC539.1 ; v3(132.97,114.52) 132.87,114.42 v1(131.36,114.42) 129.85,114.42 PH501.1
ISUMP: length 21.2
  TOP w0.127: PR514.1 141.25,120.84 141.43,120.66 142.58,120.66 v1(142.61,120.69)
  TOP w0.254: PR552.1 143.98,123.32 PR536.1 144.78,123.32 v3(145.14,123.68) ; PR551.2 140.01,122.29 PC538.2 ; PR549.2 138.44,123.71 v3(138.72,123.43) 138.62,123.33 PC529.2 138.63,122.59 PC538.2 ; PC538.2 140.37,120.84 PR514.1
  IN6 w0.254: v3(138.72,123.43) 139.31,122.84 144.29,122.84 v3(145.14,123.68)
  BOTTOM w0.203: v3(138.72,123.43) 138.72,123.74 PU500.15
  BOTTOM w0.254: v3(138.72,123.43) 138.72,122.68 138.03,121.99 138.03,121.26 PC528.2 138.04,121.24 PR558.2
IVR_ERROR: length 1.4
  TOP w0.089: v3(96.41,81.83) 95.98,82.26 T62.1
  BOTTOM w0.089: v3(96.41,81.83) 96.07,81.5 CPU1.AM49
JACK1_PLUG: length 50.9
  TOP w0.254: v3(10.47,16.25) 10.47,16.39 10.17,16.69 9.63,16.69 9.49,16.55 9.09,16.55 8.63,17 7.92,17 6.64,18.28 4.87,18.28 3.43,16.83 3.43,15.58 3.03,15.18 3.03,14.01 2.38,13.37 2.38,11.88 2.88,11.37 2.88,10.73 v1(1.93,9.78) 1.93,9.02 2.02,8.93 2.02,7.76 1.73,7.47 1.73,6.64 2.1,6.28 v3(2.69,6.28) ; v3(12.63,33.68) 12.42,33.48 12.19,33.48 11.74,33.03 JIO.1 ; RA93.1 6.65,8.01 v3(5.88,7.24)
  IN1 w0.254: v3(12.63,33.68) 12.63,33.42 11.86,32.65 11.86,26.41 13.24,25.03 13.24,19.85 12.71,19.33 12.71,18.49 v3(10.47,16.25)
  IN4 w0.254: v3(2.69,6.28) 5.26,6.28 5.88,6.9 v3(5.88,7.24)
  BOTTOM w0.254: QA3.2 11.9,15.85 11.51,16.25 v3(10.47,16.25) 10.34,16.12 QA14.2 ; RA138.2 2.75,6.23 v3(2.69,6.28)
JACK1_PLUG#: length 16.4
  TOP w0.254: RA46.1 24.16,10.87 23.31,10.87 22.68,11.5 v3(22.68,11.89)
  IN2 w0.254: v3(14.24,17.12) 13.21,16.1 13.21,14.95 16.04,12.12 22.46,12.12 v3(22.68,11.89)
  BOTTOM w0.254: QA3.1 14.2,17.08 v3(14.24,17.12)
JACK1_PLUG_C: length 15.1
  IN4 w0.254: v3(4.22,6.86) 4.85,7.5 4.85,9.21 7.96,12.32 v3(8.04,12.32)
  BOTTOM w0.254: QA14.3 10.99,14.68 10.7,14.38 9.82,14.38 9.39,13.95 RA115.2 8.04,13.34 v3(8.04,12.32) ; UA3.5 4.44,7.08 v3(4.22,6.86) RA138.1 4.94,6.23 CA81.1
JACK2_PLUG#: length 20.2
  TOP w0.254: JIO.33 12.25,17.03 v1(12.49,16.79) v3(13.04,16.79) ; v3(25.87,11.85) 25.87,12.32 RA47.1 RA49.1
  IN2 w0.254: v3(25.87,11.85) 25.43,11.41 22.28,11.41 21.95,11.74 15.86,11.74 12.78,14.82 12.78,16.53 v3(13.04,16.79)
JRTC1: length 3.1
  BOTTOM w0.127: v1(262.37,15.85) PR2.1
  BOTTOM w0.254: PD5.2 260.51,16.39 PR2.1
KB_DET#: length 176.8
  TOP w0.127: v3(93.88,13.41) v2(93.14,13.41)
  IN1 w0.099: v3(228.73,34.69) 228.73,34.64 232.48,30.89 235.94,30.89 237.1,29.73 238.77,29.73 v3(239.14,29.36)
  IN6 w0.099: v3(228.73,34.69) 229.49,33.93 229.49,32.9 229.87,32.51 229.87,29.94 229.49,29.55 227.59,29.55 226.82,28.79 226.82,27.59 226.05,26.81 226.05,26.44 224.09,24.47 219.62,24.47 216.55,21.4 216.07,21.4 214.72,20.05 212.69,20.05 211.41,18.77 206.59,18.77 205.78,17.96 200.48,17.96 200.15,17.63 194.75,17.63 193.55,16.44 193.09,16.44 190.51,13.86 183.29,13.86 182.63,14.53 179.72,14.53 179.59,14.65 169.81,14.65 169.44,14.28 167.98,14.28 167.38,13.68 158.52,13.68 157.75,14.46 154.67,14.46 152.54,16.59 148.52,16.59 147.79,17.31 142.53,17.31 140.65,15.43 120.82,15.43 120.47,15.08 95.54,15.08 v3(93.88,13.41)
  BOTTOM w0.089: UH1.D13 229.04,34.38 v3(228.73,34.69)
  BOTTOM w0.127: v3(93.88,13.41) 95.96,13.41 96.85,12.53 JKB1.30 ; v3(239.14,29.36) 239.59,29.81 239.59,30.75 RH133.1 RH131.1
KB_LED_B1_DRV: length 8.3
  TOP w0.127: Q30.2 135.7,14.9 135.56,14.76 135.19,14.76 135.05,14.9 Q30.3 135.05,16.3 134.69,16.66 131.07,16.66 v1(131.02,16.61) 130.69,16.28 R156.2
KB_LED_B1_DRV#: length 25.6
  TOP w0.127: Q30.5 135.7,13.24 v3(135.31,12.84) 135.31,12.59 135,12.28 134.41,12.28 R158.2 ; v3(145.85,21) 145.94,21.09 145.94,21.57 146.88,22.51 147.27,22.51 147.33,22.57 149.17,22.57 v1(149.51,22.22) 149.74,21.99 UE4.5
  IN2 w0.099: v3(135.31,12.84) 135.84,12.31 140.71,12.31 v3(141.14,12.74)
  BOTTOM w0.127: v3(141.14,12.74) 141.3,12.91 141.3,14.26 143,15.95 143.91,15.95 145.85,17.89 v3(145.85,21)
KB_LED_B1_DRV#_A#: length 3.2
  TOP w0.127: v2(136.03,12.04) 135.94,12.14 v3(135.94,12.84) 136.35,13.26 Q30.6
  BOTTOM w0.127: JKBBL1.5 135.25,12.15 v3(135.94,12.84)
KB_LED_B2_DRV: length 3.8
  TOP w0.127: Q33.2 124.34,11.74 124.18,11.89 123.8,11.89 123.69,11.77 Q33.3 123.02,11.45 R168.2 122.24,11.79 v1(121.6,12.42)
KB_LED_B2_DRV#: length 34.4
  TOP w0.127: v3(124.55,10.26) 124.55,10.09 124.34,9.87 Q33.5 124.34,9.21 124.17,9.04 123.37,9.04 123.32,9.1 R170.2 ; UE4.9 146.96,20.26 145.66,18.95 145.66,15.95 v1(144.25,14.54) 143.55,13.84 v3(143.55,10.5)
  IN2 w0.099: v3(124.55,10.26) 125.46,9.36 142.4,9.36 v3(143.55,10.5)
KB_LED_B2_DRV#_A#: length 13.2
  TOP w0.127: Q33.6 124.99,9.27 125.16,9.1 v2(126.29,9.1) 126.77,9.1 128.68,11 130.56,11 131.35,10.22 131.35,9.69 131.8,9.23 133.09,9.23 133.97,10.12 v3(133.97,10.32)
  BOTTOM w0.127: v3(133.97,10.32) 133.75,10.09 JKBBL1.8
KB_LED_B3_DRV: length 4.2
  TOP w0.127: R157.2 124.2,15.58 124.84,15.58 124.96,15.47 Q36.3 124.96,14.94 125.1,14.8 125.43,14.8 125.61,14.98 Q36.2 125.61,16.18 v1(125.26,16.52)
KB_LED_B3_DRV#: length 32.2
  TOP w0.127: 125.72,12.41 126.01,12.41 126.91,11.51 130.78,11.51 131.11,11.18 132.38,11.18 v3(133.24,10.32) ; 125.72,12.41 v1(125.15,12.41) 124.91,12.65 R159.2 ; 125.72,12.41 125.72,12.71 125.61,12.83 Q36.5 ; v3(144.36,10.57) 144.52,10.72 144.52,11.27 144.76,11.52 144.76,12.75 146.42,14.41 146.42,17.36 146.81,17.76 UE4.14
  IN2 w0.099: v3(133.24,10.32) 133.95,9.61 142.08,9.61 143.4,10.92 143.7,10.92 144.06,10.57 v3(144.36,10.57)
KB_LED_B3_DRV#_A#: length 10.3
  TOP w0.127: v3(133.05,12.83) 133.05,12.54 132.08,11.57 v2(131.27,11.57) 131.08,11.76 127.21,11.76 126.26,12.71 Q36.6
  BOTTOM w0.127: JKBBL1.11 132.25,12.29 132.39,12.42 132.64,12.42 v3(133.05,12.83)
KB_LED_B4_DRV: length 3.7
  TOP w0.127: v1(111.62,11.29) 111.99,11.66 R169.2 112.79,11.45 Q39.3 113.59,11.1 113.74,10.95 114.1,10.95 114.24,11.09 114.24,11.45
KB_LED_B4_DRV#: length 46.8
  TOP w0.127: v3(145.44,11.56) 145.48,11.6 146.36,11.6 148.24,13.48 v1(148.24,14.16) UE4.17 ; 114.24,9.56 114.24,9.13 114.07,8.97 R171.2 111.88,8.97 111.33,9.51 v3(111.33,10.15)
  IN2 w0.099: v3(145.44,11.56) 145.44,10.35 144.96,9.88 144,9.88 142.98,8.86 112.62,8.86 v3(111.33,10.15)
KB_LED_B4_DRV#_A#: length 18.4
  TOP w0.127: v3(130.04,10.3) 128.95,10.3 v2(128.08,9.43) 127.27,8.61 115.17,8.61 114.89,8.89 Q39.6
  BOTTOM w0.127: JKBBL1.14 130.75,9.78 130.65,9.88 130.45,9.88 v3(130.04,10.3)
KB_LED_B5_DRV: length 4.2
  TOP w0.127: v1(84.51,11.51) R173.2 83.76,12.92 83.52,12.68 Q2413.3 83.52,12.09 83.38,11.95 83.01,11.95 82.87,12.09 Q2413.2
KB_LED_B5_DRV#: length 242.7
  TOP w0.127: v3(74.93,49.48) v1(74.93,48.74)
  IN4 w0.091: v3(174.67,136.9) 174.87,137.1 174.87,137.73 174.17,138.43 171.16,138.43 169.96,139.63 157.34,139.63 156.61,140.35 152.05,140.35 149.53,137.84 143.77,137.84 142.75,138.85 139.26,138.85 137.72,137.31 133.53,137.31 132.5,136.28 130.23,136.28 126.07,132.11 104.97,132.11 97.27,124.4 97.27,123.3 94.99,121.02 91.14,121.02 89.47,119.36 87.46,119.36 85.81,117.7 85.81,98.59 84.27,97.05 84.27,92.93 74.3,82.96 74.3,63.59 77.15,60.73 77.15,55.84 75.88,54.57 75.88,50.43 v3(74.93,49.48)
  BOTTOM w0.127: UE8.17 177.68,139.38 177.59,139.28 177.42,139.28 177.37,139.33 176.44,139.33 174.86,137.75 174.86,137.09 v3(174.67,136.9) ; JKB3.2 56.15,12.71 55.74,13.12 55.74,14.1 56.62,14.98 70.14,14.98 70.89,14.23 72.61,14.23 75.82,17.44 75.82,19.03 74.79,20.06 74.79,23.84 76.99,26.04 76.99,29.45 77.87,30.33 77.87,31.86 76.57,33.16 76.3,33.16 75.52,33.94 75.52,42.55 74.21,43.87 74.21,48.76 v3(74.93,49.48)
KB_LED_G1_DRV: length 4.2
  TOP w0.127: R150.2 140.71,12.03 141.42,12.03 141.53,11.92 Q29.3 141.53,11.22 141.67,11.08 142.05,11.08 142.18,11.2 Q29.2 142.18,12.12 v1(142.58,12.52)
KB_LED_G1_DRV#: length 22.1
  TOP w0.127: UE4.4 150.24,21.99 149.34,22.89 147.3,22.89 147.19,22.77 146.78,22.77 v1(145.57,21.56) 145.4,21.39 145.4,16.26 143.23,14.09 143.23,10.78 142.49,10.04 142.25,10.04 142.18,9.96 Q29.5 142.18,9.35 141.92,9.1 R154.2
KB_LED_G1_DRV#_A#: length 10.8
  TOP w0.127: v3(135.52,10.34) 135.66,10.2 v2(135.66,9.27) 136.32,8.61 142.38,8.61 142.83,9.06 Q29.6
  BOTTOM w0.127: JKBBL1.4 135.75,10.11 v3(135.52,10.34)
KB_LED_G2_DRV: length 4.5
  TOP w0.127: Q32.3 131.69,15.53 131.84,15.69 132.18,15.69 132.34,15.53 Q32.2 132.34,15.05 132.55,14.84 133.47,14.84 R164.2 133.42,16 v1(133.42,16.28)
KB_LED_G2_DRV#: length 27
  TOP w0.127: Q32.5 132.34,13.32 131.85,12.84 v3(131.57,12.84) 131.38,12.65 R166.2 ; UE4.8 148.24,20.69 148.12,20.58 147.11,20.58 v3(146.69,21) ; v3(141.98,13.16) 141.65,13.49 v1(141.65,13.6)
  IN2 w0.099: v3(141.98,13.16) 141.98,12.93 141.13,12.09 132.33,12.09 v3(131.57,12.84)
  BOTTOM w0.127: v3(146.69,21) 146.69,17.97 145.51,16.79 145.51,15.93 144.85,15.27 143.03,15.27 141.98,14.21 v3(141.98,13.16)
KB_LED_G2_DRV#_A#: length 6.4
  TOP w0.127: v2(133.02,11.86) 133.54,12.38 133.54,13.29 133.3,13.53 Q32.6 132.99,13.96 v3(133.35,14.33)
  BOTTOM w0.127: v3(133.35,14.33) 134.25,13.43 JKBBL1.7
KB_LED_G3_DRV: length 4.2
  TOP w0.127: v1(119.43,13.1) 119.32,12.98 R151.2 119.51,11.98 120.13,11.98 120.32,11.79 Q35.3 120.32,11.17 120.49,11 120.83,11 120.97,11.14 Q35.2
KB_LED_G3_DRV#: length 37.3
  TOP w0.127: v3(144.1,11.1) 144.1,11.25 144.5,11.66 v1(144.5,13.01) 144.5,13.17 146.16,14.83 146.16,18.74 146.68,19.26 UE4.11 ; v3(120.58,10.38) 120.58,10.17 120.97,9.78 Q35.5 120.97,9.13 120.75,8.92 119.5,8.92 R155.2
  IN2 w0.099: v3(120.58,10.38) 121.47,11.27 131.9,11.27 132.16,11.01 142.52,11.01 142.66,11.15 144.05,11.15 v3(144.1,11.1)
KB_LED_G3_DRV#_A#: length 15.2
  TOP w0.127: v3(132.5,10.29) 132.5,10.15 v2(131.99,9.64) ; Q35.6 121.62,9.78 121.16,10.24 v3(121.16,10.38)
  IN2 w0.122: v3(121.16,10.38) 121.81,11.03 131.76,11.03 v3(132.5,10.29)
  BOTTOM w0.127: v3(132.5,10.29) 132.75,10.04 JKBBL1.10
KB_LED_G4_DRV: length 4.2
  TOP w0.127: R165.2 120.83,15.58 121.45,15.58 121.59,15.45 Q38.3 121.59,14.96 121.77,14.78 122.07,14.78 122.24,14.95 Q38.2 122.24,15.58 121.88,15.94 v1(121.88,16.54)
KB_LED_G4_DRV#: length 36.2
  TOP w0.127: UE4.16 147.07,16.76 146.93,16.61 146.93,12.84 v1(146.5,12.41) v3(146.14,12.05) ; v3(119.75,12.65) R167.2 121.02,12.65 121.16,12.79 122,12.79 122.24,13.03 Q38.5
  IN2 w0.099: v3(146.14,12.05) 145.33,12.87 144.81,12.87 143.68,14 140.3,14 139.96,13.66 128.15,13.66 127.15,12.65 v3(119.75,12.65)
KB_LED_G4_DRV#_A#: length 12.1
  TOP w0.127: v3(131.85,10.26) 131.66,10.26 130.67,11.25 126.56,11.25 v2(126.49,11.32) 125.76,12.05 124.92,12.05 124.77,12.21 123.5,12.21 122.89,12.81 Q38.6
  BOTTOM w0.127: JKBBL1.13 131.25,10.87 v3(131.85,10.26)
KB_LED_G5_DRV: length 4.5
  TOP w0.127: R153.2 78.53,12.63 78.53,11.97 v1(78.6,11.9) 78.67,11.83 80.19,11.83 80.46,12.09 ; Q2412.3 81.11,12.09 80.92,11.9 80.65,11.9 80.46,12.09 ; 80.46,12.09 80.46,12.41
KB_LED_G5_DRV#: length 243
  TOP w0.127: v1(75.25,51.23) 74.93,50.92 v3(74.93,50.7)
  IN4 w0.091: v3(175.28,137.35) 175.28,137.69 174.32,138.66 171.25,138.66 170.05,139.85 157.43,139.85 156.71,140.57 151.89,140.57 149.37,138.05 143.99,138.05 142.95,139.1 139.2,139.1 137.63,137.53 133.4,137.53 132.36,136.49 130.14,136.49 125.98,132.33 104.84,132.33 97.05,124.54 97.05,123.39 94.9,121.24 91.01,121.24 89.37,119.61 87.36,119.61 85.59,117.84 85.59,98.72 84.02,97.15 84.02,93.04 74.05,83.07 74.05,63.49 76.91,60.63 76.91,55.95 75.64,54.68 75.64,51.4 v3(74.93,50.7)
  BOTTOM w0.127: JKB3.3 55.65,10.17 55.86,10.38 58.1,10.38 58.42,10.7 58.42,12.98 59.93,14.49 70.06,14.49 70.63,13.92 72.66,13.92 76.14,17.4 76.14,19.09 75.06,20.17 75.06,23.71 77.26,25.91 77.26,29.35 78.12,30.22 78.12,31.97 76.66,33.43 76.39,33.43 75.78,34.04 75.78,42.68 74.5,43.96 74.5,48.05 75.36,48.91 75.36,50.27 v3(74.93,50.7) ; v3(175.28,137.35) 175.53,137.6 175.53,138.06 176.47,139 UE8.16
KB_LED_R1_DRV: length 4.1
  TOP w0.127: R144.2 137.72,15.65 138.31,15.65 138.42,15.54 Q28.3 138.42,15.05 138.58,14.89 138.88,14.89 139.07,15.08 Q28.2 139.07,15.79 138.81,16.04 v1(138.81,16.64)
KB_LED_R1_DRV#: length 24.8
  TOP w0.127: R146.2 137.42,12.74 137.92,13.25 137.92,13.76 138.17,14 138.6,14 138.74,13.86 138.95,13.86 139.07,13.74 Q28.5 139.07,12.72 v3(139.07,12.73) ; v3(145.61,22.19) 146.45,23.03 147.08,23.03 147.29,23.23 v1(148.36,23.23) 149.45,23.23 150.74,21.94 UE4.3
  BOTTOM w0.127: v3(139.07,12.73) 139.54,12.26 140.44,12.26 140.72,12.54 140.72,12.97 141.05,13.3 141.05,14.37 142.89,16.21 143.81,16.21 145.42,17.82 145.42,22 v3(145.61,22.19)
KB_LED_R1_DRV#_A#: length 9.4
  TOP w0.127: v2(140.92,15.18) 140.92,14.98 139.72,13.77 139.72,13.75 ; 139.72,13.75 139.58,13.9 139.31,13.9 v3(138.88,14.33) ; 139.72,13.75 Q28.6
  IN6 w0.099: v3(138.88,14.33) 138.47,13.92 136.42,13.92 v3(136.02,14.32)
  BOTTOM w0.127: v3(136.02,14.32) 136.36,13.98 136.36,12.54 136.25,12.42 JKBBL1.3
KB_LED_R2_DRV: length 7.1
  TOP w0.127: R160.2 138.67,10.95 138.21,10.95 137.8,11.36 Q31.2 137.8,12.03 137.7,12.13 137.26,12.13 137.15,12.01 Q31.3 137.15,11.2 137,11.05 v2(134.58,11.05)
KB_LED_R2_DRV#: length 29.5
  TOP w0.127: UE4.6 149.24,21.89 148.81,22.31 147.44,22.31 147.32,22.19 146.92,22.19 146.27,21.54 v3(146.27,20.45) 146.27,20.2 v1(145.85,19.78) ; Q31.5 137.8,10.32 v3(137.74,10.38) 138.61,10.38 138.89,10.1 138.89,9.32 139.12,9.1 R162.2
  BOTTOM w0.127: v3(146.27,20.45) 146.27,17.91 145.25,16.9 145.25,16.03 144.74,15.52 142.92,15.52 141.56,14.15 141.56,12.51 141.04,11.99 140.12,11.99 139.97,11.84 139.97,8.75 139.85,8.64 138,8.64 137.74,8.9 v3(137.74,10.38)
KB_LED_R2_DRV#_A#: length 8.5
  TOP w0.127: v2(133.87,9.3) 133.87,9.48 v3(134.74,10.34) 135.18,10.78 135.71,10.78 135.99,10.5 135.99,9.58 136.62,8.96 138.14,8.96 138.45,9.26 Q31.6
  BOTTOM w0.127: JKBBL1.6 134.75,10.33 v3(134.74,10.34)
KB_LED_R3_DRV: length 4.2
  TOP w0.127: R145.2 127.69,15.71 128.16,15.71 128.32,15.55 Q34.3 128.32,14.99 128.5,14.81 128.78,14.81 128.97,15 128.97,15.71 v1(128.34,16.35)
KB_LED_R3_DRV#: length 28
  TOP w0.127: 128.97,13.37 128.97,12.94 v3(128.72,12.69) 128.41,12.38 127.59,12.38 R147.2 ; UE4.10 146.82,19.76 145.91,18.84 145.91,15.61 v1(145.61,15.31) 144.09,13.78 v3(144.09,12.02)
  IN2 w0.099: v3(128.72,12.69) 129.35,12.05 131.8,12.05 132.36,11.49 141.74,11.49 142.27,12.02 v3(144.09,12.02)
KB_LED_R3_DRV#_A#: length 7.8
  TOP w0.127: v3(132.46,12.84) 131.78,12.16 v2(129.47,12.16) 129.39,12.23 129.39,12.68 129.62,12.91 Q34.6
  BOTTOM w0.127: v3(132.46,12.84) 132.46,13.2 132.6,13.34 133.29,13.34 133.47,13.16 133.47,12.61 133.25,12.4 JKBBL1.9
KB_LED_R4_DRV: length 4.1
  TOP w0.127: Q37.2 117.6,11.17 117.45,11.01 117.11,11.01 116.95,11.17 Q37.3 116.95,11.79 116.72,12.03 116.19,12.03 R161.2 115.66,11.79 v1(115.01,12.44)
KB_LED_R4_DRV#: length 39.8
  TOP w0.127: v3(144.96,11.12) 145.01,11.18 145.01,12.27 v1(146.46,13.72) 146.67,13.93 146.67,16.95 146.98,17.26 UE4.15 ; R163.2 116.13,8.92 117.34,8.92 117.6,9.18 Q37.5 117.6,10.19 v3(117.44,10.35)
  IN2 w0.099: v3(117.44,10.35) 118.68,9.11 142.88,9.11 143.89,10.12 144.68,10.12 144.96,10.4 v3(144.96,11.12)
KB_LED_R4_DRV#_A#: length 17.9
  TOP w0.127: v3(118.05,10.37) 118.05,10.11 118.25,9.91 Q37.6 ; v2(130.19,9.43) 130.66,9.9 v3(130.66,10.3)
  IN2 w0.122: v3(130.66,10.3) 130.18,10.78 123.18,10.78 121.76,9.36 119.06,9.36 v3(118.05,10.37)
  BOTTOM w0.127: JKBBL1.12 131.75,9.75 131.19,10.3 v3(130.66,10.3)
KB_LED_R5_DRV: length 4.5
  TOP w0.127: R149.2 v1(87.96,11.91) 88.1,11.77 89.47,11.77 89.73,12.03 ; 89.73,12.03 89.92,11.84 90.24,11.84 90.38,11.98 Q2411.3 ; 89.73,12.03 Q2411.2
KB_LED_R5_DRV#: length 244.6
  TOP w0.127: v3(74.93,50.09) 76.16,50.09 v1(76.84,49.42)
  IN4 w0.091: v3(175.53,136.79) 175.76,137.02 175.76,137.81 174.69,138.87 171.34,138.87 169.52,140.69 165.85,140.69 165.22,140.07 157.52,140.07 156.8,140.79 151.66,140.79 149.14,138.27 144.19,138.27 143.12,139.35 139.14,139.35 137.55,137.76 133.28,137.76 132.23,136.71 130.05,136.71 125.89,132.55 104.71,132.55 96.83,124.67 96.83,123.48 94.81,121.46 90.87,121.46 89.27,119.85 87.26,119.85 85.37,117.97 85.37,98.85 83.77,97.25 83.77,93.16 73.8,83.19 73.8,63.38 76.66,60.53 76.66,56.05 75.39,54.78 75.39,52.87 74.42,51.91 74.42,50.6 v3(74.93,50.09)
  BOTTOM w0.127: JKB3.4 55.15,12.82 55.46,13.13 55.46,14.2 56.5,15.24 70.26,15.24 71,14.51 72.44,14.51 75.5,17.57 75.5,18.96 74.53,19.94 74.53,23.95 76.72,26.15 76.72,29.57 77.59,30.43 77.59,31.78 76.51,32.86 76.19,32.86 75.29,33.76 75.29,36.2 75.14,36.35 75.14,42.48 73.92,43.7 73.92,49.07 v3(74.93,50.09) ; UE8.15 176.5,138.5 175.85,137.85 175.85,137.11 v3(175.53,136.79)
KB_RST#: length 97.1
  TOP w0.127: v3(215.37,31.07) 215.37,29.77 214.82,29.22 211.3,29.22 210.52,28.44 RH114.2 ; UE5.2 288,26.61 288.06,26.55 288.06,24.89 287.09,23.92 v3(287.09,23.22)
  IN1 w0.099: v3(287.09,23.22) 286.7,22.82 283.59,22.82 283.3,22.53 280.6,22.53 280.03,21.96 273.85,21.96 273.46,22.35 264.91,22.35 255.63,31.64 244.54,31.64 237.92,25.02 237.25,25.02 236.15,23.92 v3(235.94,23.92)
  IN4 w0.091: v3(215.37,31.07) 215.37,29.77 215.84,29.3 215.84,27.05 216.79,26.1 221.32,26.1 221.93,25.49 224.42,25.49 225.09,24.82 225.87,24.82 226,24.95 231.48,24.95 232.15,25.62 234.24,25.62 v3(235.94,23.92)
  BOTTOM w0.089: v3(215.37,31.07) 215.81,31.07 UH1.AT6
KP_DET#: length 232.5
  TOP w0.127: v3(86.48,16.17) 86.12,15.81 v2(86.12,15.51) ; UE5.123 288.49,23.85 288.14,23.5 288.14,23.03 287.62,22.51 v3(287.62,22.15)
  IN2 w0.099: v3(287.62,22.15) 287.12,22.65 281.82,22.65 280.72,21.55 276.21,21.55 274.39,19.74 268.63,19.74 267.04,18.15 261.74,18.15 257.81,14.23 252.85,14.23 252.51,13.88 242.49,13.88 241.5,14.87 240.02,14.87 239.26,15.63 234.67,15.63 230.12,11.09 222.02,11.09 221.03,10.09 210.24,10.09 206.56,13.77 194.35,13.77 193.17,12.59 177.76,12.59 177.42,12.24 171.73,12.24 171.59,12.11 156.76,12.11 155.31,13.55 150.92,13.55 146.57,17.9 88.21,17.9 v3(86.48,16.17)
  BOTTOM w0.127: v3(86.48,16.17) 86.48,14.93 85.64,14.09 78.37,14.09 78,13.71 JKB2.1 JKB2.2
KSI0: length 212.4
  TOP w0.127: UE5.55 273.37,17.05 273.14,17.28 v3(273.14,18.78) ; v3(80,11) v2(80.53,10.46)
  IN4 w0.091: v3(273.14,18.78) 273.15,18.78 272.63,18.78 271.37,17.52 269.06,17.52 268.94,17.63 267.77,17.63 267.48,17.35 260.72,17.35 258.48,15.11 251.23,15.11 250.75,14.63 236.95,14.63 236.34,15.24 235.5,15.24 234.87,14.62 233.78,14.62 232.91,13.74 226.84,13.74 225.96,12.87 220.59,12.87 219.71,13.74 217.24,13.74 216.08,12.59 208.77,12.59 206.01,15.36 195.76,15.36 193.5,13.1 174.88,13.1 174.03,12.25 170.12,12.25 169.87,11.99 167.8,11.99 167.46,12.34 158.1,12.34 156.86,13.58 154.22,13.58 153.49,14.31 152.71,14.31 151.45,15.57 140.93,15.57 140.81,15.45 130.57,15.45 130.32,15.2 105.71,15.2 v3(103.35,12.85)
  IN4 w0.122: v3(103.35,12.85) 102.58,12.08 101.05,12.08 100.37,11.39 83.81,11.39 83.43,11.01 83.43,10.71 82.93,10.21 80.78,10.21 v3(80,11)
  BOTTOM w0.127: JKB2.6 v3(80,11) JKB2.5 ; JKB1.17 v3(103.35,12.85)
KSI1: length 208.6
  TOP w0.127: v3(270.52,18.96) v2(271.15,18.33) 272.83,16.65 UE5.56
  IN4 w0.091: v3(98.35,12.84) 98.96,12.23 99.65,12.23 99.98,12.56 99.98,13.34 103.55,16.92 130.63,16.92 130.84,17.13 148.15,17.13 148.48,16.81 152.56,16.81 154.82,14.55 157.3,14.55 158.48,13.36 167.54,13.36 167.76,13.58 169.67,13.58 170.11,13.14 173.59,13.14 174.54,14.09 191.66,14.09 192.75,15.18 194.12,15.18 195.28,16.35 204.12,16.35 204.72,16.95 205.45,16.95 206.06,16.35 206.63,16.35 207.61,15.36 216.45,15.36 216.59,15.23 224.07,15.23 224.56,14.74 232.5,14.74 233.25,15.49 234.34,15.49 235.25,16.4 239.97,16.4 240.8,15.57 250.29,15.57 250.72,16.01 257.97,16.01 260.31,18.34 267.04,18.34 267.66,18.96 v3(270.52,18.96)
  IN4 w0.122: v3(82,10.96) 83.25,12.22 97.73,12.22 v3(98.35,12.84)
  BOTTOM w0.127: JKB1.27 v3(98.35,12.84) ; JKB2.9 v3(82,10.96) JKB2.10
KSI2: length 213.7
  TOP w0.127: UE5.57 275.78,16.25 276.29,15.73 276.29,13.96 v3(276.35,13.9) ; v3(101.85,10.26) 101.85,9.95 v2(101.3,9.4)
  IN4 w0.091: v3(101.85,10.26) 102.1,10.26 102.57,9.79 103.04,9.79 103.38,10.14 103.38,10.39 104.08,11.09 113.12,11.09 113.36,11.34 126.59,11.34 126.78,11.15 142.63,11.15 144.22,12.74 148.87,12.74 151.75,9.86 156.17,9.86 158.68,7.35 166.83,7.35 167.63,8.15 172.54,8.15 173.49,9.11 176.66,9.11 176.91,9.36 193.91,9.36 195.4,10.86 196.3,10.86 197.81,12.37 204.94,12.37 208.97,8.34 221.51,8.34 222.75,9.58 249.57,9.58 252.43,12.44 259.64,12.44 260.01,12.8 273.06,12.8 273.68,13.43 276.04,13.43 276.35,13.74 v3(276.35,13.9)
  IN4 w0.122: v3(101.85,10.26) 101.85,10.04 101.16,9.35 85.61,9.35 v3(84,10.96)
  BOTTOM w0.127: JKB1.20 v3(101.85,10.26) ; JKB2.14 v3(84,10.96) JKB2.13
KSI3: length 211
  TOP w0.127: v3(102.85,10.28) 102.21,10.91 v2(102.21,10.91) ; v3(275.62,13.88) 276.02,14.29 276.02,15.6 275.77,15.85 UE5.58
  IN4 w0.091: v3(275.62,13.88) 273.82,13.88 272.96,13.03 259.93,13.03 259.55,12.65 252.34,12.65 249.48,9.8 222.62,9.8 221.41,8.59 209.07,8.59 205.04,12.62 197.71,12.62 196.2,11.1 195.3,11.1 193.8,9.61 176.85,9.61 176.57,9.33 173.36,9.33 172.43,8.4 167.53,8.4 166.73,7.6 158.74,7.6 156.23,10.11 151.86,10.11 149,12.97 144.13,12.97 142.56,11.39 126.88,11.39 126.72,11.56 113.23,11.56 112.98,11.31 103.89,11.31 v3(102.85,10.28)
  IN4 w0.122: v3(102.85,10.28) 102.64,10.28 102.24,10.68 101.65,10.68 101.34,10.37 101.34,10 100.98,9.64 86.32,9.64 v3(85,10.96)
  BOTTOM w0.127: JKB1.18 v3(102.85,10.28) ; JKB2.15 v3(85,10.96) JKB2.16
KSI4: length 208.9
  TOP w0.127: v2(82.46,10.43) 82.97,10.94 v3(83,10.94) ; v3(270.24,18.44) 272.21,16.47 272.54,16.47 273.57,15.45 UE5.59
  IN4 w0.091: v3(270.24,18.44) 270.24,18.17 270.09,18.02 269.26,18.02 269.15,18.13 267.56,18.13 267.28,17.85 260.51,17.85 258.23,15.56 250.99,15.56 250.57,15.14 240.53,15.14 239.76,15.91 235.46,15.91 234.6,15.05 233.52,15.05 232.7,14.24 226.63,14.24 225.75,13.36 220.79,13.36 219.92,14.24 217.03,14.24 215.88,13.09 208.94,13.09 206.17,15.85 195.51,15.85 193.25,13.59 174.71,13.59 173.81,12.69 169.87,12.69 169.67,12.5 168.13,12.5 167.78,12.84 158.3,12.84 157.06,14.08 154.64,14.08 152.39,16.33 148.25,16.33 147.95,16.64 131.05,16.64 130.07,15.66 104.36,15.66 v3(101.54,12.84)
  IN4 w0.122: v3(83,10.94) 83.72,11.66 100.1,11.66 101.28,12.84 v3(101.54,12.84)
  BOTTOM w0.127: JKB2.11 v3(83,10.94) JKB2.12 ; v3(101.54,12.84) 101.35,12.65 JKB1.21
KSI5: length 209.1
  TOP w0.127: UE5.60 273.37,15.05 273.13,15.29 273.13,15.52 272.54,16.11 271.97,16.11 v2(271.64,16.44) v3(269.65,18.43)
  IN4 w0.091: v3(269.65,18.43) 269.62,18.46 267.51,18.46 267.15,18.1 260.41,18.1 258.1,15.78 250.85,15.78 250.42,15.36 240.66,15.36 239.86,16.16 235.36,16.16 234.47,15.27 233.38,15.27 232.6,14.49 224.45,14.49 223.97,14.98 216.48,14.98 216.34,15.12 207.51,15.12 206.52,16.1 195.34,16.1 193.08,13.84 174.64,13.84 173.72,12.92 169.74,12.92 169.56,12.75 168.23,12.75 167.89,13.09 158.41,13.09 157.17,14.33 154.73,14.33 152.5,16.56 148.38,16.56 148.05,16.89 130.95,16.89 130.76,16.7 104.53,16.7 v3(100.67,12.84)
  IN4 w0.122: v3(81,10.97) 81.45,10.52 82.18,10.52 82.54,10.87 82.54,11.11 83.36,11.94 99.77,11.94 v3(100.67,12.84)
  BOTTOM w0.127: JKB1.23 100.35,12.52 v3(100.67,12.84) ; JKB2.8 v3(81,10.97) JKB2.7
KSI6: length 189.4
  TOP w0.127: v3(99.85,10.24) 99.85,10.1 v2(99.16,9.41) ; UE5.61 275.37,14.65 275.6,14.88 v3(275.6,15.39)
  IN4 w0.091: v3(275.6,15.39) 274.7,15.39 272.78,13.47 259.76,13.47 259.38,13.1 252.15,13.1 249.29,10.24 222.35,10.24 221.2,9.09 209.27,9.09 205.25,13.12 196.59,13.12 193.58,10.11 176.71,10.11 176.38,9.78 173.11,9.78 172.23,8.9 167.01,8.9 166.46,9.45 157.82,9.45 155.93,11.34 151.33,11.34 149.23,13.44 143.9,13.44 142.29,11.83 127.15,11.83 126.94,12.04 113,12.04 112.71,11.75 103.69,11.75 103.11,11.17 101.18,11.17 100.25,10.24 v3(99.85,10.24)
  BOTTOM w0.127: JKB1.24 v3(99.85,10.24)
KSI7: length 189.1
  TOP w0.127: v2(98.19,10.91) 98.21,10.91 98.85,10.27 v3(98.85,10.25) ; UE5.62 273.28,14.25 272.65,14.89 v3(272.65,15.39)
  IN4 w0.091: v3(272.65,15.39) 272.05,14.8 261.18,14.8 260.72,14.33 259.68,14.33 259.12,13.77 251.81,13.77 250.04,12 227.56,12 226.66,11.1 222.17,11.1 220.9,9.83 209.56,9.83 205.53,13.86 196.32,13.86 194.03,11.57 192.34,11.57 191.62,10.86 176.51,10.86 176.1,10.45 172.72,10.45 171.92,9.65 167.32,9.65 166.77,10.2 158.13,10.2 156.24,12.09 153.6,12.09 152.87,12.82 152.09,12.82 150.7,14.2 141.55,14.2 140.76,13.41 136.61,13.41 136.55,13.47 130.57,13.47 130.19,13.09 127.43,13.09 127.24,12.9 120.8,12.9 119.84,13.86 108.72,13.86 108.03,13.18 108.03,12.31 107.71,11.99 103.61,11.99 103.02,11.4 101.09,11.4 100.41,10.72 99.32,10.72 v3(98.85,10.25)
  BOTTOM w0.127: JKB1.26 v3(98.85,10.25)
KSO0: length 210.1
  TOP w0.127: v2(96.88,9.5) 97.1,9.5 v3(97.85,10.25) ; v3(281.62,16.45) 281.62,17.08 281.98,17.44 281.98,17.8 280.62,19.15 280.62,20.08 278.2,22.51 276.2,22.51 275.26,23.45 UE5.39
  IN4 w0.091: v3(281.62,16.45) 281.43,16.26 278.07,16.26 277.85,16.47 274.52,16.47 274.31,16.26 270.92,16.26 269.7,15.04 261.08,15.04 260.58,14.55 259.59,14.55 259.04,14 251.72,14 249.97,12.25 227.46,12.25 226.56,11.35 222.06,11.35 220.79,10.08 209.66,10.08 205.63,14.11 196.26,14.11 193.97,11.82 192.23,11.82 191.52,11.1 181.52,11.1 180.77,11.85 175.19,11.85 174.01,10.67 172.59,10.67 171.81,9.9 167.43,9.9 166.88,10.44 158.23,10.44 156.34,12.34 153.7,12.34 152.97,13.07 152.19,13.07 150.83,14.42 141.46,14.42 140.67,13.63 136.7,13.63 136.64,13.68 130.48,13.68 130.1,13.31 127.29,13.31 127.13,13.15 120.91,13.15 119.97,14.09 108.62,14.09 107.79,13.25 107.79,12.46 107.55,12.22 103.53,12.22 102.93,11.62 100.99,11.62 100.38,11 98.6,11 v3(97.85,10.25)
  BOTTOM w0.127: JKB1.28 v3(97.85,10.25)
KSO1: length 201.1
  TOP w0.127: UE5.40 275.28,23.05 276.14,22.19 278.07,22.19 280.33,19.93 280.33,18.85 v3(281.56,17.62) ; v3(102.35,12.84) 102.35,12.88 101.93,13.3 v2(101.92,13.31)
  IN4 w0.091: v3(102.35,12.84) 104.94,15.43 130.2,15.43 130.43,15.67 140.72,15.67 140.84,15.79 151.58,15.79 152.81,14.56 153.56,14.56 154.29,13.83 156.96,13.83 158.2,12.59 167.59,12.59 167.93,12.25 169.77,12.25 169.99,12.47 173.9,12.47 174.78,13.34 193.35,13.34 195.61,15.6 206.11,15.6 208.88,12.84 215.98,12.84 217.13,13.99 219.82,13.99 220.69,13.12 225.86,13.12 226.73,13.99 232.81,13.99 233.65,14.83 234.74,14.83 235.55,15.65 239.57,15.65 240.3,14.92 250.72,14.92 251.14,15.34 258.35,15.34 260.62,17.6 267.38,17.6 267.67,17.88 269.04,17.88 269.16,17.77 271.17,17.77 272.61,19.21 276.29,19.21 277.48,18.02 281.16,18.02 v3(281.56,17.62)
  BOTTOM w0.127: JKB1.19 v3(102.35,12.84)
KSO2: length 203.5
  TOP w0.127: v3(281.12,13.68) 280.84,13.96 280.84,15.52 281.17,15.85 281.17,16.59 281.33,16.75 281.33,17.26 280.08,18.51 280.08,19.76 277.93,21.91 276.05,21.91 275.31,22.65 UE5.41 ; v2(104.22,10.89) 104.25,10.89 v3(104.85,10.28)
  IN4 w0.091: v3(281.12,13.68) 281.11,13.68 275.71,8.28 275.71,8.05 273.26,5.6 208.13,5.6 204.74,8.98 204.24,8.98 202.62,10.61 198.54,10.61 197.05,9.11 196.14,9.11 192.64,5.61 152.73,5.61 150.94,7.39 150.94,8.21 149.14,10 146.77,10 145.37,8.61 106.52,8.61 v3(104.85,10.28)
  BOTTOM w0.127: v3(104.85,10.28) 104.85,10.28 JKB1.14
KSO3: length 202.2
  TOP w0.127: v3(100.85,10.25) v2(100.27,10.83) ; UE5.42 275.32,22.25 275.91,21.66 277.6,21.66 279.73,19.52 279.73,18.44 280.48,17.69 280.48,16.14 280.08,15.74 v3(280.08,15.28)
  IN4 w0.091: v3(100.85,10.25) 101.55,10.95 103.21,10.95 103.79,11.53 112.85,11.53 113.14,11.82 126.81,11.82 127.01,11.61 142.43,11.61 144.01,13.19 149.12,13.19 151.96,10.36 156.34,10.36 157.49,9.2 166.36,9.2 166.91,8.65 172.33,8.65 173.23,9.56 176.47,9.56 176.78,9.86 193.68,9.86 196.69,12.87 205.14,12.87 209.17,8.84 221.31,8.84 222.49,10.02 249.38,10.02 252.24,12.88 259.47,12.88 259.84,13.25 272.87,13.25 274.42,14.8 277.88,14.8 278.67,15.58 279.77,15.58 v3(280.08,15.28)
  BOTTOM w0.127: JKB1.22 v3(100.85,10.25)
KSO4: length 195.8
  TOP w0.127: v3(280.01,16.67) 280.2,16.87 280.2,17.61 279.45,18.36 279.45,19.42 277.48,21.39 275.78,21.39 275.32,21.85 UE5.43 273.43,21.85 273.12,22.16 v2(272.37,22.16)
  IN4 w0.091: v3(105.35,12.84) 107.26,14.75 130.57,14.75 130.77,14.95 141.05,14.95 141.18,15.08 151.23,15.08 152.5,13.81 153.28,13.81 154.01,13.08 156.65,13.08 157.89,11.84 167.13,11.84 167.48,11.49 170.07,11.49 170.38,11.8 174.21,11.8 175.01,12.6 193.73,12.6 195.99,14.86 205.89,14.86 209.92,10.83 220.48,10.83 221.75,12.1 226.25,12.1 227.15,13 249.75,13 251.43,14.68 258.75,14.68 260.23,16.16 267.97,16.16 268.84,17.02 274.01,17.02 274.44,17.45 279.21,17.45 279.98,16.67 v3(280.01,16.67)
  BOTTOM w0.127: JKB1.13 v3(105.35,12.84)
