# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_ESB_CLK: length 57.5
  TOP w0.127: UE5.17 282,28.72 v3(282.02,28.74) 281.76,29 281.76,29.17 RE93.2 ; UE6.1 238.7,40.16 239.6,39.26 239.6,38.92 240.05,38.47 v1(241.62,38.47) v3(244.02,38.47)
  IN1 w0.099: v3(282.02,28.74) 281.94,28.67 281.94,28.16 281.75,27.97 278.27,27.97 275.83,30.41 275.83,31.79 274.94,32.68 264.46,32.68 260.93,36.22 257.88,36.22 253.65,40.44 250.87,40.44 250.61,40.71 246.77,40.71 244.58,38.52 244.07,38.52 v3(244.02,38.47)
EC_ESB_DAT: length 55.6
  TOP w0.127: UE6.4 240.2,43.04 240.83,42.41 241.41,42.41 241.94,41.88 241.94,38.97 242.09,38.81 v1(243.41,38.81) 243.73,38.81 v3(243.99,39.08) ; UE5.18 281.6,28.53 v3(281.41,28.72) 281.51,28.82 281.51,29.15 RE94.2
  IN1 w0.099: v3(281.41,28.72) 281.72,28.41 281.72,28.25 281.66,28.19 278.36,28.19 276.06,30.5 276.06,31.88 275.04,32.91 264.56,32.91 261.02,36.45 257.97,36.45 253.75,40.67 250.97,40.67 250.7,40.93 246.67,40.93 244.48,38.75 244.33,38.75 v3(243.99,39.08)
EC_LID_OUT#: length 70.7
  TOP w0.127: v3(225.95,16.92) 225.45,16.43 RH127.2 ; UE5.101 288.42,15.05 v3(288.06,14.7)
  IN1 w0.099: v3(288.06,14.7) 284.85,14.7 284.01,15.53 281.08,15.53 280.9,15.71 278.73,15.71 277.83,14.81 277.17,14.81 277.04,14.68 275.33,14.68 273.66,16.35 269.04,16.35 268.04,17.34 260.75,17.34 258.58,15.17 240.48,15.17 239.31,16.34 233.13,16.34 232.23,15.44 227.2,15.44 225.95,16.69 v3(225.95,16.92)
  BOTTOM w0.127: v1(224.82,17.24) 225.13,16.92 v3(225.95,16.92)
EC_MUTE#: length 327.8
  TOP w0.127: v1(283.45,9.54) 282.97,10.02 v3(282.97,10.5) 283.2,10.73 UE5.83
  IN1 w0.099: v3(1.55,14.21) 1.36,14.4 1.36,18.98 2.14,19.75 2.14,25.05 2.61,25.52 2.61,26.15 2.31,26.44 2.31,29.76 3.89,31.33 v3(5.98,31.33)
  IN2 w0.099: v3(282.97,10.5) 281.92,9.45 278.02,9.45 277.31,10.17 271.29,10.17 269.33,12.13 261.33,12.13 260.69,11.49 254.24,11.49 252.04,9.29 240.9,9.29 237.5,5.89 210.61,5.89 206.43,10.06 203.39,10.06 202.54,10.92 197.82,10.92 192.91,6 153.6,6 149.2,10.4 147.61,10.4 146.69,11.32 146.69,12.24 145.8,13.12 144.93,13.12 143.82,14.23 140.21,14.23 139.86,13.88 128.06,13.88 127.49,13.32 95.09,13.32 93.9,12.12 70.27,12.12 69.6,12.79 65.2,12.79 64.19,13.81 58.83,13.81 56.82,11.8 53.48,11.8 52.91,11.23 49.61,11.23 49.3,10.91 36.77,10.91 35.42,12.26 31.89,12.26 30.76,13.39 29.78,13.39 27.5,15.67 27.09,15.67 25.13,17.63 22.4,17.63 21.59,18.44 17.31,18.44 15.05,20.7 15.05,21.67 12.89,23.83 11.85,23.83 10.94,24.74 10.94,29.5 10.28,30.16 7.15,30.16 v3(5.98,31.33)
  BOTTOM w0.254: DA15.3 1.99,13.77 v3(1.55,14.21)
EC_ON: length 315.5
  TOP w0.127: v3(26.51,39.96) 26.35,39.96 v1(25.74,40.57) ; UE5.112 289,19.45 288.85,19.6 287.81,19.6 v3(287.26,19.05)
  TOP w0.254: PD100.2 26.51,38.39 v3(26.51,39.96)
  IN1 w0.099: v3(26.51,39.96) 27.04,39.42 27.36,39.42 27.83,38.95 31.39,38.95 33.53,41.09 38.55,41.09 39.83,42.37 44.97,42.37 47.2,44.59 48.11,44.59 49.81,46.29 50.45,46.29 51.3,47.14 51.84,47.14 53.11,48.41 53.42,48.41 53.75,48.74 56.82,48.74 61.9,53.82 67.05,53.82 70.36,50.51 70.36,43.98 71.22,43.12 71.22,31.93 70.93,31.64 70.93,28.98 71.34,28.56 71.34,26.46 69.92,25.03 v3(69.92,22.06)
  IN4 w0.091: v3(287.26,19.05) 286.84,18.63 281.78,18.63 280.45,19.96 267.6,19.96 266.73,19.09 260,19.09 257.58,16.68 250.33,16.68 249.9,16.24 241.18,16.24 240.28,17.15 234.94,17.15 233.94,16.14 232.87,16.14 232.21,15.49 224.87,15.49 224.38,15.97 216.89,15.97 216.76,16.11 207.92,16.11 206.94,17.1 206.37,17.1 205.76,17.7 204.41,17.7 203.81,17.1 195.06,17.1 193.89,15.93 192.44,15.93 191.35,14.84 174.08,14.84 173.82,14.57 169.51,14.57 169.4,14.47 167.54,14.47 167.25,14.75 163.55,14.75 163.05,14.25 158.84,14.25 155.49,17.6 153.12,17.6 152.57,18.15 147.18,18.15 146.93,17.9 130.55,17.9 130.24,17.59 99.2,17.59 98.67,17.06 75.75,17.06 73.55,19.27 72.71,19.27 v3(69.92,22.06)
EC_RST#: length 4.3
  TOP w0.127: RE68.1 271.31,24.72 271.31,24.61 CE37.1 271.97,23.95 v1(272.79,23.95) 273.08,24.25 UE5.37
EC_RX: length 136.5
  TOP w0.127: v3(277.24,23.52) 277.24,24.67 276.39,25.52 276.39,25.65 276.4,25.66 UE5.31 ; v2(173.12,13.44) 172.53,14.02 v3(172.53,14.17)
  IN2 w0.099: v3(277.24,23.52) 276.16,22.44 275.59,22.44 273.65,20.5 268.21,20.5 266.71,19 261.53,19 257.56,15.03 242.31,15.03 241.78,15.55 240.65,15.55 239.89,16.31 234.29,16.31 230.46,12.48 227.42,12.48 226.7,11.76 221.64,11.76 220.77,10.89 217.77,10.89 216.31,12.34 209.18,12.34 207.01,14.51 193.99,14.51 192.85,13.37 177.22,13.37 176.86,13.02 173.68,13.02 v3(172.53,14.17)
  BOTTOM w0.127: JWLAN1.32 174.8,26.28 175.6,25.48 175.6,21.83 177.04,20.4 177.04,17.3 176.58,16.84 176.58,15.17 176.07,14.66 173.02,14.66 v3(172.53,14.17)
EC_SCI#: length 64.9
  TOP w0.089: v3(227.54,34.74) 227.56,34.74 227.97,34.33 229.19,34.33
  TOP w0.127: 229.19,34.33 229.34,34.33 v1(229.88,33.78) 230.52,33.15 231.19,33.15 231.5,33.45 234.72,33.45 235.47,32.7 236.06,32.7 237.1,31.66 239.56,31.66 240.15,32.25 240.15,32.84 240.41,33.11 240.96,33.11 v3(241.38,32.69) ; UE5.20 280.8,26.52 281.72,25.6 281.72,24.61 v3(281.73,24.61)
  IN1 w0.099: v3(281.73,24.61) 281.22,25.11 279.35,25.11 278.99,24.74 264.85,24.74 256.37,33.22 244.98,33.22 244.79,33.4 242.09,33.4 v3(241.38,32.69)
  BOTTOM w0.089: UH1.G15 227.85,35.05 v3(227.54,34.74)
EC_SMB_CK1: length 284.2
  TOP w0.127: v3(44.35,32.22) 44.35,32.51 PR721.1 44.88,33.78 PR18.2 ; RE90.4 280.51,9.5 280.59,9.57 280.59,9.73 v3(280.44,9.88) 280.65,10.09 280.65,10.49 280.88,10.72 280.88,10.89 280.8,10.97 UE5.77
  IN1 w0.099: v3(280.44,9.88) 280.64,9.68 280.64,9.55 280.29,9.21 276.51,9.21 274.57,7.26 263.59,7.26 262.16,5.84 249.97,5.84 248.8,7.01 207.55,7.01 205.73,8.83 204.79,8.83 202.76,10.86 198.07,10.86 196.73,9.51 196.26,9.51 193.09,6.34 152.18,6.34 151.45,7.08 151.45,8.67 149.83,10.29 146.66,10.29 145.23,8.85 72.27,8.85 71.63,9.49 71.19,9.49 70.93,9.23 70.93,9.07 v3(70.72,8.85)
  IN4 w0.091: v3(70.72,8.85) 70.94,9.08 70.94,10.65 74.21,13.92 74.21,17.43 v3(74.02,17.62)
  IN6 w0.099: v3(74.02,17.62) 74.2,17.8 74.2,18.6 74.54,18.94 74.54,21.12 73.57,22.09 71.1,22.09 70.25,21.24 69.21,21.24 67.81,19.84 56.01,19.84 55.38,19.2 45.91,19.2 45.6,19.52 45.6,21.68 45.98,22.06 45.98,31.28 44.5,32.76 44.27,32.76 44.14,32.64 44.14,32.43 v3(44.35,32.22)
EC_SMB_CK2: length 362.8
  TOP w0.127: RM89.1 195.27,134.09 195.73,134.09 196.08,134.44 196.08,135.6 195.28,136.4 194.73,136.4 194.49,136.16 194.49,135.77 v3(194.4,135.68) ; RE90.2 281.51,9.47 281.69,9.64 281.69,10.75 281.6,10.84 UE5.79 281.6,12.7 281.69,12.79 281.69,15.56 282.07,15.94 282.07,16.91 282.46,17.3 282.46,18.07 281.74,18.79 281.74,19.49 v3(281.53,19.71) ; v3(163.71,51.39) 163.71,51.6 163.4,51.9 QV13.3 ; QH3.1 v3(231.09,19.57)
  IN1 w0.099: v3(281.53,19.71) 281.71,19.52 281.71,19.29 281.53,19.12 274.53,19.12 274.05,19.59 268.64,19.59 268.46,19.41 259.73,19.41 257.48,17.15 241.5,17.15 240.02,18.63 235.59,18.63 235.13,19.09 231.58,19.09 v3(231.09,19.57)
  IN4 w0.089: 159.89,66.34 159.89,66.36 159.9,66.36 159.9,77.14 160.62,77.87 160.62,81.83 160.86,82.07 160.86,95.86 159.33,97.39 159.33,98.15 159.33,98.15
  IN4 w0.091: v3(163.71,51.39) 163.7,51.4 164.17,51.4 164.43,51.65 164.43,52.02 163.99,52.46 163.38,52.46 162.19,53.65 161.81,53.65 157.71,57.75 157.71,61.86 159.89,64.05 159.89,66.34 ; v3(194.4,135.68) 194.58,135.5 194.58,135.2 194.44,135.07 193.74,135.07 192.66,136.15 189.71,136.15 187.71,134.14 187.71,133.47 186.03,131.79 174.46,131.79 173.96,132.29 169.94,132.29 169.45,132.78 169.45,133.77 v3(169.61,133.93) 169.47,134.07 169.47,134.42 169.16,134.73 167.66,134.73 167.36,135.03 167.36,136.12 166.48,137 161.72,137 160.17,135.45 155.52,135.45 154.14,134.07 154.14,129.02 152.76,127.64 152.76,125.31 150.84,123.4 150.84,120.23 156.23,114.84 156.23,103.02 158.89,100.37 158.89,98.59 159.33,98.15 159.33,98.15 ; v3(231.09,19.57) 230.64,19.12 229.01,19.12 228.41,19.71 228.41,20.86 228.09,21.17 226.26,21.17 225.67,21.76 219.38,21.76 218.74,21.13 215.98,21.13 215.55,20.7 211.27,20.7 211.09,20.88 206.29,20.88 205.35,21.83 198.71,21.83 197.45,20.57 192.74,20.57 192,19.83 174.38,19.83 174.11,20.11 166.4,20.11 165.62,20.88 164.46,20.88 164.15,20.57 164.15,20.28 v3(163.97,20.1)
  IN6 w0.099: v3(163.97,20.1) 164.15,20.28 164.15,20.52 163.91,20.76 147.52,20.76 147.23,21.04 147.23,21.55 v3(147.06,21.73)
  BOTTOM w0.127: v3(147.06,21.73) 147.22,21.57 147.22,17.9 145.96,16.64 145.96,15.05 145.46,14.55 144.84,14.55 144.71,14.67 U2407.10 ; v3(194.4,135.68) 194.55,135.83 194.55,136.14 194.85,136.44 195.34,136.44 196.22,135.56 196.93,135.56 197.27,135.9 199.15,135.9 199.99,135.07 201.93,135.07 202.26,134.73 202.26,134.43 202.46,134.23 U2410.8 ; v3(169.61,133.93) 169.45,133.77 169.45,133.57 169.14,133.26 168.54,133.26 RM67.1 ; v3(163.71,51.39) 163.71,52.15 163.9,52.34 164.16,52.34 164.33,52.17 164.33,41.37 163.74,40.78 163.6,40.78 162.6,39.78 162.6,39.27 162.08,38.75 162.08,35.58 163.11,34.55 163.11,26.96 164.12,25.94 164.12,23.07 163.82,22.76 163.82,20.88 164.14,20.56 164.14,20.27 v3(163.97,20.1)
EC_SMB_DA1: length 285
  TOP w0.127: RE90.3 281.01,9.5 280.88,9.64 280.88,9.74 v3(281.02,9.88) 280.92,9.98 280.9,10 280.9,10.39 281.13,10.62 281.13,10.87 281.2,10.94 UE5.78 ; v3(43.73,32.22) 43.73,31.71 PR20.2 43.1,32.07 PR720.1
  IN1 w0.099: v3(71.3,8.85) 71.16,9 71.16,9.14 71.28,9.26 71.54,9.26 72.17,8.63 145.32,8.63 146.75,10.06 149.74,10.06 151.22,8.57 151.22,6.98 152.09,6.12 193.18,6.12 196.35,9.29 196.82,9.29 198.16,10.63 202.67,10.63 204.7,8.6 205.64,8.6 207.45,6.79 248.7,6.79 249.87,5.62 262.26,5.62 263.68,7.04 274.66,7.04 276.61,8.98 280.39,8.98 280.86,9.46 280.86,9.72 v3(281.02,9.88)
  IN4 w0.091: v3(71.3,8.85) 71.16,8.99 71.16,10.56 74.43,13.83 74.43,17.43 v3(74.61,17.62)
  IN6 w0.099: v3(74.61,17.62) 74.43,17.8 74.43,18.51 74.76,18.85 74.76,21.21 73.66,22.32 71.01,22.32 70.15,21.46 69.11,21.46 67.72,20.07 55.92,20.07 55.28,19.43 46.01,19.43 45.82,19.62 45.82,21.59 46.2,21.97 46.2,31.37 44.59,32.98 44.17,32.98 43.92,32.73 43.92,32.41 v3(43.73,32.22)
EC_SMB_DA2: length 362.2
  TOP w0.127: v3(231.68,18.64) 231.17,18.12 230.58,18.12 230.29,17.83 v1(230.06,17.83) 229.79,18.1 QH3.4 ; RM90.1 195.27,134.35 195.63,134.35 195.83,134.55 195.83,135.5 195.18,136.15 194.85,136.15 194.76,136.06 194.76,135.91 v3(194.99,135.68) ; v3(165.46,52.85) 165.1,53.2 QV13.6 ; RE90.1 282.01,9.55 281.94,9.62 281.94,10.76 282,10.81 UE5.80 282,12.67 281.94,12.72 281.94,15.46 282.32,15.84 282.32,16.79 282.72,17.19 282.72,18.18 281.99,18.9 281.99,19.59 v3(282.11,19.71)
  IN1 w0.099: v3(282.11,19.71) 281.94,19.53 281.94,19.2 281.63,18.89 274.4,18.89 273.92,19.36 268.79,19.36 268.61,19.18 259.82,19.18 257.57,16.93 241.39,16.93 239.92,18.4 235.5,18.4 235.04,18.86 231.91,18.86 v3(231.68,18.64)
  IN4 w0.089: 160.11,66.34 160.11,77.05 160.83,77.78 160.83,81.74 161.08,81.98 161.08,95.95 159.55,97.48 159.55,98.24 159.5,98.29 159.5,98.29 159.5,98.29 159.33,98.46
  IN4 w0.091: v3(164.56,20.1) 164.37,20.29 164.37,20.48 164.55,20.66 165.53,20.66 166.31,19.89 174.01,19.89 174.29,19.61 192.09,19.61 192.83,20.35 197.54,20.35 198.8,21.61 205.26,21.61 206.2,20.66 211,20.66 211.18,20.48 215.64,20.48 216.07,20.91 218.83,20.91 219.47,21.54 225.58,21.54 226.17,20.95 228,20.95 228.19,20.76 228.19,19.62 228.93,18.89 231.44,18.89 v3(231.68,18.64) ; 159.33,98.46 159.11,98.68 159.11,100.46 156.45,103.11 156.45,114.93 151.06,120.32 151.06,123.3 152.98,125.22 152.98,127.55 154.36,128.93 154.36,133.97 155.62,135.23 160.26,135.23 161.81,136.78 166.39,136.78 167.14,136.03 167.14,134.94 167.57,134.51 169.07,134.51 169.25,134.33 169.25,134.15 169.03,133.92 v3(169.03,133.93) 169.2,133.76 169.2,132.72 169.85,132.07 173.87,132.07 174.37,131.57 186.12,131.57 186.72,132.17 187.93,133.38 187.93,134.05 189.8,135.93 192.57,135.93 193.65,134.85 194.53,134.85 194.79,135.11 194.79,135.49 v3(194.99,135.68) ; v3(165.46,52.85) 165.46,52.34 165.09,51.97 164.78,51.97 164.08,52.68 163.47,52.68 162.28,53.87 161.9,53.87 157.93,57.84 157.93,61.77 160.11,63.95 160.11,66.34
  IN6 w0.099: v3(147.64,21.73) 147.46,21.55 147.46,21.17 147.65,20.98 164.01,20.98 164.38,20.61 164.38,20.28 v3(164.56,20.1)
  BOTTOM w0.127: v3(194.99,135.68) 194.83,135.83 194.83,136.06 194.96,136.18 195.24,136.18 196.11,135.31 197.03,135.31 197.38,135.65 199.04,135.65 199.88,134.81 201.83,134.81 202.01,134.63 202.01,134.4 201.81,134.2 U2410.7 ; v3(147.64,21.73) 147.47,21.57 147.47,17.79 146.22,16.53 146.22,14.95 145.57,14.3 144.84,14.3 144.71,14.17 U2407.9 ; v3(164.56,20.1) 164.39,20.27 164.39,20.66 164.07,20.98 164.07,22.66 164.38,22.96 164.38,26.05 163.37,27.06 163.37,34.66 162.33,35.69 162.33,38.65 162.85,39.17 162.85,39.68 163.71,40.53 163.85,40.53 164.58,41.26 164.58,52.33 165.1,52.85 v3(165.46,52.85) ; RM68.1 168.67,133.52 169.03,133.52 169.19,133.68 169.19,133.77 v3(169.03,133.93)
EC_SMI#: length 75.3
  TOP w0.127: v3(281.93,23.28) 281.94,23.28 282.8,24.13 UE5.15 ; v1(237.62,26.96) 237.93,26.65 v3(238.15,26.65)
  IN1 w0.099: v3(281.93,23.28) 281.66,23.01 280.44,23.01 279.84,22.41 274.04,22.41 272.88,23.57 264.35,23.57 255.84,32.09 244.35,32.09 238.91,26.65 v3(238.15,26.65)
  IN4 w0.091: v3(221.97,28.25) 221.97,26.91 222.42,26.47 224.51,26.47 225.08,27.04 231.29,27.04 232.03,27.78 233.58,27.78 234.67,26.69 238.12,26.69 v3(238.15,26.65)
  BOTTOM w0.089: UH1.Y1 222.16,28.95 222.16,28.82 221.97,28.63 v3(221.97,28.25)
EC_TX: length 141
  TOP w0.127: v3(277.88,23.52) 277.88,24.74 276.8,25.82 UE5.30 ; RM31.1 173.14,26.46 172.68,26.91 v1(172.68,27.6) 172.68,28.07 v3(172.76,28.15)
  IN2 w0.099: v3(173.14,14.17) 174.07,13.25 176.77,13.25 177.12,13.6 192.45,13.6 193.62,14.76 207.11,14.76 209.28,12.59 216.39,12.59 217.85,11.14 220.7,11.14 221.55,11.99 226.6,11.99 227.34,12.73 230.35,12.73 234.16,16.54 239.98,16.54 240.74,15.78 241.88,15.78 242.37,15.28 257.46,15.28 261.47,19.29 266.69,19.29 268.29,20.89 273.69,20.89 275.56,22.76 275.99,22.76 276.74,23.5 276.74,23.6 277.07,23.94 277.46,23.94 v3(277.88,23.52)
  BOTTOM w0.127: v3(173.14,14.17) 173.37,14.4 176.25,14.4 176.84,14.99 176.84,16.74 177.29,17.19 177.29,20.53 175.86,21.96 175.86,25.59 174.67,26.78 JWLAN1.30 172.99,26.78 172.76,27.01 v3(172.76,28.15)
ECAGND: length 257.9
  TOP w0.203: UE5.69 277.6,10.48 277.57,10.45 CE33.2
  TOP w0.254: v3(274.58,12.98) 274.07,12.47 273.29,12.47 CE35.1 ; LE2.2 277.57,9.3 CE33.2 v3(278.2,9.87) ; PH1.2 124.4,91.71 124.4,92.03 124.88,92.51 128.05,92.51 v1(128.51,92.05) 129.16,91.4 v3(129.16,90.83)
  IN1 w0.254: v3(176.52,24.75) 174.92,24.75 171.9,27.77 171.9,28.48 169.38,30.99 167.24,30.99 164.19,34.04 164.19,37.65 164.9,38.36 164.9,39.97 164.4,40.46 162.42,40.46 162.18,40.71 162.18,40.8 159.25,43.74 159.25,44.61 155.62,48.24 154.03,48.24 147.66,54.61 146.08,54.61 140.87,59.82 140.87,64.2 136.87,68.21 136.87,84.03 131.41,89.49 130.33,89.49 129.16,90.66 v3(129.16,90.83)
  IN6 w0.254: v3(237.91,49.44) 237.91,48.72 239.22,47.41 241.24,47.41 243.46,45.19 245.18,45.19 247.81,42.55 247.81,39.43 255.79,31.44 255.79,30.77 259.11,27.45 259.7,27.45 265.62,21.53 269.02,21.53 274.7,15.84 274.7,13.11 v3(274.58,12.98)
  BOTTOM w0.254: v3(274.58,12.98) 277.69,9.87 v3(278.2,9.87) ; v3(176.52,24.75) 176.29,24.53 176.29,22.76 177.96,21.09 187.29,21.09 193.49,27.28 193.49,27.87 197.66,32.05 199.63,32.05 202.44,34.86 202.44,46.08 207.05,50.69 207.05,52.99 211.08,57.03 223.22,57.03 225.36,54.88 231.99,54.88 235.38,51.48 235.38,50.38 236.32,49.44 v3(237.91,49.44)
EDP_AUX#_C: length 3.5
  TOP w0.127: v3(99.49,130.18) 99.49,130.4 99.17,130.72 99.04,130.72 JEDP1.14
  BOTTOM w0.127: v3(99.49,130.18) 99.49,130.38 99.34,130.53 98.33,130.53 98.11,130.75 CV13.1
EDP_AUX_C: length 3.6
  TOP w0.127: JEDP1.13 99.38,131.09 99.38,130.85 99.64,130.6 v3(99.9,130.6)
  BOTTOM w0.127: CV12.1 98.31,130.9 98.43,130.77 99.44,130.77 99.61,130.6 v3(99.9,130.6)
EDP_COMP: length 2.9
  TOP w0.089: v1(123.26,85.13) RC32.2
  TOP w0.508: v3(124.35,83.91) 123.39,83.91 RC32.2
  BOTTOM w0.254: v3(124.35,83.91) 124.35,83.94 124.72,84.32 CPU1.AG6
EDP_DISP_UTIL: length 10.8
  TOP w0.127: RC33.1 v2(122.75,105.41) 122.75,104.37 121.03,102.66 121.03,99.32 v3(120.66,98.94)
  BOTTOM w0.089: v3(120.66,98.94) 120.33,99.27 CPU1.E12
EDP_HPD_R: length 13.7
  TOP w0.508: v3(118.94,99.62) 118.94,102.64 120.88,104.59 v1(120.88,106.56) 120.88,109.87 QC1.1 121.8,109.88 122.1,110.18 RC34.1
  BOTTOM w0.089: v3(118.94,99.62) 119.29,99.27 CPU1.E14
EDP_TX0#_C: length 4.2
  TOP w0.127: JEDP1.2 103.28,134.96 103.51,134.96 103.99,134.49 v3(103.99,134.2)
  BOTTOM w0.127: v3(103.99,134.2) 103.99,134.41 103.52,134.88 103.52,135.73 103.33,135.92 CV2.1
EDP_TX0_C: length 4.1
  TOP w0.127: JEDP1.1 103.63,135.32 103.63,135.18 104.21,134.61 v3(104.4,134.61)
  BOTTOM w0.127: CV1.1 103.51,136.09 103.76,135.83 103.76,134.98 104.13,134.61 v3(104.4,134.61)
EDP_TX1#_C: length 4.2
  TOP w0.127: v3(103.18,133.2) 103.18,133.37 102.91,133.64 102.64,133.64 102.4,133.89 102.24,133.89 JEDP1.5
  BOTTOM w0.127: v3(103.18,133.2) 103.18,133.42 102.01,134.6 CV4.1
EDP_TX1_C: length 4.3
  TOP w0.127: v3(103.59,133.61) 103.28,133.61 103.01,133.89 102.75,133.89 102.62,134.01 102.62,134.21 JEDP1.4
  BOTTOM w0.127: CV3.1 102.21,134.73 103.33,133.61 v3(103.59,133.61)
EDP_TX2#_C: length 3.7
  TOP w0.127: JEDP1.8 101.19,132.81 101.43,132.81 101.82,132.42 v3(101.82,132.21)
  BOTTOM w0.127: v3(101.82,132.21) 101.82,132.42 100.89,133.35 CV6.1
EDP_TX2_C: length 3.6
  TOP w0.127: v3(102.23,132.62) 101.96,132.62 101.54,133.05 101.54,133.17 101.14,133.57
  BOTTOM w0.127: v3(102.23,132.62) 101.96,132.62 100.9,133.68 CV8.1
EDP_TX3#_C: length 3.4
  TOP w0.127: JEDP1.11 100.08,131.8 100.23,131.8 100.55,131.48 v3(100.55,131.21)
  BOTTOM w0.127: v3(100.55,131.21) 100.55,131.4 100.13,131.82 99.64,131.82 99.42,132.04 CV11.1
EDP_TX3_C: length 3.5
  TOP w0.127: JEDP1.10 100.43,132.15 100.43,131.94 100.76,131.62 v3(100.96,131.62)
  BOTTOM w0.127: CV7.1 99.62,132.19 99.74,132.06 100.23,132.06 100.67,131.62 v3(100.96,131.62)
ELC_8051_C2CK_RST#: length 134.1
  TOP w0.127: v1(269.65,35.56) 269.76,35.56 v3(270.39,34.94)
  IN3 w0.091: v3(270.39,34.94) 270.59,35.15 270.59,35.29 270.45,35.43 269.32,35.43 268.34,36.41 261.81,36.41 258.47,39.75 254.38,39.75 248.49,45.64 244.46,45.64 242.13,47.98 242.13,51.04 241,52.17 234.28,52.17 232.4,50.29 220.18,50.29 219.73,49.84 211.24,49.84 208.81,47.4 205.34,47.4 203.16,45.23 203.16,24.21 198.05,19.1 189.05,19.1 188.15,18.2 v3(188.15,17.76)
  BOTTOM w0.127: v3(270.39,34.94) 269.95,34.51 269.69,34.51 269.02,33.84 RE7.2 267.93,33.43 267.93,32.9 UE1.9 ; v3(188.15,17.76) 188.15,18.4 186.59,19.95 181.33,19.95 180.35,18.97 JELC1.2
ELC_8051_C2D_P3: length 134.9
  TOP w0.127: v3(271.02,34.95) 271.59,35.52 v1(272.11,35.52)
  IN3 w0.091: v3(187.5,17.54) 187.5,17.86 188.96,19.32 197.96,19.32 202.95,24.31 202.95,45.32 205.25,47.62 208.72,47.62 211.15,50.06 219.64,50.06 220.09,50.51 232.31,50.51 234.19,52.39 241.09,52.39 242.35,51.13 242.35,48.07 244.55,45.86 248.58,45.86 254.47,39.97 258.59,39.97 261.92,36.63 268.43,36.63 269.41,35.65 270.54,35.65 270.81,35.38 270.81,35.16 v3(271.02,34.95)
  BOTTOM w0.127: v3(271.02,34.95) 270.32,34.25 269.79,34.25 268.48,32.94 268.48,32.32 UE1.10 ; v3(187.5,17.54) 187.5,18.68 186.49,19.7 181.43,19.7 181.15,19.41 JELC1.3
EN_0.675VSP: length 3.2
  TOP w0.203: PC214.1 149.75,26.52 v3(150.19,26.52) 150.49,26.82 PU200.7
  TOP w0.254: PR209.2 149.14,25.91 PC214.1
EN_1.2V: length 2.4
  BOTTOM w0.127: UA5.5 27.8,15.46 27.26,16 CA112.1 RA128.1
EN_1.5V:
  vias: v1(203.79,18.02)
EN_1.35V: length 2.4
  TOP w0.203: PU200.8 150.89,25.93 150.92,25.9
  TOP w0.254: PC213.1 150.92,25.9 PR208.2
EN_+1.05V_GPUP: length 4.1
  BOTTOM w0.254: PR677.2 PR403.1 PC659.1 143.55,86.77 143.55,87.35 143.36,87.55 PU602.5
EN_+1.05VSP: length 5.9
  BOTTOM w0.127: v1(238.75,26.74) 240.26,26.74 240.73,27.21 PC300.1
  BOTTOM w0.254: PR304.2 PR300.2 240.79,26.25 PC300.1 241.1,27.51 PU300.3
EN_+1.35VS_VGAP: length 6.1
  BOTTOM w0.127: v1(128.17,109.26) 128.48,109.56 129.81,109.56 130.28,110.03 PC312.1
  BOTTOM w0.254: PR315.2 PR313.2 130.34,109.09 PC312.1 130.75,110.03 130.92,109.87 PU301.3
EN_INVPWR: length 316.2
  TOP w0.127: UE5.68 277.2,12.82 v3(277.46,13.09) ; v1(81.04,110.44) QV2.2 81.04,112.27 81.4,112.63 81.89,112.63 v3(82.68,113.41)
  IN2 w0.099: v3(82.68,113.41) 83.71,112.38 83.71,103.96 86.8,100.87 91.54,100.87 92.07,101.4 110.79,101.4 114.73,105.35 129.52,105.35 132.7,102.16 132.7,89.75 134.08,88.38 134.08,83.74 135.75,82.07 135.75,67.74 138.57,64.92 138.57,57.86 143.34,53.09 147.89,53.09 156.68,44.3 156.68,41.55 158.08,40.15 158.08,39.53 161.05,36.56 161.05,34.81 168.61,27.25 168.61,25.69 170.28,24.02 172.06,24.02 174.44,21.64 179.77,21.64 180.37,22.24 189.94,22.24 201.41,33.71 201.41,44.46 202.48,45.54 204.38,45.54 210.03,51.18 215.85,51.18 216.52,50.51 217.43,50.51 218.14,51.23 219.92,51.23 220.79,52.1 224.85,52.1 226.23,50.71 230.42,50.71 232.03,49.1 233.48,49.1 v3(233.89,49.51)
  IN6 w0.099: v3(233.89,49.51) 234.55,50.17 238.37,50.17 239.22,49.31 240.3,49.31 243.74,45.88 245.78,45.88 248.72,42.94 248.72,40.43 250.36,38.79 252.18,38.79 256.7,34.27 256.7,33.56 256.7,31.21 259.55,28.36 260.07,28.36 265.75,22.69 269.33,22.69 272.18,19.84 273.24,19.84 277.14,15.94 277.14,13.41 v3(277.46,13.09)
  BOTTOM w0.127: RE80.1 276.99,13.56 v3(277.46,13.09)
EN_TPLED:
  vias: v1(213.43,119.29)
EN_WOL#: length 64.7
  TOP w0.127: v3(298.97,31.57) 298.97,29.59 297.26,27.88 297.26,23.69 297.5,23.45 297.5,11.81 297.16,11.47 v1(294.78,11.47) RE79.2 292.15,11.47 291.75,11.88 291.75,13.06 290.96,13.85 UE5.98 ; CL42.1 330.95,32.73 UL2.4 329.49,32.73 v3(329.06,32.3)
  IN6 w0.099: v3(329.06,32.3) 325.76,29 308.78,29 308.62,29.15 307.76,29.15 305.08,31.83 299.23,31.83 v3(298.97,31.57)
ENSMB: length 4.7
  BOTTOM w0.127: UM8.48 162.83,133.37 RM66.1 163.5,134.04 163.5,134.9 RM64.1 163.57,135.52 163.57,136.18 v1(163.45,136.3)
ENVDD_R: length 1.4
  BOTTOM w0.127: RV3.2 84.83,118.54 85.52,119.23 85.88,119.23 v1(85.89,119.24)
EQA0: length 6.5
  BOTTOM w0.127: UM8.20 151.02,130.87 150.76,130.61 150.76,128.96 150.04,128.23 RM84.2 RM81.2 150.04,125.82 v1(150.4,125.47)
EQA1: length 6.3
  BOTTOM w0.127: v1(152.33,125.92) 153.11,126.71 RM76.2 RM70.2 152.64,128.36 152.28,128.36 151.84,128.79 151.84,129.17 151.04,129.97 151.04,130.25 151.16,130.37 UM8.19
EQB0: length 4
  TOP w0.127: v1(161.18,135.03) 161.3,135.16 RM85.2 162.35,134.58 v3(162.45,134.48) 162.45,134.13 162.16,133.83 RM82.2
  BOTTOM w0.127: UM8.46 162.33,134.37 v3(162.45,134.48)
EQB1: length 6.1
  TOP w0.127: v1(165.06,133.47) 164.9,133.3 163.38,133.3 163.1,133.59 RM26.2 163.04,133.89 v3(163.04,134.48) 163.46,134.48 RM23.2
  BOTTOM w0.127: v3(163.04,134.48) 162.43,133.87 UM8.47
FB: length 4.6
  TOP w0.254: v3(140.85,126.39) 140.85,126.89 PR533.2 ; v3(140.85,126.39) 140.85,126.27 140.38,125.8 139.89,125.8 139.77,125.68 ; v3(140.85,126.39) 141.53,125.71 PR537.2
  BOTTOM w0.127: v1(141.76,126.46) 140.91,126.46 v3(140.85,126.39)
FB_1.2V: length 3.6
  BOTTOM w0.127: RA129.2 RA127.1 24.56,16.11 25.4,15.27 25.4,14.72 25.66,14.46 UA5.2
FB_1.5V: length 1.4
  TOP w0.127: v1(202.59,21.67) 203.38,22.47 PR406.1
FB_1.35V: length 3.8
  TOP w0.203: PR205.1 148.06,26.91 149.91,26.91 150.09,27.09 PU200.6
  TOP w0.254: PR207.1 146.86,27.23 PR205.1
FB_3V: length 4.3
  TOP w0.127: v1(18.07,28.21) 18.4,27.88 PR101.2
  TOP w0.203: PR101.2 PR103.2 20.63,27.88 21.38,28.63 PU100.4
FB_5V: length 4.5
  TOP w0.203: PU100.2 21.26,29.43 PR104.1
  TOP w0.254: PR102.1 19.59,31.79 v1(19.59,30.63) 20.11,30.11 PR104.1
FB_+1.05V_GPUP: length 3.9
  BOTTOM w0.254: PC661.2 PR681.2 PR685.1 139.31,86.17 139.31,87.33 139.53,87.55 PU602.6
FB_+1.05VSP: length 3.8
  BOTTOM w0.127: v1(240.44,30.05) 240.79,29.69 PR307.1
  BOTTOM w0.254: PR307.1 PR308.1 240.94,28.01 PU300.4
FB_+1.35VS_VGAP: length 4.7
  BOTTOM w0.127: v1(128.17,111.14) 128.89,111.86 PR316.1
  BOTTOM w0.254: PR316.1 130.34,110.96 PR310.1 130.67,110.94 131.24,110.37 PU301.4
FB_VDDQ_SENSE: length 67.3
  IN2 w0.254: v3(191.55,106.36) 191.59,106.4 192.12,106.4 192.4,106.12 192.4,105.45 192.92,104.93 192.92,104.17 194.45,102.64 194.45,102.19 193.78,101.53 192.44,101.53 191.65,100.74 191.65,99.98 190.37,98.7 188.99,98.7 188.41,99.28 187.53,99.28 186.99,98.73 184.63,98.73 184.15,99.21 181.99,99.21 181.42,98.64 176.85,98.64 175.94,97.73 173.7,97.73 172.72,98.71 172.72,100.55 172.09,101.18 172.09,101.82 171.2,102.71 165.76,102.71 164.44,104.03 164.44,105.53 161.7,108.27 161.7,108.92 161.18,109.44 161.18,117.74 160.78,118.14 v3(160.59,118.14)
  BOTTOM w0.157: UV1.R49 188,106.33 187.76,106.57 187.76,106.78 187.58,106.96 187.58,107.6 188.03,108.04 v1(189.55,108.04) 191.23,106.36 v3(191.55,106.36)
  BOTTOM w0.254: v3(160.59,118.14) 160.05,118.14 159.79,117.88 PR317.2
FBA_ABI#_H: length 30.4
  BOTTOM w0.089: UV7.J4 168.21,120.71 168.34,120.58 168.42,120.58 168.64,120.8 168.78,120.8 168.81,120.77 169.27,120.77 169.53,120.52 170.11,120.52 170.36,120.76 170.36,121.44 169.55,122.26 169.55,122.43 169.97,122.85 169.97,124.72 170.09,124.84 170.26,124.84 170.39,124.72 170.39,122.86 170.08,122.55 170.08,122.26 170.89,121.45 170.89,119.24 170.69,119.04 170.15,119.04 169.97,118.86 169.97,117.68 170.55,117.09 170.55,115.06 170.68,114.93 171.67,114.93 171.91,114.7 171.91,114.08 171.73,113.91
  BOTTOM w0.157: 171.73,113.91 171.73,113.42 171.25,112.95 171.25,110.7 173.1,108.86 v1(173.1,108.13) 173.1,106.78 173.6,106.27 UV1.AN49
FBA_ABI#_L: length 25.5
  TOP w0.089: UV6.J4 v3(174.21,120.68)
  IN2 w0.119: v3(182.2,111.03) 182.2,111.26 181.96,111.5 181.23,111.5 181.11,111.37 181.11,110.71 180.98,110.58 179.97,110.58 179.84,110.71 179.84,112.85 179.15,113.55 179.15,118.96 178.57,119.54 176.82,119.54 176.69,119.41 176.4,119.41 176.21,119.59 176.21,120.04 175.97,120.29 174.23,120.29 174.12,120.4 174.12,120.58 v3(174.21,120.68)
  BOTTOM w0.157: v3(182.2,111.03) 182.2,110.7 182.95,109.95 v1(182.95,108.88) 182.95,106.41 182.82,106.28 182.82,105.28 182.93,105.18 UV1.AA48
FBA_CAS#_H: length 23.2
  IN1 w0.119: v3(167.01,119.88) 166.63,119.49 166.63,114.14 166.55,114.06 166.55,113.44 166.95,113.04 v3(166.95,112.89)
  BOTTOM w0.089: v3(167.01,119.88) UV7.G3
  BOTTOM w0.157: UV1.BB49 166.4,106.56 166.2,106.76 164.92,106.76 164.71,106.96 164.71,107.96 164.53,108.14 164.27,108.14 164.08,107.96 164.08,106.92 163.89,106.73 163.63,106.73 163.44,106.92 v1(163.44,109.35) 163.44,112.22 164.32,113.1 166.73,113.1 v3(166.95,112.89)
FBA_CAS#_L: length 33.6
  TOP w0.089: 171.06,113.78 171.06,114.62 171.01,114.67 171.01,121.51 171.93,122.44 171.93,122.74 172.25,123.06 174.23,123.06 UV6.L3
  TOP w0.157: 171.06,113.78 v1(171.06,111.8) 171.06,111.45 174.05,108.45 178.55,108.45 178.69,108.59 179.85,108.59 180.57,107.88 181.77,107.88 182.73,106.91 184.76,106.91 186,105.67 v3(186,104.78)
  BOTTOM w0.089: UV1.U47 186.38,104.38 186,104.75 v3(186,104.78)
FBA_CKE_H: length 24.2
  IN1 w0.119: v3(167.01,121.48) 167.29,121.48 167.41,121.35 167.41,118.9 167.65,118.67 168.06,118.67 168.21,118.51 168.21,115.74 167.88,115.41 167.88,114.76 168,114.64 168.68,114.64 168.8,114.52 168.8,114.29 168.68,114.17 168,114.17 167.88,114.05 v3(167.88,112.98)
  BOTTOM w0.089: v3(167.01,121.48) UV7.J3
  BOTTOM w0.157: UV1.BA48 166.79,105.59 166.79,106.83 166.06,107.56 RV109.2 164.98,108.62 164.29,109.31 164.29,111.61 v1(164.79,112.11) 165.23,112.55 166.63,112.55 166.72,112.45 167.24,112.45 167.77,112.98 v3(167.88,112.98)
FBA_CKE_L: length 25.2
  TOP w0.13: v3(175.01,120.68) UV6.J3
  IN2 w0.119: v3(175.01,120.68) 175.07,120.74 176.31,120.74 177.06,119.98 178.76,119.98 179.53,119.22 179.53,113.94 v3(181.52,111.94)
  BOTTOM w0.089: UV1.U48 186.4,105.35 186.8,105.75 186.8,106.31 186.34,106.77 186.34,106.79
  BOTTOM w0.157: 186.34,106.79 RV110.2 185.71,110.37 185.71,110.99 185.05,111.65 184.03,111.65 183.29,112.38 v1(182.5,112.38) 181.96,112.38 v3(181.52,111.94)
FBA_CLK0: length 45.6
  TOP w0.13: UV6.J12 v3(167.81,120.68)
  TOP w0.14: RV123.1 162.64,121.88 163.46,121.88 v3(163.66,121.68)
  IN4 w0.112: v3(167.81,120.68) 167.62,120.87 165.04,120.87 164.02,121.88 163.87,121.88 v3(163.66,121.68)
  IN6 w0.119: v3(179.6,99.18) 179.83,99.18 179.96,99.05 179.96,98.87 179.83,98.74 177.2,98.74 176.21,97.75 173.87,97.75 173.56,98.06 173.56,98.51 173.79,98.75 173.79,105.99 171.52,108.26 168.79,108.26 164.91,112.13 164.91,120.04 165.74,120.87 167.62,120.87 v3(167.81,120.68)
  BOTTOM w0.112: UV1.AF41 v3(179.6,99.18)
FBA_CLK0#: length 45.7
  TOP w0.13: v3(167.81,121.4) 168.14,121.08 UV6.J11
  TOP w0.14: RV123.2 162.78,122.13 163.52,122.13 v3(163.66,122.26)
  IN4 w0.112: v3(167.81,121.4) 167.51,121.09 165.13,121.09 164.11,122.11 163.82,122.11 v3(163.66,122.26)
  IN6 w0.119: v3(167.81,121.4) 167.49,121.08 165.65,121.08 164.7,120.13 164.7,112.04 168.7,108.05 171.43,108.05 173.58,105.9 173.58,98.83 173.34,98.6 173.34,97.98 173.78,97.54 176.29,97.54 177.28,98.53 179.25,98.53 v3(179.6,98.18)
  BOTTOM w0.112: v3(179.6,98.18) 179.2,98.58 UV1.AF40
FBA_CLK1: length 43.9
  TOP w0.14: RV175.1 179.24,121.71 178.83,121.71 v3(178.63,121.5)
  IN2 w0.089: v3(174.21,121.48) 174.44,121.71 176.95,121.71 177,121.76 177.48,121.76
  IN2 w0.119: 177.48,121.76 178.37,121.76 v3(178.63,121.5)
  IN4 w0.112: v3(174.21,121.48) 173.88,121.14 173.88,120.88 173.6,120.6 171.84,120.6 171.58,120.34 171.58,119.69 171.69,119.58 171.98,119.58 172.21,119.35 172.21,118.84 171.98,118.61 171.69,118.61 171.58,118.5 171.58,117.34 171.69,117.23 172.01,117.23 172.24,116.99 172.24,116.49 172.01,116.26 171.69,116.26 171.58,116.14 171.58,115.64 171.83,115.39 172.02,115.39 172.27,115.15 172.27,114.67 172.02,114.42 171.83,114.42 171.72,114.31 171.72,113.42 171.9,113.24 172.06,113.24 173.56,114.73 173.91,114.73 174.24,114.39 174.24,114.04 172.75,112.55 172.75,112.39 172.94,112.2 172.94,111.48 173.82,110.6 174.18,110.6 174.37,110.4 174.53,110.4 174.87,110.74 175.22,110.74 175.56,110.41 175.56,110.06 175.22,109.71 175.22,109.55 175.46,109.32 175.61,109.32 175.96,109.66 176.31,109.66 176.64,109.32 176.64,108.97 176.3,108.63 176.3,108.47 176.54,108.24 176.7,108.24 177.04,108.58 177.39,108.58 177.73,108.24 177.73,107.89 177.38,107.55 177.38,107.39 177.86,106.92 177.86,106.6 178.6,105.85 178.6,102.18 178.37,101.94 177.56,101.94 v3(177.2,101.58)
  BOTTOM w0.089: UV7.J12 v3(174.21,121.48)
  BOTTOM w0.11: v3(177.2,101.58) 177.2,101.58 177.2,101.58 UV1.AJ44
FBA_CLK1#: length 44.3
  TOP w0.14: v3(178.63,122.09) 178.77,121.95 179.25,121.95 RV175.2
  IN2 w0.089: v3(173.41,121.48) 173.82,121.89 176.88,121.89 176.94,121.95 177.41,121.95 177.44,121.98 177.48,121.98
  IN2 w0.119: v3(178.63,122.09) 178.52,121.98 177.48,121.98
  IN4 w0.112: v3(173.41,121.48) 173.67,121.22 173.67,120.97 173.51,120.8 171.76,120.8 171.38,120.42 171.38,119.61 171.61,119.38 171.9,119.38 172.01,119.26 172.01,118.93 171.9,118.82 171.61,118.82 171.38,118.59 171.38,117.25 171.61,117.02 171.92,117.02 172.03,116.91 172.03,116.57 171.92,116.46 171.61,116.46 171.38,116.23 171.38,115.56 171.75,115.19 171.93,115.19 172.06,115.06 172.06,114.75 171.93,114.63 171.75,114.63 171.52,114.4 171.52,113.33 171.82,113.03 172.15,113.03 173.64,114.52 173.82,114.52 174.04,114.31 174.04,114.13 172.54,112.64 172.54,112.31 172.74,112.11 172.74,111.39 173.74,110.39 174.09,110.39 174.29,110.19 174.62,110.19 174.96,110.54 175.14,110.54 175.36,110.32 175.36,110.14 175.01,109.8 175.01,109.47 175.37,109.11 175.7,109.11 176.04,109.45 176.22,109.45 176.44,109.24 176.44,109.06 176.1,108.72 176.1,108.39 176.45,108.03 176.78,108.03 177.12,108.37 177.3,108.37 177.52,108.16 177.52,107.98 177.18,107.63 177.18,107.31 177.65,106.83 177.65,106.52 178.4,105.77 178.4,102.26 178.28,102.14 177.42,102.14 177.2,102.36 v3(177.2,102.38)
  BOTTOM w0.089: UV7.J11 v3(173.41,121.48)
  BOTTOM w0.11: UV1.AJ45 v3(177.2,102.38)
FBA_CS#_H: length 32.3
  IN1 w0.119: v3(175.9,111.24) 175.69,111.24 175.61,111.31 175.04,111.31 174.91,111.18 174.91,110.65 174.79,110.54 172.83,110.54 172.54,110.83 172.54,112.49 170.46,114.57 170.46,120.33 171.09,120.96 171.09,122.56 171.17,122.65 v3(171.33,122.65)
  BOTTOM w0.102: UV7.L12 174.21,123.08 172.34,123.08 172.09,123.33 172.09,123.75 171.9,123.93 171.9,125.13 171.67,125.36 170.98,125.36 170.77,125.15 170.77,123.51 170.86,123.43 171.33,122.96 v3(171.33,122.65)
  BOTTOM w0.157: v3(175.9,111.24) v1(176.82,110.31) 178.17,108.97 178.17,108.97 178.37,108.77 178.37,106.65 178.4,106.62 UV1.AG49
FBA_CS#_L: length 26.5
  TOP w0.089: UV6.G12 v3(167.01,119.08)
  IN1 w0.119: v3(176.76,111.24) 176.76,110.6 176.34,110.17 171.87,110.17 170.83,111.22 168.56,111.22 167.43,112.36 167.43,118.44 167.01,118.86 v3(167.01,119.08)
  BOTTOM w0.157: UV1.AF48 179.2,104.88 179.1,104.78 178.9,104.78 178.8,104.88 v1(178.8,108.24) 178.8,109.07 176.76,111.11 v3(176.76,111.24)
FBA_D0: length 21.5
  TOP w0.157: UV6.A4 173.81,114.18 v1(175.26,112.73) 175.9,112.09 v3(175.9,111.82)
  IN1 w0.119: v3(175.9,111.82) 176.06,111.66 177.57,111.66 180.41,108.83 180.41,108.03 181.43,107.01 181.43,102.03 182.28,101.18 184.8,101.18 v3(185.2,100.78)
  BOTTOM w0.089: UV1.V43 v3(185.2,100.78)
FBA_D1: length 22.8
  TOP w0.13: UV6.A2 175.41,114.63 v3(175.83,114.22)
  IN1 w0.119: v3(185.2,99.18) 186.02,99.99 186.02,102.95 185.38,103.58 184.19,103.58 183.92,103.85 183.92,106.25 182.51,107.66 182.51,109.2 182.16,109.55 181.37,109.55 178.36,112.55 178,112.91 176.51,112.91 176.23,113.2 176.23,113.82 v3(175.83,114.22)
  BOTTOM w0.089: UV1.V41 v3(185.2,99.18)
FBA_D2: length 20
  TOP w0.089: 175,113.78 174.12,114.65 174.12,114.8 173.81,115.11 UV6.B4
  TOP w0.157: 175,113.78 176.69,112.09 v3(176.86,112.09)
  IN1 w0.119: v3(185.2,101.58) 184.72,102.06 184.23,102.06 183.22,103.06 183.22,105.79 182.22,106.79 180.81,108.2 180.81,108.94 180.41,109.35 177.67,112.09 v3(176.86,112.09)
  BOTTOM w0.089: UV1.V44 v3(185.2,101.58)
FBA_D3: length 23.4
  TOP w0.089: UV6.B2 v3(175.81,115.88)
  IN1 w0.119: v3(185.2,99.98) 185.63,100.4 185.63,102.49 185.35,102.77 184.03,102.77 183.57,103.23 183.57,106.02 181.42,108.17 181.42,108.92 177.81,112.52 176.06,112.52 175.38,113.21 175.38,114.3 175.81,114.74 v3(175.81,115.88)
  BOTTOM w0.089: UV1.V42 v3(185.2,99.98)
FBA_D4: length 29.2
  TOP w0.089: UV6.E4 v3(174.21,118.28)
  IN1 w0.119: v3(174.21,118.28) 174.61,117.88 175.22,117.88 175.58,118.24 176.79,118.24 177.11,118.56 178.19,118.56 179.45,117.29 179.45,114.55 181.24,112.76 182.5,112.76 186.63,108.63 186.63,106.28 188.15,104.76 188.15,101.4 187.94,101.18 187.23,101.18 186.82,100.78 v3(186.8,100.78)
  BOTTOM w0.089: UV1.U43 v3(186.8,100.78)
FBA_D5: length 24.4
  TOP w0.089: 176.92,118.21 175.75,118.21 UV6.E2
  TOP w0.157: v3(177.25,118.09) 177.13,118.21 176.92,118.21
  IN1 w0.119: v3(177.25,118.09) 178.03,117.32 178.03,115.36 178.35,115.04 178.83,115.04 179.06,114.81 179.06,114.36 181.05,112.37 182.27,112.37 186.06,108.58 186.06,106.2 186.83,105.42 186.83,104.48 187.2,104.12 187.2,101.98 187.2,101.98 v3(186.8,101.58)
  BOTTOM w0.089: UV1.U44 v3(186.8,101.58)
FBA_D6: length 32.7
  TOP w0.089: UV6.F4 v3(173.41,118.28)
  IN1 w0.119: v3(173.41,118.28) 173.61,118.28 174,118.67 175.13,118.67 175.41,118.95 175.41,119.21 175.66,119.46 178.27,119.46 180.21,117.52 180.21,116.33 182.95,113.58 183.39,113.58 187.39,109.58 187.39,106.67 188.79,105.27 188.79,100.93 187.98,100.12 187.98,99.83 187.33,99.18 v3(186.8,99.18)
  BOTTOM w0.089: UV1.U41 v3(186.8,99.18)
FBA_D7: length 29
  TOP w0.089: UV6.F2 v3(175.81,119.08)
  IN1 w0.119: v3(175.81,119.08) 178.16,119.08 179.86,117.37 179.86,114.72 181.41,113.17 183.3,113.17 187.04,109.43 187.04,106.54 188.47,105.11 188.47,100.99 187.87,100.4 187.22,100.4 v3(186.8,99.98)
  BOTTOM w0.089: UV1.U42 v3(186.8,99.98)
FBA_D8: length 22.8
  TOP w0.157: UV6.A11 168.21,114.04 168.58,113.67 v3(168.61,113.67)
  IN6 w0.119: v3(182.8,103.98) 183.28,104.45 183.28,105.4 182.48,106.2 181.79,106.2 181.64,106.05 179.47,106.05 179.16,106.36 179.16,107.18 177.14,109.2 174.47,109.2 172.52,111.15 170.35,111.15 169.61,111.89 169.61,113.11 169.05,113.67 v3(168.61,113.67)
  BOTTOM w0.089: UV1.AA46 v3(182.8,103.98)
FBA_D9: length 23.3
  TOP w0.089: UV6.A13 166.61,113.86 166.52,113.78
  TOP w0.157: v3(166.96,111.26) 167.05,111.26 167.39,111.59 167.39,111.75 167.39,111.75 167.39,111.98 166.93,112.44 166.68,112.44 166.5,112.61 166.5,113.76 166.52,113.78
  IN6 w0.119: v3(182,103.98) 180.83,105.15 179.38,105.15 178.45,106.08 178.45,106.91 176.85,108.5 174.18,108.5 172.38,110.3 169.63,110.3 168.67,111.26 v3(166.96,111.26)
  BOTTOM w0.089: UV1.AC46 v3(182,103.98)
FBA_D10: length 24.7
  TOP w0.13: UV6.B11 167.81,115.08 167.81,114.39 167.41,113.99
  TOP w0.157: 167.41,113.99 167.41,112.77 168.47,111.71 v3(168.47,110.82)
  IN6 w0.119: v3(182.8,103.18) 182.39,103.58 179.25,103.58 178.88,103.95 178.88,105.13 178.18,105.83 178.18,106.68 176.71,108.16 174.03,108.16 172.25,109.94 169.35,109.94 v3(168.47,110.82)
  BOTTOM w0.089: UV1.AA45 v3(182.8,103.18)
FBA_D11: length 24.5
  TOP w0.089: 166.21,114.26 165.99,114.04
  TOP w0.13: UV6.B13 166.21,115.08 166.21,114.26
  TOP w0.157: 165.99,114.04 165.83,113.87 v1(165.83,112.71) 165.83,112.49 166.47,111.84 v3(166.84,111.84)
  IN6 w0.119: v3(182.8,104.78) 182.75,104.78 181.95,105.58 179.44,105.58 178.81,106.21 178.81,107.04 177,108.85 174.32,108.85 172.43,110.75 169.75,110.75 168.66,111.84 v3(166.84,111.84)
  BOTTOM w0.089: UV1.AA47 v3(182.8,104.78)
FBA_D12: length 27.4
  TOP w0.13: v3(167.81,117.48) UV6.E11
  IN6 w0.119: v3(184.4,103.98) 184.4,104.23 185.42,105.25 185.42,106.65 184.19,107.88 184.19,109.8 183.8,110.19 179.37,110.19 177,112.56 175.61,112.56 174.27,113.9 173.26,113.9 170.7,116.47 169.68,117.48 v3(167.81,117.48)
  BOTTOM w0.089: UV1.Y46 v3(184.4,103.98)
FBA_D13: length 24.7
  TOP w0.13: UV6.E13 v3(166.21,117.48)
  IN6 w0.119: v3(184.33,106.5) 183.85,106.5 182.86,107.48 182.23,107.48 180.53,109.18 179.19,109.18 177.9,110.47 175.51,110.47 174.88,111.1 174.88,112.09 173.89,113.09 172.92,113.09 172.23,113.78 169.74,116.27 167.69,116.27 167.44,116.52 167.44,116.87 167.23,117.08 166.61,117.08 v3(166.21,117.48)
  BOTTOM w0.089: v3(184.33,106.5) 184.33,106.31 UV1.Y49
FBA_D14: length 28.9
  TOP w0.13: UV6.F11 v3(168.61,119.08)
  IN6 w0.119: v3(184.4,103.18) 184.8,103.58 184.8,104.17 185.78,105.14 185.78,106.87 184.6,108.05 184.6,109.9 183.92,110.58 179.53,110.58 177.55,112.56 177.2,112.91 175.84,112.91 174.09,114.66 173.16,114.66 171.2,116.62 171.2,117.02 169.57,118.66 169.56,118.66 169.55,118.67 169.02,118.67 v3(168.61,119.08)
  BOTTOM w0.089: UV1.Y45 v3(184.4,103.18)
FBA_D15: length 26.9
  TOP w0.13: v3(167.01,118.28) UV6.F13
  IN6 w0.119: v3(167.01,118.28) 167.41,117.88 167.41,117.3 167.63,117.08 169.67,117.08 170.19,116.56 170.19,116.4 173.09,113.5 174.06,113.5 175.46,112.1 175.46,111.09 175.73,110.82 178.13,110.82 179.36,109.59 182.23,109.59 182.76,109.06 182.76,108.42 183.27,107.9 183.48,107.9 185.12,106.26 185.12,105.84 184.85,105.58 v3(184.4,105.58)
  BOTTOM w0.089: UV1.Y48 v3(184.4,105.58)
FBA_D16: length 48.6
  TOP w0.13: v3(167.81,128.68) 168.22,128.27 168.22,127.49 UV6.U11
  IN1 w0.119: v3(167.81,128.68) 167.79,128.7 166.92,129.57 164.35,129.57 161.86,127.08 161.86,125.72 159.46,123.31 159.46,110.3 160.97,108.79 160.97,107.36 161.53,106.79 163.95,104.37 168.76,104.37 169.55,103.58 176.81,103.58 v3(177.2,103.98)
  BOTTOM w0.089: UV1.AJ46 v3(177.2,103.98)
FBA_D17: length 44.1
  TOP w0.13: v3(166.25,128.68) 166.27,128.68 166.61,128.34 UV6.U13
  IN1 w0.119: v3(178,104.78) 177.75,104.78 177.35,105.18 172.82,105.18 172.01,105.98 164.88,105.98 160.15,110.71 160.15,123.02 162.56,125.43 162.56,126.51 162.99,126.94 163.49,126.94 163.76,127.21 163.76,127.93 164.53,128.7 166.23,128.7 v3(166.25,128.68)
  BOTTOM w0.089: UV1.AG47 v3(178,104.78)
FBA_D18: length 50.4
  TOP w0.089: UV6.T11 168.61,127.08 v3(169.41,127.08)
  IN1 w0.119: v3(169.41,127.08) 169.41,127.67 168.81,128.27 167.38,128.27 166.49,129.16 164.47,129.16 162.21,126.9 162.21,125.57 159.8,123.16 159.8,110.56 161.38,108.99 161.38,107.53 162.11,106.79 163.73,105.17 169.8,105.17 170.58,104.4 177.58,104.4 v3(178,103.98)
  BOTTOM w0.089: UV1.AG46 v3(178,103.98)
FBA_D19: length 43.3
  TOP w0.089: v3(166.21,127.08) UV6.T13
  IN1 w0.119: v3(166.21,127.08) 165.82,127.47 164.78,127.47 163.89,126.58 163.12,126.58 162.91,126.37 162.91,124.64 161.06,122.8 161.06,110.38 164.67,106.77 173.1,106.77 173.92,105.95 175.76,105.95 176.16,105.55 177.78,105.55 178.42,104.9 178.42,103.6 v3(178,103.18)
  BOTTOM w0.089: UV1.AG45 v3(178,103.18)
FBA_D20: length 43.6
  TOP w0.13: UV6.N11 167.87,124.28 167.55,124.6 167.15,124.6 v3(167.01,124.74)
  IN1 w0.119: v3(179.6,101.58) 179.21,101.97 179.21,105.68 178.77,106.13 178.77,106.74 177.28,108.23 165.36,108.23 162.52,111.07 162.52,122.46 164.34,124.27 164.34,125.31 164.52,125.49 165.58,125.49 166.33,124.74 v3(167.01,124.74)
  BOTTOM w0.089: v3(179.6,101.58) UV1.AF44
FBA_D21: length 40.5
  TOP w0.089: v3(164.73,125.08) 165.17,124.64 166.37,124.64 166.61,124.39 UV6.N13
  IN1 w0.119: v3(164.73,125.08) 164.73,124.17 162.93,122.37 162.93,111.24 165.52,108.64 177.45,108.64 179.17,106.91 179.17,106.3 179.73,105.74 179.73,104.4 179.99,104.14 179.99,102.76 v3(179.6,102.38)
  BOTTOM w0.089: UV1.AF45 v3(179.6,102.38)
FBA_D22: length 40.1
  TOP w0.13: v3(168.61,123.08) UV6.M11
  IN1 w0.119: v3(180.4,103.98) 180.56,104.13 180.56,105.63 180.01,106.17 180.01,107.33 179.76,107.58 179.11,107.58 177.69,109.01 166.42,109.01 163.86,111.57 163.86,121.25 164.09,121.48 164.09,123.04 165.3,124.25 167.97,124.25 168.22,124 168.22,123.47 v3(168.61,123.08)
  BOTTOM w0.089: UV1.AD46 v3(180.4,103.98)
FBA_D23: length 39.1
  TOP w0.13: UV6.M13 166.66,123.48 v3(167.01,123.83)
  IN1 w0.119: v3(167.01,123.83) 166.61,123.42 166.03,123.42 164.52,121.91 164.52,121.41 164.23,121.12 164.23,111.72 166.18,109.77 168.82,109.77 168.95,109.9 171.06,109.9 171.58,109.37 177.12,109.37 177.24,109.49 177.24,109.64 177.36,109.76 177.6,109.76 177.72,109.64 177.72,109.49 177.84,109.37 178.07,109.37 178.19,109.49 178.19,109.64 178.31,109.76 178.55,109.76 178.67,109.64 178.67,109.49 178.79,109.37 179.23,109.37 180.01,108.59 180.01,107.84 180.41,107.45 180.41,106.31 181.17,105.55 181.17,103.94 v3(180.4,103.18)
  BOTTOM w0.089: UV1.AD45 v3(180.4,103.18)
FBA_D24: length 30.3
  TOP w0.089: UV6.U4 v3(174.21,127.88)
  IN4 w0.112: v3(180.4,101.58) 179.99,101.98 179.99,104.14 179.72,104.41 179.72,105.97 180.03,106.28 180.03,108.38 177.79,110.61 177.79,111.82 176.22,113.39 176.22,120.06 175.83,120.45 175.83,121.57 175.41,121.99 175.41,123.24 174.62,124.03 174.62,127.47 v3(174.21,127.88)
  BOTTOM w0.089: UV1.AD44 v3(180.4,101.58)
FBA_D25: length 33.8
  TOP w0.089: UV6.U2 175.41,128.11 175.2,128.32 173.85,128.32 v3(173.41,127.88)
  IN4 w0.112: v3(173.41,127.88) 173.81,127.49 173.81,123.36 174.62,122.55 174.62,122.12 175.41,121.33 175.41,114.8 175.36,114.76 175.36,112.97 176.33,112 176.33,111.06 179.03,108.36 179.03,106.53 179.2,106.35 179.2,101.42 179.44,101.18 179.79,101.18 180.2,100.78 v3(180.4,100.78)
  BOTTOM w0.089: UV1.AD43 v3(180.4,100.78)
FBA_D26: length 33.7
  TOP w0.089: v3(171.33,124) 171.65,124.32 171.65,125.84 172.18,126.37 173.51,126.37 UV6.T4
  IN4 w0.112: v3(171.33,124) 172.25,123.09 172.85,123.09 174.07,121.87 174.38,121.87 174.62,121.63 174.62,112.45 174.89,112.19 174.89,111.67 178.39,108.17 178.39,106.53 178.94,105.98 178.94,100.89 179.45,100.38 180,100.38 v3(180.4,99.98)
  BOTTOM w0.089: UV1.AD42 v3(180.4,99.98)
FBA_D27: length 35.5
  TOP w0.089: UV6.T2 175.78,127.04 175.78,128.63 175.85,128.7
  TOP w0.157: 175.85,128.7 v3(176.14,128.99)
  IN4 w0.112: v3(176.14,128.99) 177.04,128.09 177.04,124.08 177.55,123.57 177.55,123.21 177.98,122.78 177.98,121.54 178.59,120.93 179.83,120.93 180.34,120.42 180.34,111.03 181.86,109.51 182.22,109.51 182.47,109.26 182.47,106.66 182.01,106.19 182.01,105.38 182.39,105 182.39,101.17 v3(182,100.78)
  BOTTOM w0.089: UV1.AC42 v3(182,100.78)
FBA_D28: length 30
  TOP w0.089: 176.92,124.16 176.85,124.16 176.67,123.97 174.12,123.97 UV6.N4
  TOP w0.157: 176.92,124.16 v3(177.86,124.16)
  IN4 w0.112: v3(177.86,124.16) 178,124.02 178,123.47 180.78,120.68 180.78,111.21 182.04,109.95 182.4,109.95 183.04,109.32 183.04,105.18 183.19,105.02 183.19,101.97 v3(182.8,101.58)
  BOTTOM w0.089: v3(182.8,101.58) UV1.AA44
FBA_D29: length 30.5
  TOP w0.089: UV6.N2 175.77,124.63 176.2,124.63 176.52,124.95 176.92,124.95
  TOP w0.157: 176.92,124.95 v3(177.86,124.95)
  IN4 w0.112: v3(177.86,124.95) 177.86,124.76 178.44,124.18 178.44,123.65 181.66,120.44 181.66,112.99 182.88,111.77 182.88,111.07 184.03,109.92 184.03,107.41 183.55,106.93 183.55,101.52 v3(182.8,100.78)
  BOTTOM w0.089: v3(182.8,100.78) UV1.AA43
FBA_D30: length 32.4
  TOP w0.089: 176.92,123.58 176.57,123.58 176.37,123.78 174.12,123.78 UV6.M4
  TOP w0.157: 176.92,123.58 178.86,123.58 v3(179.02,123.74)
  IN4 w0.112: v3(179.02,123.74) 181.88,120.87 182.11,120.65 182.11,113.17 183.33,111.95 183.33,111.26 184.48,110.11 184.48,107.23 183.93,106.68 183.93,100.31 v3(183.6,99.98)
  BOTTOM w0.089: UV1.AA42 v3(183.6,99.98)
FBA_D31: length 29.4
  TOP w0.089: UV6.M2 v3(175.81,123.08)
  IN4 w0.112: v3(175.81,123.08) 175.81,122.83 176.21,122.43 176.21,120.93 177.04,120.11 177.04,119.15 177.68,118.51 177.68,113.88 178.24,113.32 178.24,110.8 180.48,108.56 180.48,106.75 180.43,106.7 180.43,105.51 180.86,105.08 180.86,100.38 181.62,99.62 181.62,98.91 182.35,98.18 v3(182.8,98.18)
  BOTTOM w0.089: UV1.AA40 v3(182.8,98.18)
FBA_D32: length 28.4
  IN2 w0.119: v3(170.8,105.58) 171.25,106.02 171.25,107.06 169.9,108.41 169.9,114.65 170.45,115.2 170.45,118.04 171.33,118.91 171.33,121.82 171.93,122.43 171.93,124.45 171.2,125.19 171.2,126.84 169.36,128.68 v3(168.61,128.68)
  BOTTOM w0.089: UV1.AT48 v3(170.8,105.58) ; UV7.U4 168.21,128.28 v3(168.61,128.68)
FBA_D33: length 31.5
  IN2 w0.119: v3(170.8,103.98) 169.61,105.17 169.61,106.8 167.43,108.98 167.43,114.94 168.22,115.73 168.22,119.24 168.45,119.47 169.56,119.47 170.2,120.11 170.2,126.05 169.58,126.67 166.87,126.67 166.6,126.93 166.6,127.49 v3(166.21,127.88)
  BOTTOM w0.089: UV1.AT46 v3(170.8,103.98)
  BOTTOM w0.13: UV7.U2 v3(166.21,127.88)
FBA_D34: length 26.9
  IN2 w0.119: v3(170.8,106.38) 170.8,106.75 170.8,106.75 170.8,106.87 169.45,108.23 169.45,114.56 170,115.11 170,118.29 170.8,119.09 170.8,122.89 171.71,123.79 171.71,124.23 170.94,125 170.94,126.65 169.71,127.88 v3(168.61,127.88)
  BOTTOM w0.089: UV7.T4 168.61,127.08 v3(168.61,127.88) ; UV1.AT49 v3(170.8,106.38)
FBA_D35: length 29.1
  IN2 w0.119: v3(170.8,104.78) 170.39,105.18 170.39,106.65 168.97,108.08 168.97,111.45 168.39,112.03 168.39,113.21 168.18,113.42 168.18,113.79 169.02,114.63 169.02,118.44 169.25,118.67 169.56,118.67 170.45,119.56 170.45,126.6 169.58,127.47 167.41,127.47 v3(167.01,127.08)
  BOTTOM w0.089: v3(170.8,104.78) 171.02,104.56 UV1.AT47 ; UV7.T2 v3(167.01,127.08)
FBA_D36: length 30.9
  IN2 w0.119: v3(168.61,124.63) 168.61,124.68 168.22,124.29 166.41,124.29 166.17,124.52 164.45,124.52 162.84,122.92 162.84,122.07 161.99,121.22 161.99,110.15 165.35,106.79 166.41,105.73 166.41,104.61 167.44,103.58 168.01,103.58 v3(168.4,103.98)
  BOTTOM w0.089: UV7.N4 168.26,124.28 v3(168.61,124.63) ; UV1.AW47 v3(168.4,103.98)
FBA_D37: length 26.4
  IN2 w0.119: v3(165.04,123.03) 164.85,122.84 164.85,121.19 163.87,120.21 163.87,110.23 168.4,105.7 v3(168.4,105.58)
  BOTTOM w0.089: v3(168.4,105.58) UV1.AW48 ; v3(165.04,123.03) 165.04,123.18 164.95,123.27 164.39,123.27 164.3,123.36 164.3,123.54 164.39,123.63 164.95,123.63 165.04,123.72 165.04,123.89 164.95,123.98 164.39,123.98 164.3,124.07 164.3,124.25 164.39,124.34 164.95,124.34 165.04,124.43 165.04,124.55 165.2,124.72 166.5,124.72 166.61,124.6 UV7.N2
FBA_D38: length 27.5
  IN2 w0.119: v3(168.61,123.88) 168.17,123.43 164.56,123.43 164.15,123.02 164.15,121.5 163.83,121.19 163.31,121.19 162.88,120.76 162.88,110.59 167.48,106 167.74,106 167.99,105.74 167.99,105.17 v3(167.6,104.78)
  BOTTOM w0.089: UV7.M4 v3(168.61,123.88) ; v3(167.6,104.78) UV1.BA47
FBA_D39: length 28.2
  IN2 w0.119: v3(168.4,103.18) 168.79,103.57 168.79,104.14 168.56,104.37 167.45,104.37 167.21,104.61 167.21,105.56 165.98,106.79 162.44,110.33 162.44,121.13 163.25,121.94 163.25,122.69 164.83,124.27 165.82,124.27 166.21,123.88 v3(166.21,123.83)
  BOTTOM w0.089: v3(166.21,123.83) 166.26,123.83 UV7.M2 ; v3(168.4,103.18) UV1.AW46
FBA_D40: length 47.3
  IN6 w0.119: v3(172.4,103.98) 172.16,104.22 172.16,104.43 171.22,105.36 171.22,105.75 171.02,105.96 167.63,105.96 166.53,107.05 166.37,107.05 165.62,106.3 165.44,106.3 165.28,106.46 165.28,106.64 166.07,107.43 166.07,107.61 165.91,107.77 165.73,107.77 165.08,107.12 164.9,107.12 164.75,107.28 164.75,107.46 165.39,108.1 165.39,108.28 165.23,108.45 165.05,108.45 164.4,107.81 164.22,107.81 164.07,107.96 164.07,108.14 164.67,108.75 164.67,108.92 164.41,109.18 164.24,109.18 164.08,109.02 163.9,109.02 163.74,109.18 163.74,109.36 163.9,109.52 163.9,109.69 163.73,109.86 163.56,109.86 163.54,109.84 163.36,109.84 163.2,109.99 163.2,110.17 163.22,110.2 163.22,110.36 162.52,111.07 162.52,121.49 162.63,121.6 163.12,121.6 163.24,121.71 163.24,121.94 163.12,122.05 162.63,122.05 162.52,122.16 162.52,122.72 164.43,124.63 166,124.63 166.51,125.14 167.36,125.14 167.42,125.07 169.97,125.07 172.1,127.21 173.29,127.21 v3(173.41,127.08)
  BOTTOM w0.089: UV7.U11 v3(173.41,127.08) ; UV1.AR46 v3(172.4,103.98)
FBA_D41: length 50.9
  IN6 w0.119: v3(172.59,101.59) 172.14,101.59 170.94,102.79 165.9,102.79 160.68,108.01 160.68,113.06 160.04,113.69 160.04,122.91 160.7,123.57 160.83,123.57 162.74,125.48 162.74,126.35 163.11,126.72 163.69,126.72 165.23,128.26 170.08,128.26 170.84,129.02 174.68,129.02 v3(175.01,128.68)
  BOTTOM w0.089: UV7.U13 175.41,128.28 v3(175.01,128.68) ; UV1.AN45 173.6,102.58 172.61,101.59 v3(172.59,101.59)
FBA_D42: length 44.8
  IN6 w0.089: v3(174.21,127.08) 174.21,126.79 173.85,126.43 173.33,126.43 173.24,126.34 173.24,125.82 173.14,125.71 172.99,125.71 172.89,125.82 172.89,126.34 172.8,126.43 172.34,126.43 172.22,126.31 172.09,126.31 171.86,126.53 171.72,126.53 171.61,126.43 171.61,126.28 172.25,125.64 172.25,125.49 172.15,125.39 172,125.39 171.36,126.03 171.21,126.03 171.11,125.92 171.11,125.78 171.73,125.16 171.73,125.01 171.63,124.9 171.48,124.9 170.86,125.53 170.71,125.53 170.61,125.42 170.61,125.27 170.98,124.9 170.98,124.75 170.88,124.65 170.73,124.65 170.35,125.03 170.22,125.03 170.09,124.91 170.09,124.78 170.33,124.54 170.33,124.42 170.17,124.26 169.26,124.26 169.25,124.25 164.75,124.25
  IN6 w0.119: 164.75,124.25 164.1,123.6 164.1,121.32 163.84,121.06 163.07,121.06 162.93,120.92 162.93,111.24 167.38,106.78 170.94,106.78 171.76,105.97 171.76,105.73 v3(171.6,105.58)
  BOTTOM w0.089: UV7.T11 v3(174.21,127.08) ; UV1.AR49 v3(171.6,105.58)
