# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D43: length 46.5
  IN6 w0.119: v3(172.4,104.78) 172.04,105.14 172.04,106.17 171.05,107.16 168.3,107.16 164.5,110.95 164.33,110.95 164.11,110.73 163.93,110.73 163.77,110.89 163.77,111.07 163.99,111.29 163.99,111.46 163.82,111.64 163.82,111.96 163.7,112.08 163.4,112.08 163.28,112.2 163.28,112.43 163.4,112.55 163.74,112.55 163.86,112.68 163.86,112.9 163.74,113.03 163.41,113.03 163.28,113.16 163.28,113.38 163.41,113.51 163.7,113.51 163.82,113.63 163.82,120.46 164.4,121.04 164.4,123.11 164.74,123.45 168.21,123.45 168.25,123.48 170,123.48 170.99,124.47 171.62,124.47 172.2,125.06 172.84,125.06 172.96,124.94 172.96,124.35 173.08,124.23 173.32,124.23 173.44,124.35 173.44,124.94 173.56,125.06 176.11,125.06 176.24,125.18 176.24,128.09 v3(176.14,128.19)
  BOTTOM w0.089: UV7.T13 175.51,126.58 175.62,126.58 175.72,126.68 175.72,126.86 175.57,127.01 175.57,127.18 175.72,127.33 175.72,128.25 175.82,128.35 175.98,128.35 v3(176.14,128.19) ; UV1.AR48 v3(172.4,104.78)
FBA_D44: length 47.3
  IN6 w0.119: v3(172.09,128.63) 171.13,128.63 169.97,127.47 165.22,127.47 161.03,123.27 161.03,109.18 163.96,106.24 163.96,106.08 163.77,105.89 163.77,105.71 163.96,105.51 164.14,105.51 164.33,105.7 164.5,105.7 164.77,105.43 164.77,104.46 165.65,103.58 170.66,103.58 170.8,103.45 v3(170.8,103.18)
  BOTTOM w0.089: UV1.AT45 v3(170.8,103.18) ; v3(172.09,128.63) 172.07,128.61 172.07,125.86 172.25,125.68 172.25,125.33 172.29,125.29 172.29,124.88 172.49,124.68 173.1,124.68 173.5,124.28 UV7.N11
FBA_D45: length 47.9
  IN6 w0.119: v3(173.2,103.18) 173.2,105.11 172.35,105.97 172.35,106.42 171.2,107.57 168.56,107.57 164.21,111.92 164.21,120.23 164.91,120.93 164.91,121.67 165.11,121.87 168.19,121.87 168.31,121.99 168.31,122.56 168.43,122.68 168.67,122.68 168.79,122.56 168.79,121.99 168.91,121.87 169.48,121.87 169.77,122.15 169.93,122.15 171.09,121 171.26,121 171.42,121.17 171.42,121.34 170.33,122.43 170.33,122.62 170.94,123.23 171.26,123.23 171.91,123.88 172.84,123.88 172.96,123.76 172.96,122.63 173.08,122.51 173.32,122.51 173.44,122.63 173.44,123.76 173.55,123.88 176.13,123.88 176.25,124 176.25,124.55 176.13,124.68 v3(175.01,124.68)
  BOTTOM w0.089: UV7.N13 v3(175.01,124.68) ; UV1.AR44 172.55,101.98 173.2,102.63 v3(173.2,103.18)
FBA_D46: length 55.1
  IN6 w0.119: v3(167.83,129.76) 164.57,129.76 162.04,127.23 162.04,125.77 160.54,124.27 160.41,124.27 159.35,123.2 159.35,113.4 159.98,112.77 159.98,107.6 166.38,101.2 170.99,101.2 173.01,99.18 v3(173.2,99.18)
  BOTTOM w0.089: UV7.M11 173.41,123.88 172.35,123.88 172.1,124.13 172.1,125.21 172.06,125.25 172.06,125.6 171.88,125.78 171.88,126.53 169.72,128.7 ; UV1.AN41 v3(173.2,99.18)
  BOTTOM w0.157: 169.72,128.7 169.17,129.25 168.34,129.25 v3(167.83,129.76)
FBA_D47: length 60.2
  IN6 w0.119: v3(177.86,125.59) 177.23,126.21 177.23,127.85 176.51,128.58 175.94,128.58 175.09,129.42 170.67,129.42 170.37,129.12 164.43,129.12 162.39,127.08 162.39,125.63 160.68,123.92 160.56,123.92 159.7,123.06 159.7,113.55 160.33,112.91 160.33,107.86 166.04,102.15 170.81,102.15 171.19,101.76 171.19,101.42 172.63,99.98 v3(173.2,99.98)
  BOTTOM w0.089: UV7.M13 175.83,123.89 176.67,123.89 176.92,124.14 ; UV1.AN42 v3(173.2,99.98)
  BOTTOM w0.157: 176.92,124.14 177.1,124.32 177.1,124.83 v3(177.86,125.59)
FBA_D48: length 21.3
  IN2 w0.119: v3(177.55,113.39) 178.69,112.26 178.69,109.89 179.16,109.42 179.16,100.21 178.82,99.87 v3(178.82,99.21)
  BOTTOM w0.089: UV1.AG40 178.4,98.8 v3(178.82,99.21)
  BOTTOM w0.157: UV7.A11 174.34,114.15 174.34,113.52 175.51,112.35 176.38,112.35 176.7,112.66 v1(177.13,112.66) 177.55,113.09 v3(177.55,113.39)
FBA_D49: length 17.3
  IN2 w0.119: v3(178.06,100.8) 178.06,100.83 178.46,101.23 178.46,105.35 178.24,105.57 178.24,108.99 177.79,109.44 177.79,109.91 177.64,110.06 177.06,110.06 176.93,110.18 176.93,110.53 177.06,110.66 177.64,110.66 177.79,110.81 177.79,111.76 176.62,112.94 176.51,112.94 v3(175.79,113.66)
  BOTTOM w0.089: UV7.A13 175.41,114.04 175.68,113.78 ; v3(178.06,100.8) 178.06,100.83 UV1.AG43
  BOTTOM w0.157: 175.68,113.78 v3(175.79,113.66)
FBA_D50: length 20.5
  IN2 w0.119: v3(178,99.18) 178,99.41 178.71,100.12 178.71,109.18 178.24,109.65 178.24,112.01 v3(176.86,113.39)
  BOTTOM w0.089: UV1.AG41 v3(178,99.18) ; 175.03,113.78 175.03,113.83 174.31,114.55 174.31,114.67 173.81,115.17 UV7.B11
  BOTTOM w0.157: 175.03,113.78 175.03,113.62 175.67,112.98 176.1,112.98 176.51,113.39 v3(176.86,113.39)
FBA_D51: length 19.7
  IN2 w0.119: v3(176.64,115.23) 176.47,115.41 176.25,115.41 175.34,114.5 175.34,113.19 176.33,112.2 176.33,110.15 177.39,109.09 177.39,108.86 177.54,108.71 177.67,108.71 177.79,108.59 177.79,108.24 177.67,108.11 177.54,108.11 177.39,107.96 177.39,107.67 177.54,107.52 177.67,107.52 177.79,107.39 177.79,107.04 177.67,106.92 177.54,106.92 177.39,106.77 177.39,106.39 176.81,105.8 176.81,101.17 v3(177.2,100.78)
  BOTTOM w0.089: UV1.AJ43 v3(177.2,100.78) ; UV7.B13 175.81,115.08 176.5,115.08 v3(176.64,115.23)
FBA_D52: length 21.9
  IN2 w0.119: v3(174.21,117.48) 173.81,117.07 173.81,116.02 172.79,115.01 172.79,109.81 176,106.6 176,100.62 177.19,99.42 177.2,99.42 v3(177.2,99.18)
  BOTTOM w0.089: v3(174.21,117.48) UV7.E11 ; UV1.AJ40 v3(177.2,99.18)
FBA_D53: length 30.2
  IN2 w0.119: v3(177.24,117.46) 176.82,117.87 172.45,117.87 172.02,117.44 172.02,115.45 171.59,115.02 171.59,110.52 174.62,107.49 174.62,105.8 175.2,105.23 175.2,100.62 175.45,100.37 175.76,100.37 175.99,100.14 175.99,98.57 v3(175.6,98.18)
  BOTTOM w0.089: UV1.AK40 176,98.58 v3(175.6,98.18) ; 176.92,117.78 176.51,118.18 175.72,118.18 UV7.E13
  BOTTOM w0.157: 176.92,117.78 v3(177.24,117.46)
FBA_D54: length 23.6
  IN2 w0.119: v3(175.6,99.98) 175.41,99.98 175.01,100.38 174.65,100.38 174.18,100.85 174.18,107.44 171.25,110.37 171.25,115.24 171.35,115.34 171.35,117.56 172.47,118.69 173.02,118.69 v3(173.41,119.08)
  BOTTOM w0.089: UV1.AK42 v3(175.6,99.98)
  BOTTOM w0.13: UV7.F11 v3(173.41,119.08)
FBA_D55: length 30.1
  IN2 w0.119: v3(176.7,118.69) 176.64,118.69 176.64,118.69 174.05,118.69 173.82,118.92 173.82,119.23 173.58,119.47 172.45,119.47 172.22,119.24 170.9,117.92 170.9,110.13 171.54,109.49 173.6,107.43 173.6,100.65 174.69,99.55 175.22,99.55 v3(175.6,99.18)
  BOTTOM w0.089: UV1.AK41 v3(175.6,99.18) ; v3(176.7,118.69) 176.39,118.37 175.72,118.37 UV7.F13
FBA_D56: length 20.7
  IN4 w0.112: v3(168.61,115.08) 167.96,115.08 167.83,114.95 167.83,114.64 167.96,114.52 168.85,114.52 169.1,114.27 169.1,113.52 169.3,113.32 169.51,113.32 169.9,113.72 170.08,113.72 170.33,113.47 170.33,113.29 169.93,112.9 169.93,112.69 173.89,108.73 174.36,108.73 176.35,106.74 176.58,106.51 176.58,105.42 176.35,105.18 176.35,104.34 176.09,104.08 176.09,103.74 176.35,103.48 176.35,103.15 176.29,103.09 175.69,103.09 v3(175.6,103.18)
  BOTTOM w0.089: UV1.AK45 v3(175.6,103.18) ; UV7.A4 v3(168.61,115.08)
FBA_D57: length 24
  IN4 w0.112: v3(175.6,100.78) 175.6,100.46 175.73,100.33 176.22,100.33 176.35,100.46 176.35,101.51 176.2,101.66 176.04,101.66 175.91,101.78 175.91,102.13 176.04,102.25 176.22,102.25 176.35,102.38 176.35,102.64 176.22,102.77 175.3,102.77 175.17,102.9 175.17,104.25 175.3,104.38 175.76,104.38 176.05,104.67 176.05,106.41 175.01,107.45 174.8,107.45 174.68,107.34 174.5,107.34 174.25,107.58 174.25,107.76 174.37,107.88 174.37,108.09 174.17,108.29 173.7,108.29 170.04,111.95 168.24,111.95 167.45,112.74 167.45,113.22 167.06,113.61 v3(166.96,113.61)
  BOTTOM w0.089: 166.8,113.78 166.61,113.96 UV7.A2 ; UV1.AK43 v3(175.6,100.78)
  BOTTOM w0.157: 166.8,113.78 v3(166.96,113.61)
FBA_D58: length 21.8
  IN4 w0.112: v3(167.86,110.82) 167.86,110.63 168.37,110.12 168.88,110.12 169.73,110.97 169.91,110.97 170.15,110.72 170.15,110.54 169.3,109.69 169.3,109.48 169.76,109.03 171.2,109.03 171.39,108.83 171.6,108.83 171.73,108.96 171.91,108.96 172.16,108.72 172.16,108.54 171.92,108.3 171.92,108.12 172.17,107.88 172.35,107.88 172.58,108.11 172.76,108.11 173.01,107.87 173.01,107.69 172.77,107.45 172.77,107.27 173.02,107.03 173.19,107.03 173.43,107.27 173.61,107.27 173.85,107.02 173.85,106.84 173.8,106.79 173.72,106.71 173.72,106.47 173.87,106.32 174.03,106.32 174.11,106.41 174.27,106.41 174.43,106.26 174.43,106.1 174.34,106.01 174.34,105.85 174.61,105.58 v3(175.6,105.58)
  BOTTOM w0.089: v3(175.6,105.58) 175.9,105.58 176,105.47 UV1.AK48 ; UV7.B4 168.17,115.52 167.89,115.52 167.72,115.35 167.72,113.88 167.83,113.78
  BOTTOM w0.157: 167.83,113.78 168.34,113.26 168.34,112.74 167.86,112.26 v1(167.86,112.13) v3(167.86,110.82)
FBA_D59: length 18.9
  IN4 w0.112: v3(165.3,114.92) 165.3,114.98 165.43,115.11 166.51,115.11 166.63,114.98 166.63,114.64 166.51,114.51 165.99,114.51 165.86,114.38 165.86,114.04 165.99,113.91 166.35,113.91 166.5,113.76 166.5,112.46 166.63,112.33 167.23,112.33 168.2,111.36 169.99,111.36 174.78,106.58 v3(175.25,106.58)
  BOTTOM w0.089: v3(175.25,106.58) 175.85,105.98 UV1.AK49
  BOTTOM w0.13: v3(165.3,114.92) 165.46,115.08 166.21,115.08 UV7.B2
FBA_D60: length 26.6
  IN4 w0.112: v3(168.61,118.28) 168.21,117.87 165.85,117.87 165.45,117.47 165.14,117.47 163.82,116.15 163.82,111.71 168.74,106.79 170.99,106.79 172.77,105.01 172.97,105.01 v3(174.8,103.18)
  BOTTOM w0.089: v3(174.8,103.18) 174.13,103.18 174,103.05 174,102.91 174.13,102.78 UV1.AM45 ; UV7.E4 v3(168.61,118.28)
FBA_D61: length 26.4
  IN4 w0.112: v3(166.21,118.28) 166.21,118.27 165.14,118.27 164.3,117.44 163.13,117.44 162.96,117.26 162.96,111.13 167.93,106.16 168.79,106.16 170.57,104.38 172.79,104.38 v3(174.8,102.38)
  BOTTOM w0.089: UV1.AM44 v3(174.8,102.38)
  BOTTOM w0.13: UV7.E2 v3(166.21,118.28)
FBA_D62: length 33.8
  IN4 w0.112: v3(175.6,101.58) 175.21,101.18 174.31,101.18 173.51,101.98 172.19,101.98 171.4,102.77 168.25,102.77 166.41,104.61 166.41,106.34 162.06,110.68 162.06,118.34 163.01,119.29 164.33,119.29 164.52,119.47 167.42,119.47 v3(167.81,119.08)
  BOTTOM w0.089: UV1.AK44 v3(175.6,101.58) ; UV7.F4 v3(167.81,119.08)
FBA_D63: length 28.8
  IN4 w0.112: v3(174.8,101.58) 173.59,102.78 171.97,102.78 171.19,103.57 169.54,103.57 167.92,105.19 167.44,105.19 167.21,105.42 167.21,106.17 166.59,106.79 162.51,110.87 162.51,117.7 163.2,118.39 164.45,118.39 165.14,119.08 v3(166.21,119.08)
  BOTTOM w0.089: UV1.AM43 v3(174.8,101.58)
  BOTTOM w0.13: UV7.F2 v3(166.21,119.08)
FBA_DBI0#: length 26.6
  TOP w0.089: UV6.D2 v3(175.01,116.68)
  IN1 w0.119: v3(186.8,98.18) 186.38,98.6 186.38,103.33 185.77,103.94 185.77,104.23 185.16,104.84 185.16,106.77 184.66,107.27 183.58,107.27 183.01,107.83 183.01,109.4 182.36,110.05 181.58,110.05 180.68,110.96 177.05,114.58 177.05,116.05 176.84,116.27 175.42,116.27 v3(175.01,116.68)
  BOTTOM w0.089: v3(186.8,98.18) UV1.U40
FBA_DBI1#: length 28.9
  TOP w0.13: UV6.D13 v3(167.01,116.68)
  IN6 w0.119: v3(182,103.18) 182.39,102.78 183.09,102.78 183.63,103.33 183.63,105.48 182.45,106.66 181.41,106.66 180.38,107.69 179.26,107.69 177.32,109.62 174.64,109.62 172.67,111.6 170.8,111.6 170.06,112.35 170.06,113.58 168.97,114.66 166.8,114.66 166.63,114.84 166.63,116.29 v3(167.01,116.68)
  BOTTOM w0.089: UV1.AC45 v3(182,103.18)
FBA_DBI2#: length 45.4
  TOP w0.13: UV6.P13 167.01,125.48 v3(167.01,125.53)
  IN1 w0.119: v3(167.01,125.53) 166.74,125.53 166.6,125.67 166.6,126.48 166.4,126.68 164.71,126.68 163.57,125.55 163.57,124.71 161.56,122.69 161.56,110.6 164.94,107.22 173.39,107.22 173.66,106.95 175.55,106.95 176.13,106.38 177.79,106.38 178,106.16 178,105.67 178.65,105.02 178.65,101.78 178.44,101.56 v3(178.06,101.56)
  BOTTOM w0.089: v3(178.06,101.56) 178.06,101.63 UV1.AG44
FBA_DBI3#: length 30.4
  TOP w0.089: UV6.P2 v3(175.01,125.48)
  IN4 w0.112: v3(175.01,125.48) 175.41,125.09 175.41,124.04 176.21,123.24 176.21,122.8 176.27,122.73 176.47,122.53 176.47,121.19 176.85,120.8 177.17,120.8 177.8,120.17 177.8,119.4 179.06,118.14 179.06,110.75 181.02,108.79 181.02,107.13 181.29,106.86 181.29,100.93 181.61,100.61 181.85,100.37 182.4,100.37 v3(182.8,99.98)
  BOTTOM w0.089: UV1.AA41 v3(182.8,99.98)
FBA_DBI4#: length 31.3
  IN2 w0.119: v3(166.21,125.53) 166.61,125.14 167.41,125.14 167.46,125.09 168.76,125.09 169.01,124.84 169.01,122.56 168.33,121.88 167.64,121.88 167.41,121.66 167.41,121.32 166.89,120.8 165.1,120.8 164.42,120.12 164.42,111.69 166.19,109.91 166.19,108.69 168.8,106.07 168.8,104.53 169.11,104.23 169.2,104.13 v3(169.2,103.18)
  BOTTOM w0.089: UV1.AV45 v3(169.2,103.18) ; UV7.P2 166.21,125.48 v3(166.21,125.53)
FBA_DBI5#: length 48.4
  IN6 w0.089: 166.5,106.1 165.33,106.1 164.64,106.79 ; v3(175.81,125.48) 175.43,125.87 175.43,127.32 175.27,127.47 171.39,127.47 169.82,125.9 164.85,125.9
  IN6 w0.119: 164.64,106.79 163.46,107.97 163.46,108.14 163.73,108.41 163.73,108.55 163.54,108.74 163.39,108.74 163.1,108.45 162.95,108.45 162.75,108.65 162.75,108.79 163.21,109.25 163.21,109.39 163.01,109.58 162.87,109.58 162.42,109.13 162.27,109.13 162.08,109.32 162.08,109.47 162.52,109.91 162.52,110.08 162.02,110.58 162.02,123.07 164.85,125.9 ; v3(172.4,103.18) 172.04,103.18 171.71,103.5 171.71,104.44 170.96,105.2 167.4,105.2 166.5,106.1
  BOTTOM w0.089: UV1.AR45 v3(172.4,103.18) ; UV7.P13 v3(175.81,125.48)
FBA_DBI6#: length 20.9
  IN2 w0.119: v3(178,99.98) 177.76,99.98 177.37,100.37 177.05,100.37 176.56,100.87 176.56,106.09 176.85,106.38 176.85,108.87 175.39,110.32 175.39,112.25 174.8,112.85 174.8,114.31 175.41,114.91 175.41,117.09 v3(175.01,117.48)
  BOTTOM w0.089: UV1.AG42 v3(178,99.98) ; UV7.D13 v3(175.01,117.48)
FBA_DBI7#: length 24.5
  IN4 w0.112: v3(166.21,116.68) 166.2,116.69 164.71,116.69 164.36,116.34 164.36,111.94 168.38,107.91 168.66,107.91 168.81,107.76 168.81,107.49 168.94,107.36 169.26,107.36 169.39,107.49 169.39,107.81 169.52,107.94 169.86,107.94 169.99,107.81 169.99,107.49 170.14,107.34 170.41,107.34 170.56,107.49 170.56,107.51 170.71,107.66 171.01,107.66 171.16,107.51 171.16,107.49 171.31,107.34 171.34,107.34 172.02,106.66 172.02,106.11 172.38,105.75 172.58,105.75 172.81,105.53 173.02,105.53 173.13,105.64 173.34,105.64 173.56,105.43 173.56,105.22 173.44,105.1 173.44,104.89 173.66,104.68 173.87,104.68 173.98,104.79 174.19,104.79 174.4,104.58 174.4,104.37 174.29,104.25 174.29,104.04 174.48,103.85 174.67,103.85 v3(174.8,103.98)
  BOTTOM w0.089: UV1.AM46 174.67,103.58 174.8,103.71 v3(174.8,103.98)
  BOTTOM w0.13: v3(166.21,116.68) 166.5,116.68 166.61,116.79 UV7.D2
FBA_EDC0: length 23.8
  TOP w0.089: UV6.C2 v3(175.81,116.68)
  IN1 w0.119: v3(186.8,103.18) 186.8,103.39 186.39,103.8 186.39,105.27 185.56,106.1 185.56,107.42 185.44,107.54 185.17,107.54 185.04,107.67 185.04,107.89 185.17,108.02 185.44,108.02 185.63,108.21 185.63,108.39 185.07,108.95 184.89,108.95 184.34,108.41 184.16,108.41 184.01,108.57 184.01,108.75 184.52,109.26 184.52,109.43 182.48,111.47 180.88,111.47 177.52,114.82 177.52,116.36 176.92,116.97 176.83,117.06 176.19,117.06 v3(175.81,116.68)
  BOTTOM w0.089: UV1.U45 v3(186.8,103.18)
FBA_EDC1: length 26.7
  TOP w0.13: UV6.C13 v3(167.01,115.88)
  IN6 w0.119: v3(184.4,101.58) 183.96,102.02 183.96,105.67 182.65,106.98 181.85,106.98 180.15,108.68 178.98,108.68 177.61,110.05 174.82,110.05 172.55,112.32 172.55,112.53 169.6,115.48 167.41,115.48 v3(167.01,115.88)
  BOTTOM w0.089: UV1.Y43 v3(184.4,101.58)
FBA_EDC2: length 46.2
  TOP w0.13: v3(166.21,126.28) UV6.R13
  IN1 w0.119: v3(166.21,126.28) 166.21,126.05 166.02,125.86 164.49,125.86 164,125.37 164,124.53 162.02,122.55 162.02,110.86 165.15,107.73 176.09,107.73 176.21,107.6 176.21,106.95 176.34,106.82 176.67,106.82 176.8,106.95 176.8,107.6 176.93,107.73 177.18,107.73 177.31,107.6 177.31,106.95 177.44,106.82 177.97,106.82 178.26,106.54 178.26,105.92 178.89,105.29 178.89,100.69 v3(179.6,99.98)
  BOTTOM w0.089: UV1.AF42 v3(179.6,99.98)
FBA_EDC3: length 28.4
  TOP w0.089: UV6.R2 v3(175.01,126.28)
  IN4 w0.112: v3(175.01,126.28) 175.41,125.89 175.96,125.89 176.21,125.64 176.21,124.14 177.01,123.34 177.01,122.99 177.46,122.53 177.46,121.4 178.44,120.42 178.44,119.53 179.79,118.18 179.79,110.79 181.61,108.97 181.61,107.31 181.84,107.09 181.84,106.57 181.61,106.34 181.61,102.77 v3(182,102.38)
  BOTTOM w0.089: UV1.AC44 v3(182,102.38)
FBA_EDC4: length 30.5
  IN2 w0.119: v3(167.01,126.28) 167.42,125.87 169.58,125.87 169.81,125.64 169.81,122.43 169.02,121.64 169.02,121.33 167.96,120.27 165.2,120.27 164.91,119.97 164.91,114.05 164.96,114 164.96,111.91 165.41,111.46 166.73,110.14 166.73,108.91 169.2,106.44 v3(169.2,104.78)
  BOTTOM w0.089: UV7.R2 v3(167.01,126.28) ; UV1.AV47 v3(169.2,104.78)
FBA_EDC5: length 49.5
  IN6 w0.119: v3(175.81,126.28) 175.81,127.72 175.25,128.28 174.72,128.28 174.63,128.37 172.4,128.37 172.28,128.25 171.51,128.25 169.95,126.68 165.04,126.68 161.51,123.16 161.51,109.29 165.36,105.44 165.36,104.8 165.78,104.38 171.05,104.38 171.27,104.16 171.27,103.23 171.71,102.79 172.87,102.79 173.2,102.46 v3(173.2,101.58)
  BOTTOM w0.089: UV7.R13 v3(175.81,126.28) ; UV1.AN43 v3(173.2,101.58)
FBA_EDC6: length 21.8
  IN2 w0.119: v3(177.2,99.98) 177.09,99.98 176.31,100.76 176.31,108.39 175.64,109.06 175.43,109.06 175,108.63 174.82,108.63 174.58,108.88 174.58,109.06 175.01,109.48 175.01,109.69 174.81,109.89 174.81,112.07 174.26,112.62 174.26,113.01 174.11,113.16 173.34,113.16 173.21,113.29 173.21,113.63 173.34,113.76 174.11,113.76 174.26,113.91 174.26,115.12 v3(175.01,115.88)
  BOTTOM w0.089: UV1.AJ42 v3(177.2,99.98) ; UV7.C13 v3(175.01,115.88)
FBA_EDC7: length 24.6
  IN4 w0.112: v3(166.21,115.88) 166.54,115.88 166.66,116 166.66,116.17 166.54,116.29 165.86,116.29 165.46,115.89 164.91,115.89 164.78,115.76 164.78,113.32 164.91,113.19 165.96,113.19 166.09,113.06 166.09,112.72 165.96,112.59 165.06,112.59 164.91,112.44 164.91,112.1 167.82,109.19 168.06,109.19 168.39,109.51 168.57,109.51 168.79,109.29 168.79,109.11 168.47,108.78 168.47,108.6 168.58,108.48 170.97,108.48 174.25,105.2 175.17,105.2 v3(175.6,104.78)
  BOTTOM w0.089: UV1.AK47 v3(175.6,104.78)
  BOTTOM w0.13: UV7.C2 v3(166.21,115.88)
FBA_MA0_MA10_H: length 26.9
  IN1 w0.119: v3(168.61,121.48) 168.61,121.76 168.49,121.88 168.32,121.88 168.19,121.76 168.19,118.95 168.47,118.67 168.85,118.67 169.02,118.49 169.02,117.88 168.91,117.76 168.56,117.76 168.43,117.64 168.43,117.41 168.56,117.28 168.91,117.28 169.02,117.17 169.02,114.7 169.14,114.59 169.46,114.59 169.59,114.46 169.59,114.23 169.46,114.11 169.14,114.11 169.03,113.99 169.03,113.15 168.9,113.01 v3(168.85,113.01)
  BOTTOM w0.089: 170.42,106.79 170.39,106.79 170.2,106.59 170.2,106.47 170.62,106.05 170.62,105.9 170.51,105.8 170.37,105.8 169.95,106.22 169.82,106.22 169.6,106 UV1.AV49 ; v3(168.61,121.48) 168.3,121.48 168.21,121.57 UV7.K4
  BOTTOM w0.157: v3(168.85,113.01) 169.01,113.17 169.25,113.17 169.38,113.04 v1(169.38,111.84) 169.38,109.73 170.44,108.68 170.44,107.95 170.59,107.79 170.88,107.79 171.04,107.95 171.04,108.84 171.16,108.97 171.54,108.97 171.67,108.84 171.67,107.31 171.52,107.16 170.55,107.16 170.44,107.04 170.44,106.81 170.42,106.79
FBA_MA0_MA10_L: length 27.8
  TOP w0.089: 172.8,113.78 172.8,113.79 172.46,114.14 172.46,115.05 171.89,115.62 171.89,120.22 172.27,120.6 173.49,120.6 UV6.H4
  TOP w0.157: 172.8,113.78 172.8,113.77 174.91,111.66 174.91,111.03 175.74,110.2 177.49,110.2 177.63,110.34 180.58,110.34 180.93,109.98 182.69,109.98 v1(182.98,109.69) v3(183.6,109.08)
  BOTTOM w0.089: UV1.V47 185.21,104.77 185.21,105.91 185.2,105.91 185.2,106.12 184.66,106.65 184.66,106.75 184.62,106.79
  BOTTOM w0.157: v3(183.6,109.08) 184.36,108.32 184.36,107.06 184.62,106.79
FBA_MA1_MA9_H: length 28.5
  IN1 w0.119: v3(168.85,112.38) 168.85,112.42 169.12,112.7 169.29,112.7 170.41,111.57 170.59,111.57 170.75,111.73 170.75,111.91 169.62,113.03 169.62,113.2 169.81,113.38 169.81,115.58 169.69,115.7 169.36,115.7 169.25,115.82 169.25,116.06 169.36,116.18 169.69,116.18 169.81,116.3 169.81,117.19 169.69,117.31 169.37,117.31 169.25,117.44 169.25,117.66 169.37,117.79 169.69,117.79 169.81,117.91 169.81,119.33 169.68,119.46 168.8,119.46 168.53,119.72 168.53,119.94 168.65,120.06 169.06,120.06 169.19,120.18 169.19,120.41 169.06,120.54 168.65,120.54 168.53,120.65 168.53,120.86 169.15,121.48 v3(169.41,121.48)
  BOTTOM w0.089: 168.94,106.79 168.94,106.39 169.15,106.17 169.15,105.27 169.25,105.18 UV1.AV48 ; UV7.K5 v3(169.41,121.48)
  BOTTOM w0.157: 168.94,106.79 169.09,106.95 169.83,106.95 169.99,107.11 169.99,107.42 169.83,107.58 169.14,107.58 168.94,107.78 168.94,108.02 v1(169.09,108.18) 169.63,108.18 169.81,108.36 169.81,108.62 169.63,108.81 169.09,108.81 168.94,108.97 168.94,112.29 v3(168.85,112.38)
FBA_MA1_MA9_L: length 32.2
  TOP w0.089: UV6.H5 172.83,120.28 172.71,120.16 172.71,119.71 172.13,119.13 172.13,115.82 172.69,115.26 172.69,114.49 173.13,114.04 173.15,114.04 173.41,113.78
  TOP w0.157: v3(183.6,109.74) 182.91,110.43 181.43,110.43 180.98,110.89 180.98,112.05 180.77,112.26 180.38,112.26 180.22,112.1 180.22,110.94 180.07,110.78 179.82,110.78 179.66,110.94 v1(179.66,111.58) 179.66,112.1 179.5,112.26 179.25,112.26 179.1,112.1 179.1,110.94 178.94,110.78 178.69,110.78 178.53,110.94 178.53,112.1 178.37,112.26 178.07,112.26 177.87,112.05 177.87,110.98 177.66,110.78 177.45,110.78 177.31,110.64 175.92,110.64 175.35,111.21 175.35,111.84 173.41,113.78
  BOTTOM w0.089: UV1.V49 185.6,106.08 185.03,106.66 185.03,106.79
  BOTTOM w0.157: v3(183.6,109.74) 185.03,108.32 185.03,106.79
FBA_MA2_BA0_H: length 31.9
  BOTTOM w0.089: 172.69,113.78 172.69,114.3 172.52,114.47 172.52,114.67 171.88,115.31 171.08,115.31 170.93,115.47 170.93,117.25 170.35,117.83 170.35,118.57 170.44,118.66 170.85,118.66 171.27,119.09 171.27,121.61 170.55,122.33 170.55,122.48 170.7,122.63 170.83,122.63 171.17,122.28 171.48,122.28 171.69,122.5 171.69,122.88 170.97,123.59 170.97,124.94 171.1,125.07 171.58,125.07 171.71,124.94 171.71,123.85 171.9,123.66 171.9,123.24 172.05,123.09 172.05,122.53 172.26,122.32 173.08,122.32 173.32,122.55 173.46,122.55 173.59,122.43 173.59,121.96 173.67,121.88 UV7.K11
  BOTTOM w0.157: 172.69,113.78 172.69,113.57 174.91,111.35 v1(174.91,111.09) 174.91,110.75 176.48,109.18 176.48,107.31 177.2,106.59 177.2,105.3 177.08,105.18 UV1.AJ48
FBA_MA2_BA0_L: length 32.6
  TOP w0.089: UV6.H11 168.3,120.19 168.3,119.82 168.41,119.71 168.56,119.71 168.67,119.82 168.67,120.35 168.51,120.51 168.51,120.69 168.59,120.77 169.12,120.77 169.31,120.58 169.54,120.58 169.67,120.72 169.9,120.72 170.12,120.5 170.12,114.47 169.73,114.08 169.73,113.78
  TOP w0.157: v3(179.59,107.11) 178.94,107.11 178.9,107.14 177.04,107.14 176.88,106.99 176.88,106.5 176.73,106.34 176.48,106.34 176.32,106.5 176.32,106.99 176.16,107.14 174.45,107.14 174.29,106.99 174.29,106.39 174.14,106.23 173.89,106.23 173.73,106.39 173.73,106.99 173.57,107.14 v1(172.52,107.14) 171.7,107.14 169.73,109.11 169.73,113.78
  BOTTOM w0.089: UV1.AD47 180.72,104.29 180.6,104.29 180.47,104.42 180.47,105.37 180.35,105.5 180.09,105.5 179.96,105.63 179.96,106.02 180.05,106.11 180.12,106.11 180.21,106.2 180.21,106.38 180.12,106.47 180.05,106.47 179.96,106.56 179.96,106.73 179.9,106.79
  BOTTOM w0.157: 179.9,106.79 v3(179.59,107.11)
FBA_MA3_BA3_H: length 31.2
  BOTTOM w0.089: 173.79,113.78 173.79,114.2 173.62,114.37 172.89,114.37 172.71,114.55 172.71,114.75 172.29,115.17 172.29,115.17 171.96,115.5 171.22,115.5 171.12,115.6 171.12,115.81 171.21,115.9 171.79,115.9 171.9,116 171.9,116.15 171.79,116.25 171.21,116.25 171.12,116.34 171.12,116.52 171.21,116.61 171.79,116.61 171.9,116.71 171.9,116.85 171.79,116.96 171.21,116.96 171.12,117.04 171.12,117.22 171.22,117.32 171.79,117.32 171.9,117.43 171.9,117.57 171.79,117.67 171.49,117.67 171.4,117.76 171.4,118.1 171.29,118.2 171.15,118.2 171.04,118.1 171.04,117.76 170.95,117.67 170.78,117.67 170.54,117.91 170.54,118.33 170.68,118.47 170.93,118.47 171.56,119.1 171.56,119.68 171.46,119.78 171.46,120.04 171.56,120.13 171.56,120.4 171.46,120.49 171.46,120.75 171.56,120.84 171.56,121.11 171.46,121.2 171.46,121.46 171.56,121.55 171.56,121.73 171.46,121.82 171.46,122 171.71,122.25 171.95,122.25 172.03,122.16 172.03,121.77 172.14,121.66 172.29,121.66 172.39,121.77 172.39,122.04 172.48,122.13 172.92,122.13 173.01,122.04 UV7.K10
  BOTTOM w0.157: 173.79,113.78 173.79,113.26 v1(174.28,112.77) 175.44,111.61 175.44,110.84 177.05,109.23 177.05,108.72 177.26,108.51 177.77,108.51 177.93,108.35 177.93,108.06 177.77,107.91 177.2,107.91 177.05,107.75 177.05,107.5 177.2,107.34 177.77,107.34 177.93,107.19 177.93,106.39 178.04,106.28 178.04,105.58 178.4,105.22 UV1.AG48
FBA_MA3_BA3_L: length 29.1
  TOP w0.089: 169.29,113.78 169.29,113.91 169.8,114.42 169.8,115.63 169.71,115.72 169.51,115.72 169.42,115.8 169.42,116.12 169.51,116.21 169.71,116.21 169.8,116.3 169.8,116.94 169.57,117.17 169.57,117.4 169.8,117.62 169.8,120.04 169.55,120.28 UV6.H10
  TOP w0.157: 169.29,113.78 169.29,111.72 169.03,111.46 169.03,111.16 169.29,110.89 169.29,108.93 171.75,106.47 172.97,106.47 173.47,105.97 177.04,105.97 177.68,106.61 178.15,106.61 178.31,106.45 v1(178.31,106.38) 178.31,105.79 178.47,105.63 178.72,105.63 178.87,105.79 178.87,106.45 179.03,106.61 179.44,106.61 v3(179.58,106.47)
  BOTTOM w0.13: v3(179.58,106.47) 179.7,106.35 179.7,105.45 179.6,105.35 179.6,104.53 179.45,104.38 UV1.AF47
FBA_MA4_BA2_H: length 33.1
  IN1 w0.119: v3(174.38,111.08) 174.38,111.01 174.25,110.88 173.94,110.88 173.82,111 173.82,111.27 173.69,111.4 173.47,111.4 173.34,111.27 173.34,111 173.22,110.88 172.98,110.88 172.89,110.97 172.89,112.64 170.68,114.85 170.68,119.32 170.8,119.43 170.94,119.43 171.06,119.55 171.06,119.79 170.94,119.91 170.8,119.91 170.68,120.03 170.68,120.24 171.31,120.87 173.19,120.87 173.38,121.06 176.34,121.06 176.47,120.93 176.47,120.4 176.34,120.27 172.4,120.27 172.27,120.14 v3(172.27,120.06)
  BOTTOM w0.089: 176.39,106.79 176.8,106.37 UV1.AJ49
  BOTTOM w0.102: UV7.H11 173.81,120.64 173.69,120.77 172.23,120.77 172.11,120.64 172.11,120.23 v3(172.27,120.06)
  BOTTOM w0.157: v3(174.38,111.08) 174.38,110.66 175.99,109.06 v1(175.99,108.16) 175.99,107.19 176.39,106.79
FBA_MA4_BA2_L: length 32.4
  TOP w0.089: UV6.K11 168.21,122.25 168.34,122.37 169.58,122.37 169.67,122.46 169.67,122.82 169.77,122.92 169.92,122.92 170.02,122.82 170.02,122.44 170.09,122.37 171.09,122.37 171.21,122.25 171.21,122.09 171.09,121.97 170.67,121.97 170.62,121.92 170.62,113.78
  TOP w0.157: v3(179.59,108.16) 179.45,108.02 v1(177.12,108.02) 173.19,108.02 173.02,108.19 173.02,108.87 172.85,109.04 172.62,109.04 172.45,108.87 172.45,108.19 172.28,108.02 172.06,108.02 171.78,108.29 171.78,110.11 170.62,111.27 170.62,113.78
  BOTTOM w0.089: 180.4,106.79 180.4,105.82 180.8,105.42 UV1.AD48
  BOTTOM w0.157: v3(179.59,108.16) 180.4,107.34 180.4,106.79
FBA_MA5_BA1_H: length 30
  IN1 w0.119: v3(173.81,111.79) 173.81,112.18 173.95,112.32 174.23,112.32 174.36,112.19 174.36,111.6 174.49,111.48 174.71,111.48 174.84,111.6 174.84,112.04 174.96,112.16 175.37,112.16 175.49,112.28 175.49,112.49 175.37,112.62 174.46,112.62 174.22,112.85 174.22,113.45 174.94,114.18 174.94,114.36 174.78,114.51 174.6,114.51 173.88,113.79 173.71,113.79 173.57,113.94 173.4,113.94 173.08,113.62 172.9,113.62 172.74,113.78 172.74,113.96 173.28,114.5 173.28,114.68 173.12,114.84 172.94,114.84 172.31,114.2 172.13,114.2 171.97,114.36 171.97,114.54 172.38,114.95 172.38,115.12 172.24,115.27 172.24,117.63 172.61,118.01 v3(172.61,118.28)
  BOTTOM w0.102: UV7.H10 173.01,120.46 172.91,120.56 172.77,120.56 172.67,120.46 172.67,119.66 172.11,119.09 172.11,118.26 172.21,118.15 172.49,118.15 v3(172.61,118.28)
  BOTTOM w0.157: UV1.AJ47 176.8,104.08 176.7,103.98 176.49,103.98 176.39,104.08 176.39,106.16 175.43,107.11 175.43,109 173.81,110.62 v3(173.81,111.79)
FBA_MA5_BA1_L: length 33.9
  TOP w0.089: 170.18,113.78 170.18,114.14 170.3,114.25 170.3,114.38 170.31,114.39 170.31,121.38 170.19,121.49 169.89,121.49 169.79,121.59 169.79,121.72 169.89,121.82 170.23,121.82 170.31,121.9 170.31,122.09 170.22,122.18 169.22,122.18 169.01,121.97 UV6.K10
  TOP w0.157: v3(180.82,106.54) 180.82,107.18 181.08,107.44 181.59,107.44 181.76,107.26 v1(181.76,106.42) 181.76,105.36 181.54,105.13 180.38,105.13 180.2,105.31 180.2,107.23 179.85,107.58 171.88,107.58 171.35,108.11 171.35,109.64 170.18,110.8 170.18,113.78
  BOTTOM w0.13: UV1.AD49 180.8,106.52 v3(180.82,106.54)
FBA_MA6_MA11_H: length 31.7
  BOTTOM w0.089: UV7.H5 168.79,120.28 168.64,120.43 168.64,120.52 168.7,120.58 169.19,120.58 169.48,120.3 170.61,120.3 170.7,120.21 170.7,120.03 170.61,119.94 169.93,119.94 169.8,119.82 169.8,119.72 169.93,119.59 170.61,119.59 170.7,119.5 170.7,119.32 170.61,119.23 170.03,119.23 169.77,118.97 169.77,117.6 170.36,117.01 170.36,114.86 170.48,114.74 171.59,114.74 171.72,114.62 171.72,114.44 171.63,114.35 170.3,114.35 170.19,114.25 170.19,114.1 170.3,114 171.19,114 171.29,113.89 171.29,113.78 ; UV1.AM47 174.4,104.75 174.26,104.88 174.06,104.88 173.93,104.75 173.93,103.97 173.85,103.9 172.96,103.9 172.76,104.1 172.76,104.73 172.88,104.85 173.14,104.85 173.27,104.98 173.27,106.16 172.99,106.44 172.14,106.44 172.01,106.57 172.01,106.83
  BOTTOM w0.157: 171.29,113.78 171.29,113.62 170.82,113.15 v1(170.82,112.77) 170.82,110.52 172.14,109.19 172.14,108.95 172.28,108.82 172.49,108.82 172.66,108.65 172.66,108.4 172.49,108.23 172.27,108.23 172.1,108.07 172.1,107.84 172.27,107.67 172.5,107.67 172.66,107.51 172.66,107.16 172.56,107.06 172.1,107.06 172.01,106.97 172.01,106.83
FBA_MA6_MA11_L: length 27.6
  TOP w0.089: 171.93,113.78 171.93,114.7 171.43,115.2 171.43,121.28 172.12,121.97 172.92,121.97 UV6.K5
  TOP w0.157: v3(182.04,109.08) 180.61,109.08 180.22,109.47 177.99,109.47 177.85,109.33 v1(175.36,109.33) 174.42,109.33 172.52,111.22 172.52,112.81 171.93,113.4 171.93,113.78
  BOTTOM w0.157: UV1.AC48 181.85,105.18 181.99,105.31 181.99,105.95 182.51,106.48 182.51,108.6 v3(182.04,109.08)
FBA_MA7_MA8_H: length 31.1
  IN1 w0.119: v3(169.41,119.88) 169.41,120.57 169.54,120.7 169.96,120.7 170.35,121.08 170.35,123.27 170.47,123.4 170.74,123.4 170.87,123.27 170.87,121.05 170.15,120.34 170.15,114.01 170.27,113.89 170.54,113.89 170.66,113.76 170.66,113.54 170.54,113.41 170.27,113.41 170.15,113.29 170.15,113 170.37,112.79 170.55,112.79 171.06,113.3 171.24,113.3 171.4,113.14 171.4,112.96 170.88,112.45 170.88,112.27 171.04,112.11 171.43,112.11 171.55,111.98 171.55,110.99 171.68,110.86 172,110.86 172.11,110.97 v3(172.11,112.14)
  BOTTOM w0.089: v3(169.41,119.88) 168.94,119.88 168.71,120.11 168.58,120.11 168.35,119.88 168.28,119.88 168.21,119.94 UV7.H4
  BOTTOM w0.157: v3(172.11,112.14) 172.34,111.91 v1(172.34,111.66) 172.34,110.85 174.06,109.13 174.06,106.91 174.4,106.56 UV1.AM49
FBA_MA7_MA8_L: length 27.5
  TOP w0.089: 171.49,113.78 171.49,114.45 171.2,114.75 171.2,121.38 172.03,122.2 173.49,122.2 UV6.K4
  TOP w0.157: 171.49,113.78 171.49,111.63 v1(173.17,109.95) 174.23,108.89 178.37,108.89 178.51,109.03 180.03,109.03 180.75,108.31 v3(182.04,108.31)
  BOTTOM w0.157: v3(182.04,108.31) 182.04,106.7 181.6,106.27 UV1.AC49
FBA_MA12_RFU_H: length 31
  BOTTOM w0.089: UV7.J5 169.29,121.08 169.65,120.72 170.04,120.72 170.17,120.84 170.17,121.36 169.36,122.18 169.36,122.51 169.77,122.93 169.77,125.2 169.98,125.4 170.37,125.4 170.58,125.2 170.58,123.27 170.58,122.78 170.27,122.47 170.27,122.34 171.08,121.53 171.08,119.16 170.77,118.85 170.22,118.85 170.16,118.78 170.16,117.76 170.74,117.17 170.74,115.29 170.91,115.12 171.8,115.12 172.17,114.76 172.17,113.78
  BOTTOM w0.157: UV1.AN48 173.99,105.57 173.99,106.39 173.53,106.85 173.53,109.04 v1(172.67,109.9) 172.55,110.02 171.69,110.88 171.69,112.77 172.17,113.24 172.17,113.78
FBA_MA12_RFU_L: length 31.4
  TOP w0.089: 172.37,113.78 172.37,113.78 172.27,113.88 172.27,114.77 171.66,115.38 171.66,120.41 172.33,121.08 UV6.J5
  TOP w0.157: v3(183.6,108.31) 183.6,108.14 183.73,108.02 185.27,108.02 185.4,107.89 185.4,107.47 185.27,107.35 182.92,107.35 182.74,107.52 182.74,109.17 182.37,109.54 180.76,109.54 180.4,109.9 v1(178.65,109.9) 177.81,109.9 177.67,109.76 174.6,109.76 172.96,111.4 172.96,112.99 172.37,113.59 172.37,113.78
  BOTTOM w0.157: UV1.AA49 183.39,106.17 183.39,108.11 v3(183.6,108.31)
FBA_RAS#_H: length 23.4
  IN1 w0.119: v3(166.96,110.68) 166.41,110.68 166.28,110.8 166.28,112.22 166.16,112.35 165.94,112.35 165.81,112.47 165.81,112.7 165.94,112.82 166.3,112.82 166.42,112.95 166.42,113.07 166.2,113.29 166.2,113.93 165.8,114.33 165.8,114.78 165.92,114.9 166.28,114.9 166.41,115.03 166.41,115.25 166.28,115.38 165.92,115.38 165.8,115.5 165.8,116.36 165.68,116.49 165.68,116.84 165.8,116.97 165.8,117.85 165.66,117.99 165.66,118.32 165.8,118.46 165.8,118.97 165.67,119.09 165.63,119.09 165.51,119.22 165.51,119.45 165.63,119.57 165.67,119.57 165.8,119.7 165.8,120.53 165.95,120.68 166.12,120.68 166.61,120.18 166.79,120.18 166.95,120.34 166.95,120.52 166.46,121.02 166.46,121.19 166.6,121.33 166.6,121.6 167.01,122.01 v3(167.01,122.28)
  BOTTOM w0.13: UV7.L3 167.17,122.68 167.01,122.52 v3(167.01,122.28)
  BOTTOM w0.157: UV1.AW49 168.56,105.98 167.81,106.73 167.81,106.94 167.94,107.07 167.94,110 v1(167.71,110.24) 167.4,110.24 v3(166.96,110.68)
FBA_RAS#_L: length 26.9
  TOP w0.089: v3(174.21,119.88) UV6.G3
  IN2 w0.119: v3(174.21,119.88) 174.61,119.49 175.96,119.49 176.36,119.09 177.87,119.09 178.12,118.84 178.12,113.95 179.4,112.67 179.4,109.84 179.52,109.72 181.43,109.72 181.57,109.86 v3(181.57,111.04)
  BOTTOM w0.089: 185.46,106.79 185.46,106.57 186,106.04 186,105.58 UV1.V48
  BOTTOM w0.157: v3(181.57,111.04) 182,111.47 182.56,111.47 v1(183.26,110.78) 185.46,108.57 185.46,106.79
FBA_RST#_H: length 22.6
  IN1 w0.119: v3(165.81,111.89) 165.81,111.7 165.78,111.67 165.41,111.67 165.06,112.02 165.06,113.05 165.13,113.12 165.72,113.12 165.85,113.25 165.85,113.47 165.72,113.6 165.15,113.6 165.04,113.7 165.04,113.93 164.87,114.1 164.87,119.04 165,119.16 165.04,119.16 165.17,119.29 165.17,119.51 165.04,119.64 165,119.64 164.87,119.77 164.87,120 165.02,120.15 165.02,120.32 164.74,120.6 164.74,120.78 164.9,120.94 165.08,120.94 165.36,120.66 165.53,120.66 166.21,121.34 v3(166.21,121.48)
  BOTTOM w0.089: v3(166.21,121.48) 166.46,121.48 166.61,121.33 UV7.J2 ; UV1.BA49 167.2,106.39
  BOTTOM w0.157: 167.2,106.39 167.26,106.45 167.26,106.97 166.9,107.33 166.9,107.8 167.06,107.95 167.31,107.95 167.46,108.11 v1(167.46,108.23) 167.46,108.37 167.32,108.52 167.06,108.52 166.9,108.68 166.9,108.92 167.06,109.08 167.31,109.08 167.46,109.24 167.46,109.49 167.31,109.65 167.06,109.65 166.9,109.8 166.9,109.93 166.2,110.63 RV107.1 166.2,111.49 v3(165.81,111.89)
FBA_RST#_L: length 22.7
  TOP w0.13: UV6.J2 175.77,121.44 176.91,121.44 v3(177.1,121.25)
  IN2 w0.119: v3(177.1,121.25) 177.1,121.06 177.31,120.85 179.24,120.85 179.97,120.12 179.97,114.13 182.13,111.97 v3(182.13,111.91)
  BOTTOM w0.089: 185.9,106.79 185.9,106.71 186.07,106.54 186.4,106.21 UV1.U49
  BOTTOM w0.157: 185.9,106.79 v1(185.9,108.51) 185.9,109.01 RV108.1 183,111.91 v3(182.13,111.91)
FBA_WCK0: length 26.1
  TOP w0.112: UV6.D4 173.83,117.06 173.83,116.72 173.69,116.58 173.44,116.58 v3(173.34,116.68)
  IN6 w0.119: v3(173.34,116.68) 173.4,116.74 173.55,116.74 173.62,116.66 173.62,115.48 174.62,114.48 175.47,114.48 175.6,114.61 176.94,114.61 179.11,112.44 184.06,112.44 185.33,111.17 185.33,108.36 186.44,107.25 186.44,104.52 185.5,103.59 185.18,103.59 185.05,103.71 185.05,103.93 185.1,103.98 v3(185.2,103.98)
  BOTTOM w0.11: v3(185.2,103.98) 185.2,103.7 185.33,103.58 UV1.V46
FBA_WCK0_N: length 26.1
  TOP w0.112: UV6.D5 v3(173.41,117.48)
  IN6 w0.119: v3(173.41,117.48) 173.83,117.06 173.83,115.57 174.71,114.69 175.39,114.69 175.51,114.82 177.03,114.82 179.2,112.65 184.15,112.65 185.54,111.25 185.54,108.45 186.65,107.34 186.65,104.44 185.59,103.38 185.4,103.38 v3(185.2,103.18)
  BOTTOM w0.11: UV1.V45 v3(185.2,103.18)
FBA_WCK1: length 38.4
  TOP w0.089: UV6.P4 v3(173.41,125.48)
  IN4 w0.112: v3(180.4,99.18) 180.67,99.18 180.83,99.01 180.83,98.92 180.67,98.76 178.27,98.76 178.02,98.51 178.02,98.33 177.91,98.21 177.57,98.21 177.46,98.33 177.46,98.55 177.23,98.79 176.95,98.79 176.78,98.96 176.78,104.91 177.16,105.29 177.16,106.84 174.64,109.36 174.29,109.36 171.16,112.48 171.16,122.21 170.68,122.69 170.68,124.19 171.19,124.7 172.74,124.7 172.98,124.93 172.98,125.31 173.14,125.48 v3(173.41,125.48)
  BOTTOM w0.089: UV1.AD41 v3(180.4,99.18)
FBA_WCK1_N: length 38.5
  TOP w0.089: UV6.P5 v3(172.61,125.48)
  IN4 w0.112: v3(172.61,125.48) 172.77,125.32 172.77,125.02 172.66,124.91 171.11,124.91 170.47,124.27 170.47,122.61 170.96,122.13 170.96,112.4 174.2,109.15 174.56,109.15 176.95,106.76 176.95,105.37 176.57,104.99 176.57,98.87 176.86,98.58 177.14,98.58 177.26,98.47 177.26,98.24 177.49,98.01 177.99,98.01 178.23,98.24 178.23,98.42 178.35,98.55 180.76,98.55 181.04,98.83 181.04,99.04 181.17,99.17 v3(181.17,99.17)
  BOTTOM w0.089: UV1.AD40 180.8,98.8 v3(181.17,99.17)
FBA_WCK2: length 36.9
  IN4 w0.089: v3(168.61,125.48) 168.61,125.25 168.54,125.18 168.35,125.18 167.55,124.37 165.1,124.37 164.58,123.86 164.22,123.86
  IN4 w0.112: v3(170.8,101.58) 170.88,101.5 171.07,101.5 171.16,101.59 171.16,101.92 171,102.08 167,102.08 165.23,103.85 165.23,106.46 161.23,110.46 161.23,118.56 162.74,120.06 162.74,122.67 163.93,123.86 164.22,123.86
  BOTTOM w0.089: UV7.P4 v3(168.61,125.48) ; UV1.AT44 v3(170.8,101.58)
FBA_WCK2_N: length 36.9
  IN4 w0.089: 164.22,123.65 164.23,123.65 164.24,123.66 164.3,123.66 164.31,123.67 164.66,123.67 165.17,124.19 167.62,124.19 168.43,125 168.65,125 168.91,125.26 168.98,125.26 169.19,125.48 v3(169.32,125.48)
  IN4 w0.112: 164.22,123.65 164.01,123.65 162.94,122.58 162.94,119.98 161.43,118.47 161.43,110.54 165.43,106.54 165.43,103.94 167.08,102.29 171.08,102.29 171.37,102 171.37,101.81 v3(171.6,101.58)
  BOTTOM w0.089: v3(169.32,125.48) 169.32,125.33 169.07,125.08 UV7.P5 ; UV1.AT43 v3(171.6,101.58)
FBA_WCK3: length 31.8
  IN6 w0.119: v3(174.8,99.98) 174.62,99.8 174.41,99.8 174.22,99.98 174.22,105.67 174.54,105.99 176.63,105.99 177.03,106.4 177.03,107.23 176.53,107.73 173.86,107.73 173.6,107.99 173.25,107.99 173.01,107.74 172.83,107.74 172.58,107.99 172.58,108.17 172.83,108.42 172.83,108.76 172.55,109.04 170.92,109.04 170.8,109.17 170.8,109.35 v3(170.91,109.46)
  BOTTOM w0.089: 170.17,113.78 170.17,113.85 169.97,114.05 169.53,114.05 169.4,114.18 169.4,114.37 169.53,114.49 169.97,114.49 170.17,114.7 170.17,115.46 169.97,115.66 169.54,115.66 169.41,115.79 169.41,115.98 169.54,116.1 169.97,116.1 170.17,116.3 170.17,116.93 169.7,117.4 168.54,117.4 UV7.D4
  BOTTOM w0.11: UV1.AM42 174.4,100.14 174.56,99.98 v3(174.8,99.98)
  BOTTOM w0.14: v3(170.91,109.46) 170.74,109.63 170.74,109.82 170.19,110.37 170.19,113.27 170.2,113.27 170.17,113.3 170.17,113.78
FBA_WCK3_N: length 31.7
  IN6 w0.119: v3(170.33,109.46) 170.59,109.2 170.59,109.08 170.84,108.83 172.46,108.83 172.62,108.67 172.62,108.5 172.37,108.25 172.37,107.9 172.74,107.53 173.09,107.53 173.34,107.78 173.51,107.78 173.77,107.52 176.45,107.52 176.82,107.14 176.82,106.48 176.54,106.2 174.46,106.2 174.01,105.75 174.01,99.9 174.32,99.59 174.94,99.59 175.06,99.47 175.06,99.3 174.94,99.18 v3(174.8,99.18)
  BOTTOM w0.089: UV7.D5 169.15,117.21 169.62,117.21 169.98,116.85 169.98,116.38 169.89,116.29 169.46,116.29 169.22,116.06 169.22,115.71 169.46,115.47 169.89,115.47 169.98,115.38 169.98,114.77 169.89,114.69 169.45,114.69 169.21,114.45 169.21,114.1 169.45,113.86 169.89,113.86 169.93,113.82 169.93,113.78
  BOTTOM w0.11: v3(174.8,99.18) 174.8,99.4 174.62,99.58 UV1.AM41
  BOTTOM w0.14: 169.93,113.78 169.93,113.2 169.95,113.18 169.95,110.27 170.5,109.72 170.5,109.63 v3(170.33,109.46)
FBA_WE#_H: length 30.6
  IN1 w0.119: v3(173.37,112.27) 173.37,112.65 171.78,114.24 171.6,114.24 171.44,114.4 171.44,114.57 171.84,114.96 171.84,115.13 171.69,115.28 171.03,115.28 170.9,115.41 170.9,115.66 171.03,115.79 171.89,115.79 172.02,115.91 172.02,116.13 171.89,116.26 171.03,116.26 170.9,116.39 170.9,116.61 171.03,116.74 171.89,116.74 172.02,116.86 172.02,117.06 171.89,117.18 171.03,117.18 170.9,117.31 170.9,117.54 171.03,117.66 171.95,117.66 172.08,117.79 172.08,118.01 171.95,118.14 171.07,118.14 170.94,118.27 170.94,118.65 171.07,118.78 171.15,118.78 171.28,118.9 171.28,120.52 171.41,120.65 171.63,120.65 171.76,120.52 171.76,118.78 171.88,118.66 173.67,118.66 173.8,118.78 173.8,119.4 173.92,119.52 174.09,119.52 174.21,119.4 v3(174.21,119.08)
  BOTTOM w0.13: UV7.G12 v3(174.21,119.08)
  BOTTOM w0.157: v3(173.37,112.27) 173.37,110.43 v1(174.58,109.23) 174.58,107.05 174.82,106.81 174.82,105.36 174.63,105.18 UV1.AM48
FBA_WE#_L: length 38.2
  TOP w0.13: v3(167.01,123.03) 167.01,122.91 167.24,122.68 UV6.L12
  IN1 w0.119: v3(167.01,123.03) 166.63,122.64 166.63,122.07 166.44,121.88 165.2,121.88 164.91,121.59 164.91,121.31 164.52,120.92 164.52,113.95 164.66,113.81 164.66,111.93 166.36,110.23 168.6,110.23 169.18,110.8 170.75,110.8 171.75,109.81 176.57,109.81 177.36,110.6 v3(177.36,111.24)
  BOTTOM w0.157: v3(177.36,111.24) v1(178.6,110) 181.3,107.3 181.3,106.28 181.2,106.18 181.2,104.08 181.3,103.98 181.5,103.98 181.6,104.08 UV1.AC47
FBB_ABI#_H: length 31.1
  IN1 w0.089: v3(188.67,120.82) 189.04,120.45 189.04,120.16 189.75,119.45 192.65,119.45
  IN1 w0.119: 192.65,119.45 192.89,119.21 192.89,118.21 194.25,116.86 194.25,113.69 194.5,113.44 194.5,112.35 196.48,110.38 197.41,110.38 v3(197.45,110.42)
  BOTTOM w0.089: v3(188.67,120.82) 188.62,120.77 186.55,120.77 UV9.J4
  BOTTOM w0.157: v3(197.45,110.42) 197.4,110.37 197.4,109.2 200.99,105.6 200.99,103.68 200.08,102.76 200.08,102.3 199.3,101.53 198.85,101.53 UV1.B44
FBB_ABI#_L: length 39.1
  TOP w0.089: UV8.J4 v3(186.65,121.48)
  IN1 w0.089: v3(186.65,121.48) 188.08,120.05 188.08,118.17
  IN1 w0.119: 188.08,118.17 189.78,116.47 189.78,113.61 195.53,107.85 197.11,107.85 198.17,106.79 199.97,104.98 199.97,96.38 200.9,95.45 v3(200.9,94.9)
  BOTTOM w0.102: 200.07,92.79 198.27,92.79 197.86,92.38 UV1.C32
  BOTTOM w0.13: v3(200.9,94.9) 201,94.8 201,93.72 200.07,92.79
FBB_CAS#_H: length 22.3
  BOTTOM w0.089: 187.88,119.4 187.49,119.78 185.75,119.78 UV9.G3
  BOTTOM w0.157: UV1.D49 196.8,106.58 196.47,106.91 195.93,107.45 192.93,107.45 v1(191.69,108.7) 190.02,110.37 189.35,110.37 188.09,111.62 188.09,116.2 187.88,116.42 187.88,116.95 188.03,117.11 188.08,117.11 188.23,117.26 188.23,117.58 188.08,117.74 188.03,117.74 187.88,117.89 187.88,119.4
FBB_CAS#_L: length 40.5
  TOP w0.089: v3(186.65,119.08) 186.65,119.54 186.41,119.78 185.75,119.78 UV8.L3
  IN1 w0.089: 189.05,116.37 187.87,117.55 187.17,117.55 187.07,117.64 187.07,118.65 v3(186.65,119.08)
  IN1 w0.119: v3(200.51,90.72) 199.89,91.33 199.89,95.86 199.71,96.04 199.71,103 198.98,103.73 198.98,104.01 197.08,105.92 196,107 194.4,107 189.05,112.35 189.05,116.37
  BOTTOM w0.089: UV1.C29 198.08,90.45 200.24,90.45 v3(200.51,90.72)
FBB_CKE_H: length 24.2
  BOTTOM w0.089: UV9.J3 185.81,120.72 185.81,120.29 186.12,119.97 187.66,119.97 188.03,119.61 188.22,119.42
  BOTTOM w0.157: UV1.C48 197.6,105.42 197.18,105.85 197.18,106.89 196.18,107.89 193.32,107.89 192.9,108.31 RV113.2 191.76,109.25 v1(189.35,111.65) 188.6,112.41 188.6,114.11 188.49,114.21 188.49,118 188.22,118.27 188.22,119.42
FBB_CKE_L: length 46.6
  TOP w0.089: UV8.J3 v3(185.05,120.68)
  IN1 w0.089: v3(185.05,120.68) 185.44,120.29 185.44,118.42 186.77,117.08 187.57,117.08 188.16,116.49
  IN1 w0.119: v3(201.75,90.73) 201.5,90.48 201.5,90.48 200.95,89.93 199.46,89.93 198.52,90.87 198.52,97.61 196.58,99.55 196.27,99.55 195.2,100.62 195.2,102.07 194.39,102.88 194.39,105.81 194.03,106.16 194.02,106.16 188.16,112.03 188.16,116.49
  BOTTOM w0.089: 201.11,90.09 201.09,90.07 199.75,90.07 199.34,89.65 198.72,89.65 UV1.B29
  BOTTOM w0.157: 201.11,90.09 v3(201.75,90.73) 203.09,90.73 RV114.2
FBB_CLK0: length 52.8
  TOP w0.089: UV8.J12 v3(193.05,121.48)
  TOP w0.14: v3(196.95,121.19) 197.41,121.19 RV178.1
  IN6 w0.089: v3(193.05,121.48) 193.05,121.45 193.62,120.88 195.17,120.88 195.18,120.89 195.21,120.89
  IN6 w0.119: v3(196.95,121.19) 196.83,121.31 195.71,121.31 195.36,121.66 194.41,121.66 194.17,121.9 193.67,121.9 193.46,121.69 193.26,121.69 v3(193.05,121.48) ; 195.21,120.89 196.62,120.89 197.04,120.47 197.04,119.27 197.63,118.68 197.63,117.25 197.75,117.13 198.5,117.13 198.75,116.88 198.75,116.36 198.5,116.11 197.75,116.11 197.63,115.99 197.63,113.18 197.83,112.98 198,112.98 199.61,114.59 199.97,114.59 200.34,114.23 200.34,113.87 198.72,112.26 198.72,112.09 199.63,111.19 199.79,111.19 201.27,112.67 201.63,112.67 201.99,112.3 201.99,111.95 200.51,110.47 200.51,110.3 200.78,110.04 200.78,109.68 200.9,109.56 201.8,109.56 202.05,109.31 202.05,108.78 201.8,108.54 200.9,108.54 200.78,108.42 200.78,100.43 200.01,99.66 196.47,99.66 196.11,100.03 195.66,100.03 195.31,99.67 195.31,99.47 v3(195.6,99.18)
  BOTTOM w0.112: v3(195.6,99.18) 195.6,99.68 195.72,99.79 195.93,99.79 196,99.72 UV1.E41
FBB_CLK0#: length 53.8
  TOP w0.089: UV8.J11 v3(192.25,121.48)
  TOP w0.14: RV178.2 197.39,121.67 197.06,121.67 v3(196.95,121.77)
  IN6 w0.089: v3(192.25,121.48) 192.54,121.48 192.94,121.07 193.17,121.07 193.54,120.7 195.18,120.7 195.2,120.68 195.21,120.68
  IN6 w0.119: v3(192.25,121.48) 192.67,121.9 193.37,121.9 193.58,122.11 194.26,122.11 194.5,121.87 195.45,121.87 195.8,121.52 196.71,121.52 v3(196.95,121.77) ; v3(194.8,99.18) 195.1,99.47 195.1,99.76 195.57,100.24 196.2,100.24 196.56,99.87 199.93,99.87 200.57,100.51 200.57,108.51 200.81,108.75 201.72,108.75 201.84,108.87 201.84,109.23 201.72,109.35 200.81,109.35 200.57,109.59 200.57,109.95 200.3,110.22 200.3,110.56 201.78,112.04 201.78,112.22 201.54,112.46 201.36,112.46 199.88,110.98 199.54,110.98 198.51,112.01 198.51,112.35 200.12,113.96 200.12,114.14 199.88,114.38 199.7,114.38 198.09,112.77 197.75,112.77 197.42,113.1 197.42,116.08 197.67,116.32 198.41,116.32 198.54,116.45 198.54,116.79 198.41,116.92 197.67,116.92 197.42,117.16 197.42,118.59 196.83,119.18 196.83,120.38 196.53,120.68 195.21,120.68
  BOTTOM w0.112: UV1.F41 v3(194.8,99.18)
FBB_CLK1: length 37.6
  IN2 w0.119: v3(196.18,119.99) 195.96,119.77 193.04,119.77 192.77,120.04 192.77,120.4 v3(193.05,120.68)
  IN6 w0.119: v3(193.05,120.68) 192.93,120.56 192.93,120.08 193.13,119.88 195.1,119.88 196.62,118.36 196.62,116.01 196.38,115.76 195.59,115.76 195.48,115.64 195.48,115.29 195.59,115.17 196.38,115.17 196.62,114.92 196.62,113.4 197.17,112.85 197.17,112.51 196.79,112.13 196.79,111.96 197.04,111.71 197.21,111.71 197.6,112.09 197.94,112.09 198.93,111.09 198.93,103.94 199.42,103.45 199.42,101.33 198.2,100.1 196.83,100.1 196.62,100.31 196.62,100.56 v3(196.4,100.78)
  BOTTOM w0.089: UV9.J12 v3(193.05,120.68)
  BOTTOM w0.11: UV1.E42 v3(196.4,100.78)
  BOTTOM w0.14: RV138.1 197.32,119.82 196.35,119.82 v3(196.18,119.99)
FBB_CLK1#: length 37.6
  IN2 w0.119: v3(192.25,120.68) 192.56,120.37 192.56,119.96 192.95,119.56 196.03,119.56 v3(196.18,119.41)
  IN6 w0.119: v3(197.2,100.78) 196.95,100.78 196.83,100.65 196.83,100.4 196.91,100.31 198.11,100.31 199.21,101.42 199.21,103.36 198.72,103.85 198.72,111 197.85,111.88 197.68,111.88 197.3,111.5 196.96,111.5 196.58,111.87 196.58,112.22 196.96,112.6 196.96,112.77 196.41,113.32 196.41,114.84 196.29,114.96 195.51,114.96 195.26,115.2 195.26,115.73 195.51,115.97 196.29,115.97 196.41,116.09 196.41,118.27 195.01,119.67 193.04,119.67 192.72,119.99 192.72,120.2 v3(192.25,120.68)
  BOTTOM w0.089: v3(192.25,120.68) UV9.J11
  BOTTOM w0.11: UV1.D42 v3(197.2,100.78)
  BOTTOM w0.14: RV138.2 197.24,119.58 196.35,119.58 v3(196.18,119.41)
FBB_CS#_H: length 36.3
  IN1 w0.119: v3(199.91,112.7) 199.91,115.08 198.78,116.21 198.78,119.39 198.22,119.95 198.22,121.85 197.36,122.71 195.84,122.71 195.01,121.88 194.46,121.88 194.07,122.28 v3(193.05,122.28)
  BOTTOM w0.089: UV9.L12 v3(193.05,122.28)
  BOTTOM w0.157: UV1.A39 199.23,98.01 199.71,98.01 200.73,99.02 201.33,99.02 203.08,100.77 203.58,100.77 204.6,101.79 v1(204.6,103.35) 204.6,108 v3(199.91,112.7)
FBB_CS#_L: length 44.9
  TOP w0.089: UV8.G12 v3(192.25,123.08)
  IN1 w0.119: v3(204.86,100.63) 204.55,100.94 204.55,101.95 204.55,101.95 204.55,106.86 201.89,109.53 201.89,115.3 201.33,115.85 201.33,116.01 201.89,116.57 201.89,116.75 201.75,116.88 201.57,116.88 201.02,116.33 200.86,116.33 200.7,116.48 200.7,116.64 201.57,117.51 201.57,117.69 201.4,117.86 201.24,117.86 200.53,117.15 200.38,117.15 200.22,117.31 200.22,117.47 200.92,118.18 200.92,118.4 199.13,120.19 199.13,122.28 197.68,123.73 195.52,123.73 195.32,123.53 192.7,123.53 v3(192.25,123.08)
  BOTTOM w0.089: UV1.B38 198.81,97.59 200.05,97.59 200.43,97.97 200.9,97.97 201.11,98.19
  BOTTOM w0.157: 201.11,98.19 203.26,100.34 v1(204.09,100.34) 204.53,100.34 204.82,100.63 v3(204.86,100.63)
FBB_D0: length 59.6
  TOP w0.089: UV8.A4 v3(186.65,127.88)
  IN3 w0.112: v3(186.65,127.88) 190.04,127.88 190.44,127.47 192.47,127.47 192.65,127.29 192.65,124.5 192.92,124.23 194.19,124.23 194.63,123.79 195.33,123.79 196.53,122.58 196.53,120.8 196.73,120.61 196.73,116.49 199.6,113.61 201.88,113.61 202,113.5 202,113.27 201.88,113.16 200.42,113.16 200.29,113.03 200.29,112.84 200.42,112.71 201.88,112.71 202,112.6 202,112.38 201.88,112.27 200.44,112.27 200.32,112.14 200.32,111.95 200.44,111.82 201.88,111.82 202,111.71 202,94.26 200.22,92.48 200.22,92.18 198.75,90.71 197.67,90.71 v3(197.2,91.18)
  BOTTOM w0.089: UV1.D30 v3(197.2,91.18)
FBB_D1: length 59.5
  TOP w0.089: UV8.A2 v3(185.05,127.88)
  IN3 w0.112: v3(185.05,127.88) 185.42,128.25 193.2,128.25 193.45,128.01 193.45,125.22 194.06,124.61 195.02,124.61 197.37,122.27 197.37,117.47 200.76,114.07 202.25,114.07 202.38,113.95 202.38,91.98 201.68,91.28 200.45,91.28 199.17,90 195.2,90 v3(194.82,90.39)
  BOTTOM w0.089: UV1.G30 194.43,90.78 v3(194.82,90.39)
FBB_D2: length 61.7
  TOP w0.089: UV8.B4 v3(185.85,127.08)
  IN3 w0.112: v3(196.4,90.38) 196.79,90.76 196.79,91.29 197.09,91.59 197.35,91.59 197.61,91.86 197.61,92.12 198.46,92.96 198.98,92.96 200.07,94.05 200.07,94.59 201.42,95.95 201.42,109.96 201.23,110.15 201.08,110.15 200.15,109.22 199.99,109.22 199.83,109.38 199.83,109.54 200.76,110.47 200.76,110.62 200.6,110.78 200.44,110.78 199.52,109.85 199.36,109.85 199.2,110.01 199.2,110.17 200.13,111.1 200.13,111.26 199.97,111.42 199.81,111.42 198.88,110.49 198.72,110.49 198.57,110.64 198.57,110.8 199.5,111.73 199.5,111.89 199.34,112.05 199.18,112.05 198.25,111.12 198.09,111.12 197.93,111.28 197.93,111.34 195.26,114.01 195.26,117.44 195.71,117.88 195.71,120.04 195.77,120.11 195.77,122.52 194.82,123.47 194.63,123.47 194.12,123.98 192.41,123.98 191.84,124.55 191.84,125.31 191.01,126.14 191.01,126.27 190.64,126.63 190.39,126.63 189.57,127.45 186.22,127.45 v3(185.85,127.08)
  BOTTOM w0.089: UV1.E30 v3(196.4,90.38)
