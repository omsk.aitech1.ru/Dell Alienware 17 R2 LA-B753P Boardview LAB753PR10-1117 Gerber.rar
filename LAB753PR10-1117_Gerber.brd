# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_MA12_RFU_L: length 36.5
  BOTTOM w0.089: UV1.B11 198.4,75.89 198.76,76.25 198.76,76.42 199.06,76.72 199.73,76.72 201.05,78.03 201.11,78.03
  BOTTOM w0.157: UV13.J5 220.37,91.22 220.37,91.48 219.34,92.52 219.34,92.74 219.65,93.06 219.65,93.24 219.39,93.5 219.21,93.5 218.89,93.19 218.67,93.19 218.49,93.36 212.98,93.36 212.8,93.55 211.97,93.55 v1(210.63,92.21) 207.25,88.83 207.25,82.14 203.86,78.74 202.34,78.74 201.63,78.03 201.11,78.03
FBC_RAS#_H: length 34.2
  TOP w0.089: UV12.L3 221.2,89.46 221.2,91 222.07,91.87 222.07,92.57 221.81,92.84 221.4,92.84 221.17,92.61 220.87,92.61 220.61,92.87 219.72,92.87 219.7,92.85 212.94,92.85 212.91,92.81 212.67,92.81
  TOP w0.157: 212.67,92.81 v1(210.34,92.81) 209.13,92.81 206.61,90.29 v3(205.3,90.29)
  BOTTOM w0.157: v3(205.3,90.29) 205.72,90.29 205.92,90.5 205.92,91.07 205.72,91.28 204.45,91.28 204.29,91.12 204.29,90.58 204.13,90.43 203.65,90.43 203.34,90.12 201.81,90.12 200.85,89.15 200.85,88.22 200.49,87.87 199.9,87.87 199.79,87.97 197.99,87.97 UV1.C26
FBC_RAS#_L: length 38.6
  IN4 w0.112: v3(219.91,92.51) 218.15,90.75 212.64,90.75 211.37,89.48 v3(211.37,89.07)
  BOTTOM w0.089: UV13.G3 221.51,89.53 221.2,89.83 221.2,91.21 v3(219.91,92.51)
  BOTTOM w0.157: UV1.A5 200.96,72.53 201.59,72.53 202.59,73.53 202.62,73.53 204.07,74.98 205.07,74.98 207.23,77.14 207.23,78.4 209.87,81.05 v1(209.87,81.83) 209.87,87.73 211.21,89.07 v3(211.37,89.07)
FBC_RST#_H: length 34.2
  TOP w0.089: 219.7,86.22 219.6,86.32 219.6,88.05 UV12.J2
  TOP w0.157: v3(200.33,88.31) 200.23,88.21 200.23,83.25 201.08,82.4 v1(202.61,82.4) 208.8,82.4 RV115.1 210.1,82.21 211.53,82.21 212.35,83.02 212.35,84.18 213.77,85.6 215.39,85.6 215.9,85.09 216.94,85.09 217.87,84.16 219.93,84.16 220.21,84.44 220.21,85.43 219.88,85.77 219.88,85.88 219.7,86.05 219.7,86.22
  BOTTOM w0.13: UV1.A27 200.27,88.38 v3(200.33,88.31)
FBC_RST#_L: length 33.9
  BOTTOM w0.089: UV13.J2 219.41,87.86 219.41,87.23 218.92,86.74
  BOTTOM w0.157: UV1.B4 198.83,70.41 199.34,70.41 200.5,71.57 201.25,71.57 202.57,72.89 202.6,72.89 204.25,74.54 v1(204.92,74.54) 205.25,74.54 206.1,75.4 207.66,76.95 207.66,78.22 210.36,80.93 RV146.1 211.29,86.6 212.3,86.6 212.92,85.98 215.41,85.98 215.89,85.5 217.64,85.5 218.88,86.74 218.92,86.74
FBC_WCK0: length 41.2
  IN6 w0.119: v3(194.82,73.56) 194.99,73.73 195.86,73.73 196.62,74.5 202.78,74.5 204.06,75.78 204.84,75.78 210.6,81.54 214.08,81.54 216.02,83.48 216.87,83.48 219.3,85.91 219.3,89.13 221.74,91.57 223.69,91.57 223.91,91.36 223.91,91 224.18,90.73 224.28,90.73 224.39,90.62 224.39,90.43 v3(224.31,90.36)
  BOTTOM w0.089: UV1.F8 194.91,73.18 194.82,73.27 v3(194.82,73.56) ; v3(224.31,90.36) 224.18,90.36 223.91,90.09 UV13.D4
FBC_WCK0_N: length 41.1
  IN6 w0.119: v3(224.31,91.16) 224.18,91.29 224.12,91.35 224.12,91.45 223.78,91.78 221.65,91.78 219.09,89.22 219.09,86 216.78,83.7 215.93,83.7 213.99,81.75 210.51,81.75 204.76,75.99 203.97,75.99 202.69,74.71 196.54,74.71 195.77,73.94 194.53,73.94 194.15,73.56 v3(194.02,73.56)
  BOTTOM w0.089: v3(194.02,73.56) 194.02,73.56 UV1.G8 ; UV13.D5 v3(224.31,91.16)
FBC_WCK1: length 32.9
  IN6 w0.119: v3(193.2,76.78) 193.13,76.78 192.81,77.1 192.81,78.24 193.05,78.48 198.26,78.48 201.1,81.32 203.13,81.32 206.99,85.19 206.99,86.55 212.24,91.8 214.74,91.8 215.1,91.44 215.1,90.76 v3(215.51,90.36)
  BOTTOM w0.089: UV13.P4 v3(215.51,90.36)
  BOTTOM w0.11: v3(193.2,76.78) UV1.H12
FBC_WCK1_N: length 33
  IN6 w0.119: v3(215.51,91.16) 215.34,91.32 215.34,91.5 214.83,92.01 212.16,92.01 206.78,86.64 206.78,85.27 203.04,81.53 201.01,81.53 198.17,78.69 192.96,78.69 192.6,78.33 192.6,76.97 v3(192.4,76.78)
  BOTTOM w0.089: UV13.P5 v3(215.51,91.16)
  BOTTOM w0.11: UV1.J12 192.63,76.2 192.48,76.2 192.4,76.28 v3(192.4,76.78)
FBC_WCK2: length 43.2
  TOP w0.089: UV12.P4 v3(223.51,90.36)
  IN1 w0.119: v3(223.51,90.36) 223.1,90.76 223.1,91.26 223.05,91.32 223.05,91.63 222.87,91.8 219.44,91.8 218.73,92.51 218.73,95.89 218.07,96.56 218.07,97.82 218.51,98.26 218.51,99.24 217.62,100.13 210.68,100.13 202.55,92 202.55,90.44 201.28,89.16 201.28,89.16 200.92,88.8 200.92,88.05 200.56,87.68 197.27,87.68 197.14,87.56 197.14,87.24 v3(197.2,87.18)
  BOTTOM w0.11: v3(197.2,87.18) 196.96,87.42 UV1.D26
FBC_WCK2_N: length 43.3
  TOP w0.089: UV12.P5 v3(223.51,91.16)
  IN1 w0.119: v3(223.51,91.16) 223.51,91.16 223.26,91.4 223.26,91.72 222.96,92.02 219.53,92.02 218.94,92.6 218.94,95.98 218.28,96.65 218.28,97.74 218.72,98.17 218.72,99.33 217.7,100.34 210.59,100.34 202.34,92.09 202.34,90.53 201.07,89.25 201.07,89.25 200.71,88.89 200.71,88.13 200.47,87.89 197.18,87.89 196.93,87.64 196.93,87.44 196.67,87.18 v3(196.4,87.18)
  BOTTOM w0.11: UV1.E26 v3(196.4,87.18)
FBC_WCK3: length 45
  TOP w0.089: UV12.D4 v3(216.31,90.36)
  IN1 w0.119: v3(216.31,90.36) 216.31,90.55 216.73,90.98 216.73,91.98 218.5,93.75 218.5,95.6 217.71,96.39 217.71,97.06 217.24,97.53 217.24,98.72 216.83,99.13 210.27,99.13 203.14,91.99 203.14,90.26 201.27,88.39 201.27,87.23 199.47,85.43 199.47,84.16 198.53,83.22 193.19,83.22 193.06,83.09 192.49,83.09 v3(192.41,83.17)
  BOTTOM w0.089: v3(192.41,83.17) 192.8,82.78 UV1.J20
FBC_WCK3_N: length 45.2
  TOP w0.089: UV12.D5 215.91,91.33 216.02,91.44 216.26,91.44 216.31,91.39 v3(216.31,91.16)
  IN1 w0.119: v3(192.4,82.38) 192.4,82.63 192.66,82.88 193.15,82.88 193.28,83.01 198.62,83.01 199.68,84.08 199.68,85.34 201.48,87.14 201.48,88.31 203.35,90.17 203.35,91.91 210.36,98.92 216.74,98.92 217.03,98.63 217.03,97.44 217.5,96.98 217.5,96.3 218.29,95.51 218.29,93.84 216.52,92.07 216.52,91.37 v3(216.31,91.16)
  BOTTOM w0.089: UV1.K20 192.36,82.78 192.52,82.62 192.52,82.49 v3(192.4,82.38)
FBC_WE#_H: length 38.1
  TOP w0.089: 212.67,95.44 212.97,95.44 213.2,95.21 213.2,94.54 213.74,94 218.25,94 218.61,94.35 218.61,94.98 218.42,95.17 218.2,95.17 218,95.36 218,95.74 218.31,96.05 UV12.G12
  TOP w0.157: v3(201.34,84.54) 201.33,84.54 201.11,84.76 201.11,87.4 201.28,87.58 201.28,89.61 202.18,90.51 202.18,92.1 202,92.29 202,92.29 201.81,92.48 201.81,94.26 204.18,96.64 v1(205.04,96.64) 211.46,96.64 211.79,96.31 211.79,95.73 212.08,95.44 212.67,95.44
  BOTTOM w0.157: v3(201.34,84.54) 200.96,84.54 200.11,83.69 199.6,83.18 197.27,83.18 197.17,83.28 197.17,83.48 197.27,83.58 UV1.C21
FBC_WE#_L: length 35.8
  BOTTOM w0.089: 201.11,78.47 201.04,78.47 199.6,77.03 199.04,77.03 198.4,76.39 UV1.B12 ; 218.42,93.64 219.41,94.63 219.41,94.88 219.19,95.11 218.3,95.11 217.93,95.47 217.93,95.98 UV13.L12
  BOTTOM w0.157: 201.11,78.47 201.45,78.47 202.16,79.18 203.68,79.18 206.81,82.32 206.81,89.01 v1(207.87,90.07) 211.79,93.98 213,93.98 213.35,93.64 218.42,93.64
FBD_ABI#_H: length 43.5
  BOTTOM w0.089: UV16.J4 219.6,72.23 219.6,72.91 219.62,72.94 219.62,73.73
  BOTTOM w0.157: UV1.L1 191.2,66.75 191.25,66.7 191.75,66.19 194.76,66.19 194.88,66.07 199.68,66.07 200.13,66.51 200.66,66.51 200.92,66.77 204.09,66.77 v1(204.79,67.46) 208.6,71.27 208.6,72.24 208.15,72.69 208.15,73.57 209.53,74.95 209.79,74.95 209.94,75.11 209.94,76 210.13,76.19 210.39,76.19 210.57,76 210.57,75.11 210.73,74.95 211.05,74.95 211.2,75.11 211.2,76.09 211.39,76.28 211.65,76.28 211.83,76.09 211.83,75.11 211.99,74.95 212.4,74.95 212.56,75.11 212.56,75.68 212.72,75.83 213.03,75.83 213.19,75.68 213.19,74.89 213.36,74.71 218.64,74.71 219.62,73.73
FBD_ABI#_L: length 56.9
  TOP w0.089: 212.16,73.43 212.23,73.43 212.42,73.25 212.63,73.25 213.53,74.14 218.93,74.14 219.6,73.46 219.6,73.1 219.67,73.03 220.03,73.03 220.21,72.85 220.21,71.99 220.58,71.62 220.58,71.42 220.39,71.24 220.28,71.24 220.01,71.5 219.86,71.5 219.58,71.22 219.47,71.22 219.37,71.33 219.37,71.54 219.41,71.58 219.41,71.97 219.48,72.04 219.79,72.04 UV15.J4
  TOP w0.157: v3(182.74,63.83) 183.03,63.83 183.05,63.85 183.12,63.85 183.32,64.04 184.43,64.04 184.69,63.78 184.95,63.52 185.29,63.17 189.03,63.17 190.41,64.55 191.2,65.34 196.25,65.34 197.23,66.32 197.23,66.39 197.68,66.83 197.68,67.06 197.58,67.16 197.58,67.38 197.8,67.61 198.02,67.61 198.13,67.5 198.35,67.5 198.57,67.73 198.57,67.95 198.47,68.05 198.47,68.28 198.69,68.5 198.91,68.5 199.02,68.39 199.24,68.39 199.77,68.93 200.17,68.93 200.45,68.66 200.67,68.66 200.9,68.89 200.9,69.16 200.64,69.42 200.56,69.5 200.46,69.6 200.46,70.02 200.8,70.35 201.04,70.6 201.49,70.6 201.72,70.83 201.72,71.28 201.99,71.54 202.38,71.54 202.63,71.79 202.63,72.19 204.22,73.78 v1(208.8,73.78) 210.36,73.78 210.71,73.43 212.16,73.43 212.16,73.43
  BOTTOM w0.157: v3(182.74,63.83) 182.54,63.83 181.55,64.82 181.55,65.17 182.26,65.88 182.26,67.29 181.97,67.59 181.97,68.01 UV1.AC2
FBD_CAS#_H: length 41.6
  BOTTOM w0.089: 200.93,70.26 200.47,69.8 200.47,69.18 200.17,68.87 199.8,68.87 199.68,68.75 197.98,68.75 UV1.C2
  BOTTOM w0.157: UV16.G3 221.51,71.43 221.11,71.83 221.11,72.87 220.92,73.06 220.32,73.06 220.17,73.22 220.17,73.98 219.91,74.23 219.91,74.45 220.03,74.57 220.03,74.79 219.81,75.02 219.58,75.02 219.47,74.9 219.25,74.9 218.35,75.8 216.25,75.8 216.09,75.64 216.09,75.43 215.94,75.27 215.62,75.27 215.46,75.43 215.46,75.64 215.31,75.8 214.99,75.8 214.83,75.64 214.83,75.43 214.68,75.27 214.36,75.27 214.2,75.43 214.2,75.64 214.05,75.8 213.87,75.8 213.17,76.5 213.17,77.83 212.8,78.2 212.26,78.2 212.02,78.44 212.02,79.12 212.45,79.55 212.45,81.15 212.31,81.29 211.95,81.29 211.83,81.17 211.83,79.91 211.28,79.36 211.28,77.95 210.92,77.59 210.15,77.59 209.79,77.22 208.92,76.35 206.65,74.09 206.65,74.09 205.79,73.23 204.79,73.23 203.15,71.58 203.12,71.58 v2(202.33,70.79) 201.79,70.26 200.93,70.26
FBD_CAS#_L: length 57.4
  TOP w0.089: UV15.L3 221.2,71.43 221.2,72.93 221.77,73.5 221.77,74.55 221.24,75.08 220.59,75.08 220.21,74.71 213.36,74.71 213.3,74.77 212.16,74.77
  TOP w0.157: v3(179.21,65.18) 180.24,66.21 184.24,66.21 185.97,64.48 188.45,64.48 190.58,66.61 194.8,66.61 195.26,67.08 195.26,67.84 195.78,68.35 197.34,68.35 198.71,69.72 198.71,70.14 203.66,75.09 v1(206.72,75.09) 210.9,75.09 211.23,74.77 212.16,74.77
  BOTTOM w0.157: v3(179.21,65.18) 179.21,67.05 178.81,67.45 178.81,68.77 UV1.AG3
FBD_CKE_H: length 38.1
  TOP w0.157: v3(203.96,70.57) 203.96,70.26 203.98,70.25 203.98,69.36 204.19,69.15 204.62,69.15 204.78,69.3 v1(204.78,69.61) 204.78,70.3 204.94,70.46 205.25,70.46 205.41,70.3 205.41,69.3 205.57,69.15 205.88,69.15 206.04,69.3 206.04,70.3 206.2,70.46 206.51,70.46 206.67,70.3 206.67,69.3 206.83,69.15 207.14,69.15 207.3,69.3 207.3,70.3 207.46,70.46 207.77,70.46 207.93,70.3 207.93,69.3 208.09,69.15 208.63,69.15 209.74,68.04 RV152.2 212.32,68.02 v3(212.35,67.99)
  BOTTOM w0.089: UV1.D1 196.8,67.52 197.1,67.21 199.26,67.21 199.7,67.66 200.06,67.66 200.56,68.16 200.56,68.37 200.92,68.72 200.92,69.04 201.11,69.24 ; UV16.J3 220.23,70.81 220.23,70.09 220.04,69.9 219.78,69.9 219.6,69.72 219.6,69.4 219.72,69.28 219.72,68.18
  BOTTOM w0.157: 219.72,68.18 219.72,68.04 219.58,67.91 219.11,67.91 218.33,67.13 212.63,67.13 212.35,67.41 v3(212.35,67.99) ; 201.11,69.24 202.01,69.24 203.4,70.63 203.9,70.63 v3(203.96,70.57)
FBD_CKE_L: length 53.5
  TOP w0.089: 218.56,68.18 219.41,69.03 219.41,70.2 219.53,70.31 219.53,70.74 UV15.J3
  TOP w0.157: 218.56,68.18 218.56,67.92 218.23,67.59 215.69,67.59 215.2,67.1 213.79,67.1 213.34,66.65 212.41,66.65 211.61,65.85 RV150.2 210.9,66.3 206.8,66.3 206.26,66.84 205.33,66.84 204.54,66.04 200.89,66.04 197.34,62.49 191.44,62.49 189.88,60.93 188.97,60.93 188.97,60.93 v1(183.33,60.93) 182.96,60.93 v3(180.94,62.96)
  BOTTOM w0.157: v3(180.94,62.96) 180.85,62.87 179.86,62.87 178.34,64.39 178.34,66.73 178.02,67.04 178.02,68 UV1.AG2
FBD_CLK0: length 64.1
  TOP w0.089: v3(219.51,77.92) UV15.J12
  IN2 w0.119: v3(219.51,77.92) 219.31,77.72 219.08,77.72 218.66,77.3 218.66,76.23 218.06,75.63 212.95,75.63 209.84,78.74 208.4,78.74 208.28,78.86 208.28,81.45 208.03,81.7 207.51,81.7 207.26,81.45 207.26,78.86 207.14,78.74 206.79,78.74 206.67,78.86 206.67,80.77 206.42,81.02 205.9,81.02 205.65,80.77 205.65,78.27 205.15,77.77 204.49,77.77 204.37,77.89 204.37,79.4 204.13,79.64 203.6,79.64 203.36,79.4 203.36,77.89 203.24,77.77 202.88,77.77 202.76,77.89 202.76,79.4 202.52,79.64 201.98,79.64 201.74,79.4 201.74,77.87 201.65,77.77 201.41,77.77 200.45,78.74 190.63,78.74 188.06,76.16 188.06,75.24 187.78,74.97 186.49,74.97 186.28,75.17 185.79,75.17 185.47,74.85 185.47,74.53 185.31,74.38 v3(185.2,74.38)
  IN6 w0.119: v3(219.51,77.92) 219.72,78.13 219.72,79.2 220.04,79.52 220.04,82.06 v3(219.84,82.26)
  BOTTOM w0.112: UV1.V9 v3(185.2,74.38)
  BOTTOM w0.14: RV182.1 219.7,82.4 v3(219.84,82.26)
FBD_CLK0#: length 65.2
  TOP w0.089: UV15.J11 v3(219.51,77.12)
  IN2 w0.119: v3(186,74.34) 185.85,74.34 185.68,74.54 185.68,74.76 185.87,74.96 186.2,74.96 186.4,74.75 187.87,74.75 188.27,75.15 188.27,76.08 190.72,78.53 200.36,78.53 201.33,77.56 201.73,77.56 201.95,77.78 201.95,79.31 202.07,79.43 202.43,79.43 202.55,79.31 202.55,77.8 202.79,77.56 203.32,77.56 203.57,77.8 203.57,79.31 203.69,79.43 204.04,79.43 204.16,79.31 204.16,77.8 204.41,77.56 205.23,77.56 205.86,78.19 205.86,80.68 205.99,80.81 206.33,80.81 206.46,80.68 206.46,78.77 206.7,78.53 207.23,78.53 207.47,78.77 207.47,81.36 207.6,81.49 207.94,81.49 208.07,81.36 208.07,78.77 208.31,78.53 209.76,78.53 212.87,75.41 218.14,75.41 218.87,76.14 218.87,77.21 219.17,77.51 219.56,77.51 219.64,77.43 219.64,77.25 v3(219.51,77.12)
  IN6 w0.119: v3(220.42,82.26) 220.25,82.09 220.25,79.44 219.93,79.11 219.93,77.66 219.51,77.24 v3(219.51,77.12)
  BOTTOM w0.112: v3(186,74.34) 185.6,74.74 UV1.V10
  BOTTOM w0.14: v3(220.42,82.26) 220.42,83.02 RV182.2
FBD_CLK1: length 55.6
  TOP w0.14: RV212.1 221.31,82.94 221.31,82.44 v3(221.11,82.24)
  IN2 w0.119: v3(220.31,78.72) 220.48,78.55 220.62,78.55 221.02,78.15 221.02,75.95 219.59,74.51 212.68,74.51 211.33,75.86 209.94,75.86 209.69,76.1 209.69,77.01 209.57,77.13 209.22,77.13 209.1,77.01 209.1,76.1 208.85,75.86 208.32,75.86 208.08,76.1 208.08,77.04 207.96,77.16 207.6,77.16 207.48,77.04 207.48,76.1 207.24,75.86 206.71,75.86 206.46,76.1 206.46,77.04 206.34,77.16 205.99,77.16 205.87,77.04 205.87,76.1 205.62,75.86 202.24,75.86 200.89,77.21 200.05,78.04 192.08,78.04 191.39,77.35 191.39,77.23 188.46,74.3 188.46,72 188.13,71.67 188.13,71.44 v3(188.4,71.18)
  IN6 w0.119: v3(221.11,82.24) 221.28,82.07 221.28,81.42 220.5,80.63 220.5,78.91 220.47,78.89 v3(220.31,78.72)
  BOTTOM w0.089: UV1.R6 v3(188.4,71.18) ; v3(220.31,78.72) UV16.J12
FBD_CLK1#: length 56.5
  TOP w0.14: v3(221.74,82.24) 221.55,82.44 221.55,82.94 RV212.2
  IN2 w0.119: v3(220.31,77.92) 220.31,78.22 220.43,78.34 220.53,78.34 220.81,78.06 220.81,76.04 219.5,74.72 212.76,74.72 211.42,76.07 210.02,76.07 209.9,76.19 209.9,77.09 209.65,77.35 209.14,77.35 208.89,77.09 208.89,76.19 208.77,76.07 208.41,76.07 208.29,76.19 208.29,77.13 208.05,77.37 207.51,77.37 207.27,77.13 207.27,76.19 207.15,76.07 206.79,76.07 206.67,76.19 206.67,77.13 206.43,77.37 205.9,77.37 205.66,77.13 205.66,76.19 205.54,76.07 202.32,76.07 201.04,77.35 200.14,78.25 191.99,78.25 191.18,77.44 191.18,77.31 188.25,74.39 188.25,72.09 187.92,71.76 187.92,71.5 v3(187.6,71.18)
  IN6 w0.119: v3(221.74,82.24) 221.49,81.99 221.49,81.33 220.71,80.55 220.71,78.32 220.31,77.92 v3(220.31,77.92)
  BOTTOM w0.089: v3(220.31,77.92) UV16.J11
  BOTTOM w0.112: UV1.R5 v3(187.6,71.18)
FBD_CS#_H: length 46.9
  IN4 w0.112: v3(218.71,78.72) 219.12,78.32 219.12,77.7 218.57,77.16 218.57,75.89 217.6,74.91 215.08,74.91 213.32,73.16 213.32,72.57 209.88,69.13 208.9,69.13 v3(208.04,68.26)
  BOTTOM w0.089: UV16.L12 v3(218.71,78.72)
  BOTTOM w0.157: v3(208.04,68.26) 208,68.23 208,66.36 205.74,64.1 202.03,64.1 199.71,61.77 190.1,61.77 v1(187.17,64.7) 186.4,65.47 UV1.U1
FBD_CS#_L: length 57
  TOP w0.089: UV15.G12 218.31,78.01 218,77.71 218,77.26 218.12,77.14 218.51,77.14 218.61,77.03 218.61,76.32 218.18,75.89 213.82,75.89 213.07,76.64 213.07,76.76 213.38,77.07 213.38,77.22 213.27,77.33 213.13,77.33 212.82,77.01 212.69,77.01 212.36,77.35
  TOP w0.157: v3(185.19,67.97) 185.19,68.27 185.06,68.4 184.25,68.4 184.12,68.53 184.12,68.99 184.25,69.12 184.68,69.12 184.81,69.24 184.81,72.99 184.93,73.12 185.42,73.12 185.55,72.99 185.55,72.5 185.68,72.37 186.97,72.37 187.2,72.14 187.2,71.71 187.32,71.58 187.96,71.58 188.09,71.71 188.09,72.25 188.22,72.37 189.84,72.37 190.2,72.37 191.01,73.18 191.84,73.18 192.09,72.93 192.34,72.93 192.55,73.13 192.55,73.35 191.93,73.98 191.93,74.16 192.2,74.42 192.38,74.42 193,73.8 193.22,73.8 194.58,75.16 194.58,75.39 193.96,76.01 193.96,76.19 194.23,76.45 194.41,76.45 195.03,75.83 195.25,75.83 195.76,76.34 198.44,76.34 198.55,76.46 198.55,77.05 198.64,77.14 199.1,77.14 199.18,77.05 199.18,76.51 199.34,76.35 199.96,76.35 200.44,76.83 200.44,77.06 200,77.5 200,78.21 200.12,78.34 v1(207.13,78.34) 211.37,78.34 212.36,77.35 212.36,77.35
  BOTTOM w0.13: UV1.V2 185.59,68.38 v3(185.19,67.97)
FBD_D0: length 64
  TOP w0.089: UV15.A4 v3(213.11,71.52)
  IN1 w0.119: v3(179.6,72.78) 179.69,72.78 180.31,73.39 180.31,73.56 179.9,73.97 179.9,74.15 180.06,74.3 180.24,74.3 180.64,73.9 180.81,73.9 181.01,74.1 181.01,75.26 181.14,75.38 181.36,75.38 181.49,75.26 181.49,74.1 181.61,73.98 183.16,73.98 183.3,74.12 183.3,75.31 183.43,75.44 183.72,75.44 183.85,75.31 183.85,74.12 183.99,73.98 184.65,73.98 184.8,73.83 184.8,73.2 184.91,73.08 185.26,73.08 185.39,72.95 185.39,72.73 185.26,72.6 184.91,72.6 184.8,72.48 184.8,69.39 184.99,69.19 185.32,69.19 186.47,68.05 187.34,68.05 187.62,67.77 187.62,67.24 187.77,67.09 187.77,66.92 187.57,66.73 187.57,66.56 187.74,66.39 187.91,66.39 188.11,66.58 188.27,66.58 188.44,66.41 188.44,66.25 188.25,66.05 188.25,65.88 188.42,65.71 188.59,65.71 188.78,65.91 188.95,65.91 189.12,65.74 189.12,65.57 188.93,65.38 188.93,65.21 189.1,65.03 189.27,65.03 189.46,65.22 189.64,65.22 189.79,65.06 189.79,64.88 189.61,64.7 189.61,64.53 189.97,64.17 190.31,64.17 190.44,64.3 190.44,64.82 190.57,64.95 190.83,64.95 190.95,64.83 190.95,64.29 191.07,64.17 191.31,64.17 191.43,64.29 191.43,64.83 191.55,64.95 191.8,64.95 191.91,64.83 191.91,64.29 192.03,64.17 192.27,64.17 192.39,64.29 192.39,64.83 192.51,64.95 192.76,64.95 192.88,64.83 192.88,64.3 193,64.17 193.23,64.17 193.35,64.3 193.35,64.83 193.47,64.95 193.97,64.95 194.09,64.83 194.09,64.7 194.22,64.57 194.44,64.57 194.57,64.7 194.57,64.83 194.69,64.95 195.12,64.95 195.24,64.83 195.24,64.3 195.36,64.17 195.61,64.17 195.73,64.29 195.73,64.88 195.86,65.01 196.08,65.01 196.21,64.88 196.21,64.29 196.33,64.17 196.99,64.17 197.05,64.23 201.17,64.23 201.49,64.55 205.11,64.55 209.97,69.41 209.97,69.72 211.77,71.52 211.77,71.52 212.6,72.35 213.24,72.35 213.43,72.16 213.43,71.84 v3(213.11,71.52)
  BOTTOM w0.089: UV1.AF7 v3(179.6,72.78)
FBD_D1: length 65.7
  TOP w0.089: UV15.A2 v3(213.11,69.92)
  IN1 w0.119: v3(179.6,74.38) 179.6,75.21 179.47,75.34 178.75,75.34 178.6,75.18 178.6,70.93 178.75,70.78 183,70.78 183.19,70.59 183.19,68.52 185.05,66.66 185.08,66.66 186.49,65.25 186.49,64.35 187.95,62.89 201.49,62.89 202.09,63.49 205.69,63.49 206.88,62.3 207.06,62.3 207.22,62.46 207.22,62.64 206.12,63.73 206.12,63.91 206.29,64.08 206.47,64.08 207.82,62.72 208,62.72 208.16,62.88 208.16,63.06 206.8,64.41 206.8,64.59 206.96,64.75 207.14,64.75 208.49,63.4 208.67,63.4 208.83,63.56 208.83,63.74 207.48,65.09 207.48,65.27 207.64,65.43 207.82,65.43 209.17,64.07 209.35,64.07 209.51,64.23 209.51,64.41 208.19,65.73 208.19,65.9 210.37,68.07 211.61,68.07 211.84,68.3 211.84,69.13 212.63,69.92 v3(213.11,69.92)
  BOTTOM w0.089: UV1.AF9 v3(179.6,74.38)
FBD_D2: length 55.3
  TOP w0.089: UV15.B4 213.92,72.31 213.38,72.31 212.75,71.67 212.75,71.16 212.67,71.08
  TOP w0.157: v3(212.48,70.77) 212.48,70.89 212.67,71.08
  IN1 w0.119: v3(212.48,70.77) 212.85,71.14 212.85,71.24 212.5,71.59 212.35,71.59 210.38,69.62 210.38,69.29 205.29,64.2 201.64,64.2 201.25,63.82 189.82,63.82 187.3,66.34 187.3,66.9 185.81,68.39 185.04,68.39 184.71,68.72 184.54,68.72 184.26,68.44 184.09,68.44 183.92,68.61 183.92,68.78 184.2,69.06 184.2,69.23 183.86,69.57 183.86,72.15 183.74,72.27 183.27,72.27 183.14,72.4 183.14,72.62 183.27,72.75 183.82,72.75 183.95,72.87 183.95,73.71 183.82,73.84 183.33,73.84 183.21,73.71 183.21,73.33 183.08,73.2 181.69,73.2 181.56,73.33 181.56,73.71 181.44,73.84 181.06,73.84 180.78,73.55 180.78,73.34 180.9,73.22 181.05,73.22 181.17,73.1 181.17,72.87 180.58,72.28 180.58,71.91 180.45,71.79 180.22,71.79 180.1,71.91 180.1,72.28 179.98,72.4 179.2,72.4 179.07,72.27 179.07,72.1 179.2,71.98 v3(179.6,71.98)
  BOTTOM w0.089: UV1.AF6 179.2,71.85 179.33,71.98 v3(179.6,71.98)
FBD_D3: length 58.7
  TOP w0.089: UV15.B2 v3(213.91,70.72)
  IN1 w0.119: v3(179.6,73.58) 179.35,73.58 179.22,73.7 179.22,74.97 179.11,75.08 178.96,75.08 178.82,74.95 178.82,71.72 178.98,71.57 183.4,71.57 183.53,71.44 183.53,68.68 184.62,67.6 186.18,67.6 186.35,67.42 186.35,67.25 186.12,67.02 186.12,66.84 186.28,66.68 186.46,66.68 186.69,66.91 186.86,66.91 187.01,66.77 187.01,66.53 186.44,65.97 186.44,65.79 186.6,65.63 186.78,65.63 187.06,65.91 187.24,65.91 187.4,65.74 187.4,65.56 186.84,65 186.84,64.82 187,64.66 187.18,64.66 187.74,65.23 187.92,65.23 188.08,65.06 188.08,64.88 187.36,64.15 187.36,63.97 187.51,63.82 187.69,63.82 188.42,64.55 188.6,64.55 188.76,64.39 188.76,64.21 188.13,63.57 188.13,63.39 188.28,63.24 188.46,63.24 189.1,63.88 189.27,63.88 189.68,63.47 201.4,63.47 201.78,63.86 205.43,63.86 210.63,69.05 211.27,69.05 212.56,70.35 213.83,70.35 213.91,70.42 v3(213.91,70.72)
  BOTTOM w0.089: v3(179.6,73.58) 179.53,73.65 179.29,73.65 179.2,73.56 UV1.AF8
FBD_D4: length 61.2
  TOP w0.089: UV15.E4 v3(217.11,72.32)
  IN1 w0.119: v3(217.11,72.32) 217.5,71.94 217.5,69.63 217.3,69.43 215.7,69.43 215.52,69.26 215.52,67.75 208.46,60.69 208.46,58.71 205.48,55.73 201.94,55.73 196.71,60.96 187.58,60.96 182.08,66.46 180.52,66.46 178.47,68.51 178.47,68.99 177.18,70.28 177.18,71.96 v3(178,72.78)
  BOTTOM w0.089: UV1.AG7 v3(178,72.78)
FBD_D5: length 56.6
  TOP w0.089: UV15.E2 v3(217.11,70.72)
  IN1 w0.119: v3(178,71.98) 177.62,71.6 177.62,70.39 179.63,68.38 180.66,68.38 187.67,61.37 196.79,61.37 202.09,56.08 205.34,56.08 208.05,58.79 208.05,60.86 214.71,67.52 214.71,69.32 215.73,70.34 216.73,70.34 v3(217.11,70.72)
  BOTTOM w0.089: UV1.AG6 v3(178,71.98)
FBD_D6: length 65.3
  TOP w0.089: UV15.F4 v3(217.91,72.32)
  IN1 w0.119: v3(217.91,72.32) 218.29,71.95 218.29,71.24 218,70.96 218,68.44 217.59,68.02 217.23,68.02 214.13,64.92 214.13,63.39 205.77,55.03 201.65,55.03 196.54,60.14 187.42,60.14 181.77,65.79 180.06,65.79 176.19,69.66 176.19,72.96 177.08,73.85 177.48,73.85 v3(178,74.38)
  BOTTOM w0.089: UV1.AG9 v3(178,74.38)
FBD_D7: length 60.5
  TOP w0.089: UV15.F2 217.51,70.31 217.81,70 217.81,69.26 217.87,69.2 217.87,68.85 v3(217.5,68.47)
  IN1 w0.119: v3(217.5,68.47) 217.19,68.47 213.72,65 213.72,63.47 205.63,55.38 201.8,55.38 196.67,60.5 187.55,60.5 181.86,66.19 180.24,66.19 177.96,68.47 177.96,68.95 176.7,70.21 176.7,72.81 177.07,73.18 177.6,73.18 v3(178,73.58)
  BOTTOM w0.089: UV1.AG8 v3(178,73.58)
FBD_D8: length 43.6
  TOP w0.089: 212.67,78.13 212.9,78.13 UV15.A11
  TOP w0.157: v3(210.38,78.89) v1(211.46,78.89) 211.6,78.89 212.36,78.13 212.67,78.13
  IN3 w0.112: v3(210.38,78.89) 209.65,78.17 209.65,77.99 209.49,77.83 209.33,77.83 208.91,78.25 208.75,78.25 208.6,78.09 208.6,77.93 209.02,77.51 209.02,77.36 208.86,77.2 208.7,77.2 208.28,77.62 208.12,77.62 207.96,77.46 207.96,77.3 208.39,76.88 208.39,76.72 208.23,76.56 208.07,76.56 207.65,76.99 207.49,76.99 207.33,76.83 207.33,76.67 207.75,76.25 207.75,76.09 207.59,75.93 207.44,75.93 207.02,76.35 206.86,76.35 206.7,76.19 206.7,76.04 207.12,75.62 207.12,75.46 206.96,75.3 206.8,75.3 206.38,75.72 206.22,75.72 206.07,75.56 206.07,75.4 206.49,74.98 206.49,74.83 206.33,74.67 206.17,74.67 205.75,75.09 205.59,75.09 201.97,71.46 198.44,71.46 197.75,70.78 184.14,70.78 184.03,70.89 182.52,70.89 v3(182,70.37)
  BOTTOM w0.089: UV1.AC5 v3(182,70.37)
FBD_D9: length 37.4
  TOP w0.089: UV15.A13 212.85,79.12 212.67,78.94 212.67,78.86
  TOP w0.157: 212.67,78.86 v3(212.49,78.69)
  IN3 w0.112: v3(212.49,78.69) 212.49,78.4 202.25,68.16 200.6,68.16 200.28,67.85 199.58,67.85 199.05,68.38 196.13,68.38 196.02,68.27 196.02,68.09 195.89,67.96 195.62,67.96 195.5,68.09 195.5,68.27 195.39,68.38 184.64,68.38 184.15,68.86 184.11,68.86 183.4,69.58 v3(182.8,69.58)
  BOTTOM w0.089: UV1.AA4 v3(182.8,69.58)
FBD_D10: length 40.9
  TOP w0.089: UV15.B11 v3(213.91,77.92)
  IN3 w0.112: v3(182,69.57) 182.4,69.18 183.14,69.18 184.73,67.58 186.44,67.58 187.44,66.59 199.6,66.59 199.77,66.77 201.85,66.77 202.04,66.95 202.04,67.11 201.64,67.51 201.64,67.69 201.77,67.82 201.95,67.82 202.35,67.42 202.51,67.42 213.45,78.37 213.8,78.37 213.91,78.26 v3(213.91,77.92)
  BOTTOM w0.089: v3(182,69.57) 181.6,69.97 UV1.AC4
FBD_D11: length 41.3
  TOP w0.089: UV15.B13 v3(213.91,79.52)
  IN3 w0.112: v3(213.91,79.52) 214.3,79.13 214.3,77.76 214.07,77.53 213.1,77.53 201.99,66.43 200.19,66.43 199.84,66.07 187.24,66.07 186.67,66.64 184.14,66.64 v3(182,68.77)
  BOTTOM w0.089: UV1.AC3 181.6,69.17 v3(182,68.77)
FBD_D12: length 44.4
  TOP w0.089: UV15.E11 v3(216.31,77.12)
  IN3 w0.112: v3(216.31,77.12) 215.92,76.73 212.78,76.73 202.14,66.09 200.93,66.09 200.46,65.62 187.1,65.62 186.39,66.33 183.29,66.33 181.17,68.46 181.17,69.61 v3(180.4,70.38)
  BOTTOM w0.089: v3(180.4,70.38) UV1.AD4
FBD_D13: length 48.2
  TOP w0.089: UV15.E13 217.01,79.43 217.01,80.66 216.79,80.88
  TOP w0.157: v3(216.48,81.13) 216.55,81.13 216.79,80.88
  IN3 w0.112: v3(216.48,81.13) 215.97,81.63 211.02,81.63 202.63,73.24 197.8,73.24 196.95,72.38 184.24,72.38 183.45,73.17 180.24,73.17 180.01,72.94 180.01,69.17 v3(180.4,68.78)
  BOTTOM w0.089: UV1.AD2 v3(180.4,68.78)
FBD_D14: length 49.8
  TOP w0.089: 218.58,80.73 218.58,80.63 218,80.06 218,78.02 UV15.F11
  TOP w0.157: 218.58,80.73 218.58,81.07 217.56,82.09 v1(215.86,82.09) 215.33,82.09 214.49,81.24 214.05,81.24 v3(213.49,80.69)
  IN3 w0.112: v3(180.4,71.18) 180.53,71.31 180.53,72.35 180.86,72.68 181.29,72.68 181.55,72.42 181.55,72.19 181.59,72.14 181.59,71.72 181.74,71.58 197.79,71.58 198.31,72.1 202.12,72.1 210.99,80.96 213.22,80.96 v3(213.49,80.69)
  BOTTOM w0.089: UV1.AD5 v3(180.4,71.18)
FBD_D15: length 52.4
  TOP w0.089: 217.38,80.88 217.2,80.7 217.2,79.43 UV15.F13
  TOP w0.157: 217.38,80.88 v3(217.43,80.93)
  IN3 w0.089: v3(181.18,67.2) 181.18,67.72 180.49,68.4 180.25,68.4 179.2,69.46
  IN3 w0.112: 179.2,69.46 179.2,72.9 179.48,73.18 179.73,73.18 180.5,73.95 183.13,73.95 183.9,73.18 193.48,73.18 193.49,73.19 197.38,73.19 197.77,73.58 202.33,73.58 210.83,82.08 216.27,82.08 v3(217.43,80.93)
  BOTTOM w0.089: UV1.AD1 v3(181.18,67.2)
FBD_D16: length 45.9
  TOP w0.089: UV15.U11 v3(226.71,77.12)
  IN5 w0.119: v3(226.71,77.12) 226.71,76.57 224.78,74.64 218.95,74.64 218.06,75.53 213.62,75.53 213.55,75.46 201.98,75.46 201.09,74.58 198.76,74.58 198.58,74.76 193.04,74.76 192.28,73.99 192.28,72.39 192.02,72.13 192.02,71.78 191.8,71.55 191.44,71.55 190.69,70.8 190.69,70.45 190.2,69.95 188.55,69.95 188.17,69.58 v3(187.6,69.58)
  BOTTOM w0.089: UV1.R4 v3(187.6,69.58)
FBD_D17: length 51.4
  TOP w0.089: UV15.U13 v3(227.27,79.12)
  IN5 w0.119: v3(186.8,68.78) 187.22,68.35 190.31,68.35 191.93,69.98 192.82,69.98 193.3,70.45 193.3,72.29 194.12,73.12 197.3,73.12 197.42,73.24 203.15,73.24 204.5,74.59 216.78,74.59 217.74,73.62 225.26,73.62 228.04,76.4 228.04,78.75 227.66,79.12 v3(227.27,79.12)
  BOTTOM w0.089: UV1.U3 v3(186.8,68.78)
FBD_D18: length 51.5
  TOP w0.089: UV15.T11 225.76,77.52 226.13,77.9 226.4,77.9 227.14,78.64 227.51,78.64 v3(227.59,78.56)
  IN5 w0.119: v3(186.8,69.58) 187.2,69.18 190.58,69.18 191.08,69.67 191.08,70.45 191.42,70.8 192.56,70.8 192.78,71.02 192.78,71.07 192.79,71.08 192.79,73.12 193.64,73.97 202.12,73.97 203.13,74.97 217.48,74.97 218.32,74.13 225.14,74.13 227.59,76.59 v3(227.59,78.56)
  BOTTOM w0.089: UV1.U4 v3(186.8,69.58)
FBD_D19: length 47.2
  TOP w0.089: UV15.T13 v3(225.11,78.72)
  IN5 w0.119: v3(186.8,70.38) 187.95,70.38 188.34,70.77 190.12,70.77 191.14,71.78 191.14,74.45 192.28,75.59 200.92,75.59 201.14,75.81 201.14,75.81 204.73,75.81 205.8,76.88 212.81,76.88 213.75,75.95 218.28,75.95 219.08,75.15 223.69,75.15 224.72,76.18 224.72,78.33 v3(225.11,78.72)
  BOTTOM w0.089: UV1.U5 v3(186.8,70.38)
FBD_D20: length 50
  TOP w0.089: UV15.N11 222.8,77.83 222.8,79.53 222.61,79.72 222.61,80.21 222.82,80.42 222.82,80.8 222.89,80.86 222.89,80.88
  TOP w0.157: 222.89,80.88 v3(222.89,81.24)
  IN5 w0.119: v3(222.89,81.24) 222.89,81.71 221.9,82.69 214.62,82.69 213.62,81.69 202.44,81.69 198.82,78.07 190.31,78.07 188.41,76.16 188.41,75.08 187.64,74.32 187.33,74.32 186.97,73.97 186.15,73.97 184.81,72.63 184.81,71.57 v3(185.2,71.18)
  BOTTOM w0.089: UV1.V6 v3(185.2,71.18)
FBD_D21: length 49.6
  TOP w0.089: 223.88,80.88 223.72,80.72 223.27,80.72 223.01,80.46 223.01,80.34 222.8,80.13 222.8,79.8 223.11,79.49 UV15.N13
  TOP w0.157: 223.88,80.88 v3(224.2,81.2)
  IN5 w0.119: v3(224.2,81.2) 223.87,80.87 222.5,80.87 221.75,81.62 214.31,81.62 213.81,81.12 203.71,81.12 199.79,77.2 192.8,77.2 192.18,77.83 191.53,77.83 187.66,73.95 187.44,73.95 187.18,73.69 187.18,73.42 186.93,73.17 185.86,73.17 185.61,72.92 185.61,70.78 v3(185.2,70.38)
  BOTTOM w0.089: UV1.V5 v3(185.2,70.38)
FBD_D22: length 57.4
  TOP w0.089: 222.14,80.88 221.88,80.61 221.88,80.26 222,80.13 222,79.71 222.19,79.53 222.44,79.53 222.61,79.36 222.61,77.83 UV15.M11
  TOP w0.157: 222.14,80.88 222.14,81.2 222.73,81.79 222.85,81.79 v1(223.11,82.05) 223.33,82.27 v3(223.33,82.58)
  IN5 w0.119: v3(184.4,69.58) 183.45,70.52 183.45,74.98 184.24,75.77 185.33,75.77 186.06,76.5 186.06,76.57 186.75,77.26 188.1,77.26 189.57,78.73 189.57,80.19 189.99,80.61 199.77,80.61 201.93,82.77 211.97,82.77 212.78,83.58 222.32,83.58 v3(223.33,82.58)
  BOTTOM w0.089: UV1.Y4 v3(184.4,69.58)
FBD_D23: length 53.1
  TOP w0.089: UV15.M13 221.81,79.62 221.81,80.05 221.69,80.18 221.69,80.42 221.57,80.54 221.57,80.88
  TOP w0.157: 221.57,80.88 221.57,81.45 v3(222.7,82.58)
  IN5 w0.119: v3(184.4,70.38) 184.01,70.77 184.01,74.54 184.3,74.83 185.99,74.83 186.25,75.08 186.25,75.53 186.5,75.78 187.87,75.78 188,75.91 188,76.45 190.12,78.58 198.55,78.58 202.24,82.26 212.16,82.26 213.03,83.14 222.14,83.14 v3(222.7,82.58)
  BOTTOM w0.089: UV1.Y5 183.67,70.78 183.57,70.68 183.57,70.48 183.67,70.38 v3(184.4,70.38)
FBD_D24: length 54.1
  TOP w0.089: v3(226.71,73.2) 226.71,72.32 UV15.U4
  IN6 w0.097: v3(184.4,71.98) 184.79,72.37 185.6,72.37 186.18,71.78 186.18,71.02 186.44,70.77 188.04,70.77 188.83,69.98 190.25,69.98 190.44,69.78 190.44,66.26 191.02,65.69 199.2,65.69 199.32,65.57 207.07,65.57 208.3,66.8 215.56,66.8 216.07,67.31 217.85,67.31 219.53,68.98 219.53,70.91 221.32,72.71 226.22,72.71 v3(226.71,73.2)
  BOTTOM w0.089: UV1.Y6 v3(184.4,71.98)
FBD_D25: length 54.5
  TOP w0.089: UV15.U2 v3(226.71,70.72)
  IN6 w0.097: v3(184.4,72.78) UV1.Y7 184,71.74 184.18,71.56 185.56,71.56 185.94,71.18 185.94,70.26 186.23,69.98 188.18,69.98 188.8,69.36 188.8,66.96 190.51,65.24 198.95,65.24 199.03,65.16 207.24,65.16 208.47,66.39 215.73,66.39 216.24,66.9 218.02,66.9 219.84,68.72 219.84,70.6 221.18,71.93 226.13,71.93 226.32,71.74 226.32,71.11 v3(226.71,70.72)
  BOTTOM w0.089: UV1.Y7 v3(184.4,72.78)
FBD_D26: length 56.3
  TOP w0.089: v3(226.5,73.73) 226.5,73.55 225.94,72.99 225.94,72.35 UV15.T4
  IN6 w0.097: v3(184.4,73.58) 184.81,73.17 190.54,73.17 190.76,72.95 190.76,66.52 191.15,66.13 199.71,66.13 199.91,65.93 206.85,65.93 208.13,67.21 215.39,67.21 215.9,67.72 217.74,67.72 219.21,69.18 219.21,71.17 221.87,73.83 226.4,73.83 v3(226.5,73.73)
  BOTTOM w0.089: UV1.Y8 v3(184.4,73.58)
FBD_D27: length 64.7
  TOP w0.089: UV15.T2 v3(225.91,70.72)
  IN6 w0.097: v3(225.91,70.72) 225.52,70.33 225.52,69.65 225.13,69.26 225.13,68.5 223.21,66.58 222.87,66.58 217.93,61.63 212.59,61.63 207.12,56.15 202.34,56.15 196.96,61.53 189.94,61.53 187.37,64.11 185.75,64.11 182.93,66.93 182.18,66.93 180.82,68.29 180.82,72.13 181.54,72.85 181.54,73.91 v3(182,74.38)
  BOTTOM w0.089: UV1.AC9 v3(182,74.38)
FBD_D28: length 61.8
  TOP w0.089: UV15.N4 222.8,71.62 222.8,69.23 222.66,69.09 222.66,68.18
  TOP w0.157: v3(223.21,67.17) 222.66,67.71 222.66,68.18
  IN6 w0.097: v3(182,72.78) 181.61,72.39 181.61,71.72 181.15,71.26 181.15,68.49 182.37,67.27 183.08,67.27 185.9,64.46 187.51,64.46 190.08,61.88 197.1,61.88 202.48,56.5 206.89,56.5 212.36,61.98 217.64,61.98 222.83,67.17 v3(223.21,67.17)
  BOTTOM w0.089: UV1.AC7 v3(182,72.78)
FBD_D29: length 53.8
  TOP w0.089: UV15.N2 v3(223.51,69.92)
  IN6 w0.097: v3(223.51,69.92) 223.51,68.45 217.49,62.44 213.05,62.44 212.49,63.01 199.38,63.01 198.66,62.29 190.25,62.29 186.25,66.3 184.84,66.3 182.84,68.29 181.95,68.29 181.47,68.77 181.47,71.2 182,71.73 v3(182,71.98)
  BOTTOM w0.089: UV1.AC6 v3(182,71.98)
FBD_D30: length 54.8
  TOP w0.089: 221.89,68.18 222.47,68.77 222.47,69.17 222.61,69.31 222.61,71.62 UV15.M4
  TOP w0.157: 221.89,68.18 221.62,67.91 v3(221.62,67.17)
  IN6 w0.097: v3(221.62,67.17) 217.3,62.85 213.56,62.85 213,63.41 199.08,63.41 198.37,62.7 190.42,62.7 186.52,66.6 185.1,66.6 183.39,68.32 183.39,68.8 183.01,69.18 182.56,69.18 182.4,69.34 182.4,73.18 v3(182,73.58)
  BOTTOM w0.089: UV1.AC8 v3(182,73.58)
FBD_D31: length 58
  TOP w0.089: UV15.M2 v3(221.91,70.72)
  IN6 w0.097: v3(182,75.38) 183.75,73.63 183.75,70.39 184.17,69.98 185.74,69.98 186.54,69.18 187.77,69.18 188.16,68.79 188.16,67.05 190.38,64.83 198.59,64.83 198.68,64.75 208.2,64.75 208.32,64.87 208.32,65.74 208.44,65.87 208.67,65.87 208.79,65.74 208.79,64.87 208.91,64.75 209.15,64.75 209.27,64.87 209.27,65.91 209.4,66.04 209.62,66.04 209.75,65.91 209.75,64.87 209.87,64.75 210.95,64.75 211.07,64.87 211.07,65.82 211.19,65.94 211.43,65.94 211.55,65.82 211.55,64.87 211.66,64.75 211.95,64.75 212.98,65.78 217.48,65.78 220.23,68.52 220.23,69.63 220.93,70.33 221.52,70.33 v3(221.91,70.72)
  BOTTOM w0.089: UV1.AC10 v3(182,75.38)
FBD_D32: length 23.7
  IN6 w0.119: v3(194,67.98) 194.4,67.58 195,67.58 195.46,67.11 200.05,67.11 200.76,67.81 206.1,67.81 207.4,69.11 208.35,69.11 208.83,68.63 210.81,68.63 211.36,69.18 v3(211.36,69.81)
  BOTTOM w0.089: v3(194,67.98) 193.7,67.98 193.6,68.08 UV1.H2
  BOTTOM w0.157: v3(211.36,69.81) 212.04,70.49 212.04,71.04 212.93,71.92 UV16.U4
FBD_D33: length 25.3
  IN6 w0.119: v3(210.87,69.47) 210.44,69.04 208.96,69.04 208.48,69.52 207.23,69.52 205.93,68.22 200.72,68.22 200.13,67.63 199.58,67.63 199.21,68 198.73,68 198.2,67.46 196.15,67.46 195.24,68.37 194.57,68.37 194.38,68.56 194.38,69.2 v3(194,69.58)
  BOTTOM w0.089: UV16.U2 212.97,70.32 212.67,70.02 ; UV1.H4 193.6,70.31 193.5,70.41 193.29,70.41 193.19,70.31 193.19,69.68 193.29,69.58 v3(194,69.58)
  BOTTOM w0.157: 212.67,70.02 212.37,70.02 v1(211.43,69.09) 211.25,69.09 v3(210.87,69.47)
FBD_D34: length 26.3
  IN6 w0.119: v3(211.27,68.49) 211,68.22 208.75,68.22 208.29,68.68 207.54,68.68 206.27,67.4 200.92,67.4 200.29,66.78 194.4,66.78 v3(194,67.18)
  BOTTOM w0.089: UV1.H1 v3(194,67.18)
  BOTTOM w0.157: UV16.T4 213.91,72.32 212.51,72.32 211.49,71.3 211.49,70.78 210.43,69.73 210.43,69.03 210.97,68.49 v3(211.27,68.49)
FBD_D35: length 26.5
  IN6 w0.119: v3(194,68.78) 193.49,68.27 193.49,67.04 194.07,66.46 200.5,66.46 200.85,66.82 207.16,66.82 208.16,67.81 211.34,67.81 212.03,68.5 v3(213.1,68.5)
  BOTTOM w0.089: UV16.T2 213.88,69.89 213.88,69.27 v3(213.1,68.5) ; UV1.H3 194.32,69.18 194.42,69.08 194.42,68.88 194.32,68.78 v3(194,68.78)
FBD_D36: length 25.5
  IN6 w0.119: v3(216.31,71.52) 215.89,71.1 215.01,71.1 213.84,72.27 213.55,72.27 212.59,73.23 205.35,73.23 202.75,70.63 199.61,70.63 198.18,69.2 196.1,69.2 195.99,69.31 195.99,69.99 v3(195.6,70.38)
  BOTTOM w0.089: UV1.F5 v3(195.6,70.38) ; UV16.N4 v3(216.31,71.52)
FBD_D37: length 23.2
  IN6 w0.119: v3(216.31,69.92) 216.3,69.93 214.16,69.93 213.49,70.6 213.49,70.91 213.3,71.1 212.92,71.1 212.68,71.35 210.66,71.35 210.35,71.04 206.6,71.04 205.28,69.71 199.4,69.71 198.08,68.39 196.79,68.39 v3(196.4,68.78)
  BOTTOM w0.089: UV1.E2 v3(196.4,68.78) ; UV16.N2 v3(216.31,69.92)
FBD_D38: length 24.4
  IN6 w0.119: v3(217.11,71.52) 216.72,71.91 214.53,71.91 212.8,73.64 205.18,73.64 202.58,71.04 199.27,71.04 198.2,69.97 196.79,69.97 v3(196.4,69.58)
  BOTTOM w0.089: UV16.M4 v3(217.11,71.52) ; UV1.E4 v3(196.4,69.58)
FBD_D39: length 24.4
  IN6 w0.119: v3(197.2,68.78) 198.1,68.78 199.51,70.18 202.88,70.18 205.52,72.82 212.42,72.82 212.67,72.57 213.49,71.75 213.49,71.36 213.74,71.11 214.11,71.11 214.32,70.9 214.32,70.47 214.45,70.34 216.69,70.34 v3(217.11,69.92)
  BOTTOM w0.089: UV16.M2 v3(217.11,69.92) ; UV1.D3 v3(197.2,68.78)
FBD_D40: length 34.1
  IN4 w0.112: v3(213.91,77.12) 213.72,77.12 213.48,76.88 209.21,76.88 207.89,75.56 207.89,75.41 208.9,74.4 208.9,74.24 208.74,74.08 208.58,74.08 207.57,75.09 207.41,75.09 207.26,74.93 207.26,74.77 208.27,73.76 208.27,73.61 208.11,73.45 207.95,73.45 207.32,74.07 207.14,74.07 207.01,73.94 207.01,73.76 207.63,73.13 207.63,72.97 203.52,68.86 199.07,68.86 198.62,68.4 193.37,68.4 192.85,68.93 192.85,69.13 v3(192.4,69.58)
  BOTTOM w0.089: UV1.J4 v3(192.4,69.58) ; UV16.U11 v3(213.91,77.12)
FBD_D41: length 50.2
  IN4 w0.112: v3(218.98,80.48) 218.98,80.46 218.66,80.14 218.3,79.78 218.3,75.97 217.6,75.27 211.45,75.27 202.52,66.34 192.32,66.34 191.6,67.06 v3(191.6,70.38)
  BOTTOM w0.089: UV1.L5 v3(191.6,70.38)
  BOTTOM w0.157: UV16.U13 212.84,79.12 212.71,79.25 212.71,80.53 213.43,81.24 213.59,81.24 v1(214.51,82.16) 215.1,82.76 217.12,82.76 218.98,80.9 v3(218.98,80.48)
FBD_D42: length 33.2
  IN4 w0.112: v3(214.71,77.12) 214.3,76.72 214.3,76.16 214.09,75.95 211.16,75.95 210.72,75.5 210.56,75.5 209.68,76.38 209.52,76.38 209.36,76.23 209.36,76.07 210.24,75.19 210.24,75.03 210.08,74.87 209.93,74.87 209.04,75.75 208.89,75.75 208.73,75.59 208.73,75.43 209.61,74.55 209.61,74.39 203.19,67.97 198.69,67.97 198.32,67.6 192.77,67.6 v3(192.4,67.98)
  BOTTOM w0.089: UV1.J2 v3(192.4,67.98) ; UV16.T11 v3(214.71,77.12)
FBD_D43: length 41.8
  IN4 w0.112: v3(218.14,80.84) 218.14,80.28 217.51,79.64 217.51,76.13 216.98,75.61 211.31,75.61 202.5,66.8 192.62,66.8 v3(192.41,67.01)
  BOTTOM w0.089: v3(192.41,67.01) 192.8,67.39 UV1.J1
  BOTTOM w0.157: UV16.T13 214.71,79.52 214.71,80.81 214.56,80.96 214.56,81.42 215.33,82.2 v1(216.32,82.2) 216.83,82.2 218.14,80.88 v3(218.14,80.84)
FBD_D44: length 35.6
  IN4 w0.112: v3(192.4,71.98) 193.24,71.98 193.93,72.67 197.36,72.67 197.63,72.4 202.2,72.4 203.61,73.81 203.61,75.88 206.21,78.47 207.18,78.47 207.3,78.58 207.3,79.56 207.42,79.69 207.62,79.69 207.74,79.56 207.74,78.58 207.85,78.47 208.16,78.47 208.28,78.6 208.28,79.78 208.41,79.91 212.9,79.91 212.91,79.92 215.78,79.92 215.91,79.79 215.91,79.3 216.07,79.13 216.45,79.13 216.47,79.12 216.47,79.12 216.7,78.89 216.7,77.53 v3(217.11,77.12)
  BOTTOM w0.089: UV1.J6 v3(192.4,71.98) ; UV16.N11 v3(217.11,77.12)
FBD_D45: length 35.5
  IN4 w0.112: v3(194,70.38) 194.4,70.78 201.14,70.78 203.95,73.59 203.95,75.73 206.35,78.13 208.5,78.13 208.62,78.26 208.62,78.96 208.75,79.08 208.94,79.08 209.07,78.96 209.07,78.26 209.2,78.13 209.39,78.13 209.52,78.26 209.52,79.44 209.65,79.57 209.84,79.57 209.97,79.44 209.97,78.26 210.09,78.13 211.27,78.13 211.38,78.24 211.38,79.46 211.5,79.57 211.72,79.57 211.83,79.46 211.83,78.24 211.94,78.13 213.07,78.13 213.5,78.56 213.5,78.94 213.68,79.12 215.68,79.12 216.07,78.72 v3(216.31,78.72)
  BOTTOM w0.089: UV16.N13 v3(216.31,78.72) ; v3(194,70.38) UV1.H5
FBD_D46: length 38.1
  IN4 w0.112: v3(191.6,74.38) 192.04,73.94 200.71,73.94 207.36,80.59 208.85,80.59 208.96,80.7 208.96,81.09 209.08,81.2 209.3,81.2 209.41,81.09 209.41,80.7 209.52,80.59 209.75,80.59 209.86,80.7 209.86,81.09 209.97,81.2 210.19,81.2 210.31,81.09 210.31,80.7 210.42,80.59 210.64,80.59 210.75,80.7 210.75,81.09 210.86,81.2 211.09,81.2 211.2,81.09 211.2,80.7 211.31,80.59 211.54,80.59 211.65,80.7 211.65,81.09 211.76,81.2 211.98,81.2 212.09,81.09 212.09,80.7 212.21,80.59 212.43,80.59 212.54,80.7 212.54,81.09 212.65,81.2 v3(215.13,81.2)
  BOTTOM w0.089: UV16.M11 218,78.02 218,79.3 ; UV1.L9 v3(191.6,74.38)
  BOTTOM w0.157: v3(215.13,81.2) 215.13,81.2 215.49,81.56 216.66,81.56 216.99,81.24 216.99,80.74 217.11,80.61 217.11,79.74 217.3,79.55 217.75,79.55 218,79.3
FBD_D47: length 37.9
  IN4 w0.112: v3(191.6,73.58) 191.91,73.27 193.53,73.27 193.61,73.19 200.44,73.19 200.92,73.67 201.08,73.67 201.94,72.8 202.12,72.8 202.25,72.94 202.25,73.12 201.39,73.98 201.39,74.14 201.55,74.3 201.71,74.3 202.57,73.44 202.75,73.44 202.89,73.57 202.89,73.75 202.02,74.62 202.02,74.77 202.18,74.93 202.34,74.93 202.95,74.32 203.13,74.32 203.27,74.46 203.27,74.64 202.66,75.25 202.66,75.41 207.5,80.25 216.23,80.25 217.11,79.37 v3(217.11,78.72)
  BOTTOM w0.089: UV16.M13 v3(217.11,78.72) ; UV1.L8 v3(191.6,73.58)
FBD_D48: length 59.4
  IN1 w0.119: v3(186.8,75.38) 186.38,74.96 186.38,74.08 185.61,73.31 185.61,69.39 186.64,68.37 187.57,68.37 188.03,67.9 188.03,67.32 190,65.35 196.5,65.35 197.21,64.64 201.09,64.64 201.35,64.9 203.89,64.9 205.47,66.47 209.06,70.07 209.73,70.07 212.39,72.72 225.49,72.72 226.04,73.27 226.04,74.55 227.21,75.73 227.21,77.58 v3(226.96,77.83)
  BOTTOM w0.089: v3(226.96,77.83) 226.65,77.52 UV16.A11 ; v3(186.8,75.38) UV1.U10
FBD_D49: length 52.9
  IN1 w0.119: v3(226.71,78.72) 225.5,77.51 225.5,76.11 223.3,73.91 212.41,73.91 211.6,73.09 209.39,70.89 208.72,70.89 203.52,65.69 201.15,65.69 200.92,65.46 197.53,65.46 196.8,66.18 192.02,66.18 189.8,68.39 188.9,68.39 188.17,69.13 188.17,69.64 187.82,69.98 186.55,69.98 186.25,70.28 186.25,72.03 186.8,72.58 v3(186.8,72.78)
  BOTTOM w0.089: UV1.U7 v3(186.8,72.78) ; UV16.A13 v3(226.71,78.72)
FBD_D50: length 54.7
  IN1 w0.119: v3(186.8,74.38) 186.8,74.34 186.44,73.75 186.4,73.71 186.4,72.57 185.9,72.07 185.9,69.94 186.67,69.17 187.76,69.17 188.55,68.38 188.55,67.3 190.08,65.76 192.15,65.76 192.16,65.77 196.67,65.77 197.39,65.05 201,65.05 201.22,65.27 203.68,65.27 208.89,70.48 209.56,70.48 212.62,73.54 223.67,73.54 226.29,76.15 226.29,76.74 v3(225.91,77.12)
  BOTTOM w0.089: UV1.U9 v3(186.8,74.38) ; v3(225.91,77.12) UV16.B11
FBD_D51: length 51.4
  IN1 w0.119: v3(187.6,71.98) 187.21,71.59 187.21,70.72 187.53,70.4 187.8,70.4 189.02,69.18 190.93,69.18 191.74,68.37 192.56,68.37 193.46,67.47 193.46,67.09 193.95,66.6 197,66.6 197.73,65.86 200.84,65.86 201.23,66.26 203.52,66.26 208.42,71.16 208.42,72.07 210.67,74.31 222.99,74.31 224.72,76.04 224.72,78.95 224.89,79.12 225.51,79.12 v3(225.91,79.52)
  BOTTOM w0.089: UV1.R7 v3(187.6,71.98) ; UV16.B13 v3(225.91,79.52)
FBD_D52: length 51.9
  IN1 w0.119: v3(223.59,81.24) 223.2,80.86 221.05,80.86 220.21,80.02 212.4,80.02 203.61,71.24 201.55,69.18 200.17,69.18 199.94,68.95 198.46,68.95 197.89,68.37 197.01,68.37 196.8,68.58 196.8,69.75 196.57,69.98 196.25,69.98 196,70.22 196,72.5 195.57,72.93 194.76,72.93 194.42,73.26 194.42,74.07 193.73,74.77 191.84,74.77 190.83,75.77 187.99,75.77 v3(187.6,75.38)
  BOTTOM w0.089: UV16.E11 222.8,77.83 222.8,80.46 223.22,80.88 ; UV1.R10 v3(187.6,75.38)
  BOTTOM w0.157: 223.22,80.88 v3(223.59,81.24)
FBD_D53: length 45.6
  IN1 w0.119: v3(223.52,79.53) 223.14,79.53 221.93,78.32 219.29,78.32 219.12,78.15 219.12,77.79 218.84,77.51 210.56,77.51 206.21,73.16 206.21,72.21 202.67,68.67 200.73,68.67 200.06,68 199.53,68 199.05,68.48 198.44,68.48 198.03,68.07 196.98,68.07 196.74,68.31 196.26,68.31 196,68.57 196,69.75 195.77,69.98 195.4,69.98 195.19,70.19 195.19,71.78 193.01,73.96 189.62,73.96 v3(189.17,74.41)
  BOTTOM w0.089: v3(223.52,79.53) 223.12,79.12 UV16.E13 ; UV1.P10 188.8,74.78 189.17,74.41 v3(189.17,74.41)
FBD_D54: length 43
  IN1 w0.119: v3(221.91,77.12) 221.51,77.52 219.35,77.52 218.57,76.74 210.37,76.74 206.67,73.04 206.67,72.06 202.93,68.32 200.89,68.32 200.28,67.72 199.47,67.72 198.97,68.21 198.62,68.21 198.23,67.83 196.85,67.83 196.65,68.03 196.13,68.03 195.65,68.51 195.65,68.95 195.2,69.4 195.2,69.75 194.98,69.98 194.55,69.98 194.41,70.12 194.41,72.13 193.34,73.2 189.62,73.2 v3(189.2,72.78)
  BOTTOM w0.089: UV16.F11 v3(221.91,77.12) ; UV1.P8 v3(189.2,72.78)
FBD_D55: length 47.4
  IN1 w0.119: v3(189.2,73.58) 188.7,73.07 188.7,72.6 188.92,72.38 193.19,72.38 193.52,72.04 193.52,70.25 193.81,69.96 194.23,69.96 194.4,69.79 194.4,69.42 194.65,69.18 194.96,69.18 195.19,68.94 195.19,68.63 196.27,67.55 197.91,67.55 198.31,67.15 200.32,67.15 200.89,67.72 202.9,67.72 207.08,71.9 207.08,72.87 210.04,75.83 211.89,75.83 218.43,75.83 219.33,76.74 220.88,76.74 v3(221.88,75.74)
  BOTTOM w0.089: UV16.F13 222.61,78.82 222.61,76.48 v3(221.88,75.74) ; UV1.P9 v3(189.2,73.58)
FBD_D56: length 48.1
  IN2 w0.119: v3(227.21,71.99) 227.21,68.75 226.11,67.66 220.69,67.66 219.59,66.55 218.46,66.55 218.11,66.9 205.92,66.9 205.58,66.56 189.26,66.56 188.72,67.1 188.72,69.9 v3(189.2,70.38)
  BOTTOM w0.089: v3(227.21,71.99) 227.14,71.92 UV16.A4 ; UV1.P5 v3(189.2,70.38)
FBD_D57: length 46.5
  IN2 w0.119: v3(189.2,71.18) 189.2,71.38 189.6,71.78 189.6,73.73 189.85,73.98 190.16,73.98 190.4,74.22 190.4,74.44 192.2,76.25 201.17,76.25 201.98,75.43 210.86,75.43 212.35,73.95 225.7,73.95 226.13,73.52 226.13,71.86 226.32,71.67 226.32,70.32 v3(226.71,69.92)
  BOTTOM w0.089: UV16.A2 v3(226.71,69.92) ; UV1.P6 v3(189.2,71.18)
FBD_D58: length 45.9
  IN2 w0.119: v3(189.2,67.98) 189.98,67.98 191.18,69.18 199.08,69.18 199.3,68.95 206.94,68.95 208.21,70.22 211.64,70.22 212.34,69.53 213.39,69.53 213.68,69.24 213.68,68.29 214,67.97 218.74,67.97 219.32,68.55 224.81,68.55 225.11,68.85 225.11,69.37 225.52,69.78 225.52,73.28 v3(225.62,73.39)
  BOTTOM w0.089: UV1.P2 v3(189.2,67.98) ; v3(225.62,73.39) 225.81,73.2 225.81,72.18 225.55,71.92 UV16.B4
FBD_D59: length 41
  IN2 w0.119: v3(225.91,69.92) 225.9,69.92 225.9,68.78 225.23,68.11 219.5,68.11 218.92,67.53 209.36,67.53 208.21,68.68 207.86,68.68 207.86,68.67 207.65,68.67 207.1,68.12 200.44,68.12 200.32,68 199.75,68 199.37,68.37 191.21,68.37 189.89,67.06 v3(189.32,67.06)
  BOTTOM w0.089: UV16.B2 v3(225.91,69.92) ; UV1.P1 188.8,67.57 v3(189.32,67.06)
FBD_D60: length 39.4
  IN2 w0.119: v3(190,70.38) 189.61,70.77 189.61,71.34 189.61,71.34 189.61,71.35 189.83,71.57 190.4,71.57 190.78,71.94 190.78,73.17 191.04,73.43 191.04,74.37 191.45,74.78 198.15,74.78 198.5,74.43 210.32,74.43 212.39,72.35 214.12,72.35 214.56,71.92 222.3,71.92 v3(222.71,72.32)
  BOTTOM w0.089: UV1.M5 v3(190,70.38) ; v3(222.71,72.32) UV16.E4
FBD_D61: length 36.6
  IN2 w0.119: v3(223.51,70.72) 223.12,71.12 214.87,71.12 214.01,71.97 212.08,71.97 210.74,73.31 200.68,73.31 198.95,71.58 191.2,71.58 190.8,71.18 v3(190,71.18)
  BOTTOM w0.089: UV1.M6 v3(190,71.18) ; UV16.E2 v3(223.51,70.72)
FBD_D62: length 37
  IN2 w0.119: v3(190,71.98) 190.39,72.37 190.39,73.14 190.73,73.48 190.73,74.41 192.08,75.76 201.02,75.76 201.8,74.98 210.54,74.98 212.81,72.72 221.52,72.72 v3(221.91,72.32)
  BOTTOM w0.089: v3(221.91,72.32) UV16.F4 ; UV1.M7 v3(190,71.98)
FBD_D63: length 43.5
  IN2 w0.119: v3(189.2,71.98) 188.81,71.58 188.81,70.87 188.41,70.46 188.41,66.92 189.35,65.97 209.64,65.97 209.76,66.1 211.54,66.1 212.06,65.58 219.36,65.58 v3(220.99,67.21)
  BOTTOM w0.089: 221.62,68.18 221.62,69.21 221.94,69.52 221.94,69.95 UV16.F2 ; UV1.P7 v3(189.2,71.98)
  BOTTOM w0.157: v3(220.99,67.21) 221.62,67.85 221.62,68.18
FBD_DBI0#: length 57.6
  TOP w0.089: UV15.D2 v3(215.51,70.72)
  IN1 w0.119: v3(178,75.38) 178.38,75 178.38,70.27 179.47,69.18 180.53,69.18 181.32,68.39 181.32,68.32 187.84,61.8 196.97,61.8 202.26,56.5 205.16,56.5 207.58,58.92 207.58,61.11 213.88,67.41 213.88,69.18 215.43,70.72 v3(215.51,70.72)
  BOTTOM w0.089: UV1.AG10 v3(178,75.38)
FBD_DBI1#: length 39.8
  TOP w0.089: UV15.D13 v3(216.31,79.52)
  IN3 w0.112: v3(216.31,79.52) 216.31,79.57 215.65,80.23 213.24,80.23 213.04,80.42 212.16,80.42 210.92,79.18 210.92,78.67 206.04,73.79 205.89,73.79 202.78,70.68 198.92,70.68 198.22,69.98 184.12,69.98 183.7,70.39 v3(182.8,70.39)
  BOTTOM w0.089: UV1.AA5 183.19,70.78 182.8,70.39 v3(182.8,70.39)
FBD_DBI2#: length 43.6
  TOP w0.089: v3(224.31,79.52) 224.03,79.25 UV15.P13
  IN5 w0.119: v3(224.31,79.52) 223.9,79.11 212.13,79.11 210.7,77.69 202.12,77.69 200.4,75.96 192.2,75.96 190.76,74.51 190.76,71.97 190.37,71.58 187.44,71.58 187.05,71.98 v3(186.8,71.98)
  BOTTOM w0.089: UV1.U6 v3(186.8,71.98)
FBD_DBI3#: length 53.1
  TOP w0.089: UV15.P2 v3(224.31,70.72)
  IN6 w0.097: v3(224.31,70.72) 223.93,71.1 223,71.1 221.03,69.13 221.03,68.61 219.95,67.54 219.95,66.84 218.44,65.33 213.13,65.33 212.09,64.29 198.48,64.29 198,63.81 190.75,63.81 187.77,66.78 187.77,67.78 187.19,68.36 184.65,68.36 183.5,69.51 183.5,72.88 v3(182.8,73.58)
  BOTTOM w0.089: UV1.AA8 v3(182.8,73.58)
FBD_DBI4#: length 28.5
  IN6 w0.119: v3(194.8,68.78) 195.38,68.78 196.44,67.72 198.11,67.72 198.62,68.23 199.46,68.23 199.77,67.91 200,67.91 200.82,68.73 205.72,68.73 207.02,70.02 210.76,70.02 211.08,70.34 211.59,70.34 212.42,69.52 213.37,69.52 213.62,69.26 213.62,68.12 214,67.74 215.21,67.74 v3(215.91,68.44)
  BOTTOM w0.089: v3(194.8,68.78) 195.6,68.78 UV1.E3 ; UV16.P2 215.53,69.94 215.53,68.82 v3(215.91,68.44)
FBD_DBI5#: length 37.1
  IN4 w0.112: v3(215.51,78.72) 215.12,78.33 215.12,77.78 214.87,77.53 213.4,77.53 213.16,77.3 209.03,77.3 205.91,74.17 205.91,74.01 206.9,73.02 206.9,72.84 206.77,72.7 206.59,72.7 205.59,73.7 205.43,73.7 205.27,73.54 205.27,73.38 205.94,72.71 205.94,72.53 205.81,72.39 205.63,72.39 204.96,73.06 204.8,73.06 204.64,72.91 204.64,72.75 204.93,72.46 204.93,72.3 204.77,72.14 204.61,72.14 204.32,72.43 204.17,72.43 204.01,72.27 204.01,72.12 204.3,71.83 204.3,71.67 204.14,71.51 203.98,71.51 203.69,71.8 203.53,71.8 203.38,71.64 203.38,71.48 203.66,71.2 203.66,71.04 203.51,70.88 203.35,70.88 203.06,71.17 202.9,71.17 201.48,69.75 199.27,69.75 198.69,69.18 193.6,69.18 v3(192.4,70.38)
  BOTTOM w0.089: UV1.J5 v3(192.4,70.38) ; v3(215.51,78.72) UV16.P13
FBD_DBI6#: length 50.2
  IN1 w0.119: v3(186.8,73.58) 187.2,73.18 187.85,73.18 188,73.02 188,70.94 188.18,70.77 191.03,70.77 191.2,70.6 191.2,69.52 191.53,69.19 192.74,69.19 193.17,68.75 193.17,68.22 193.83,67.57 195.34,67.57 195.89,67.02 197.04,67.02 197.69,66.37 200.74,66.37 201.24,66.87 203.42,66.87 207.97,71.43 207.97,72.33 210.46,74.82 222.35,74.82 223.09,75.56 223.09,78.31 v3(223.51,78.72)
  BOTTOM w0.089: UV1.U8 v3(186.8,73.58) ; UV16.D13 v3(223.51,78.72)
FBD_DBI7#: length 37.9
  IN2 w0.119: v3(190,69.58) 190.64,70.22 191.2,70.77 199.77,70.77 201.45,72.45 210.83,72.45 211.92,71.36 212.71,71.36 212.94,71.13 214.05,71.13 214.31,70.87 214.31,70.56 214.54,70.33 223.9,70.33 v3(224.31,69.92)
  BOTTOM w0.089: UV16.D2 v3(224.31,69.92) ; UV1.M4 v3(190,69.58)
