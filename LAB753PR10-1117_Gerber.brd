# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NUMLOCK LED_A#: length 312.7
  TOP w0.127: v3(275.65,23.65) 275.65,23.66 275.65,24.3 275.3,24.65 UE5.36 ; v1(229.55,54.66) 229.35,54.46 v3(229.35,53.53) ; v3(187.81,144.43) 187.81,146.63 187.65,146.79 JPWR1.30
  IN2 w0.099: v3(187.81,144.43) 185.85,142.47 171.67,142.47 166.51,137.31 161.58,137.31 161.07,137.83 161.07,137.98 160.57,138.49 158.4,138.49 156.98,139.91 153.36,139.91 152.77,139.33 152.77,138.17 151.08,136.48 151.08,130.61 150.48,130 150.48,128.08 151.36,127.19 151.36,126.19 149.5,124.34 149.5,119.79 153.91,115.38 153.91,91.37 155.08,90.2 155.08,81.66 154.5,81.08 154.5,78.54 155.28,77.76 155.28,77.31 155.71,76.89 155.71,66.7 156.92,65.49 156.92,57.19 157.43,56.68 157.43,55.61 157.81,55.22 157.81,49.57 160.8,46.59 160.8,41.16 161.29,40.67 161.29,39.59 164.45,36.43 165.53,36.43 167.21,34.75 167.21,32.53 171.8,27.94 171.8,27.3 174.76,24.34 178.47,24.34 178.7,24.11 189.14,24.11 199.45,34.42 199.45,36.3 199.19,36.56 199.19,45.01 201.53,47.34 203.53,47.34 207.72,51.54 207.72,53.04 211.39,56.7 224.17,56.7 226.85,54.01 228.87,54.01 v3(229.35,53.53)
  IN6 w0.099: v3(275.65,23.65) 275.65,23.66 275.65,23.79 266.26,33.17 264.54,33.17 252.93,44.78 251.74,44.78 242.16,54.37 235.79,54.37 234.76,55.4 230.41,55.4 229.35,54.35 v3(229.35,53.53)
NVVDD PSI: length 67.8
  TOP w0.127: v3(155.34,62.42) 155.01,62.42 RV35.1 154.76,63.04 156.05,63.04 157.23,64.23 v2(165.69,64.23) 167.88,66.42 169.23,66.42 v3(170,67.2)
  TOP w0.254: PR607.2 175.57,26.33 175.19,25.95 172.43,25.95 171.35,27.03 v3(170.97,27.03)
  IN2 w0.122: v3(155.34,62.42) 154.66,62.42 154.36,62.12 154.36,57.69 155.95,56.09 155.95,54.49 156.7,53.74 156.7,47.8 158.6,45.9 158.6,42.6 160.8,40.4 160.8,39.42 162.89,37.33 162.89,35.93 170.97,27.85 v3(170.97,27.03)
  BOTTOM w0.089: v3(170,67.2) 170.82,67.2 UV1.AT1
NVVDD PWM_VID: length 82
  TOP w0.254: PR610.2 175.48,25.57 172.1,25.57 v2(171.67,26) 171.25,26.42 v3(170.97,26.42)
  IN2 w0.122: v3(170.97,26.42) 170.5,26.89 170.5,27.94 162.64,35.8 162.64,37.16 159.69,40.11 159.69,40.87 158.33,42.22 158.33,45.72 156.45,47.61 156.45,53.64 155.71,54.38 155.71,55.96 154.05,57.61 154.05,63.26 154.88,64.09 154.88,70.3 155.06,70.47 155.06,76.15 v3(154.47,76.74)
  IN6 w0.089: v3(167.63,75.19) 165.86,75.19 162.98,78.07 159.33,78.07
  IN6 w0.099: 159.33,78.07 158.7,78.07 157.37,76.74 v3(154.47,76.74)
  BOTTOM w0.089: v3(167.63,75.19) 168.17,75.19 169.05,74.31 170.87,74.31 UV1.AT9
ON/OFFBTN#: length 284.8
  TOP w0.127: v3(156.17,128.39) 155.73,128.83 SW2.4 153.28,128.83 152.62,129.49 152.62,132.63 153.22,133.23 SW2.3 155.16,133.23 156.2,134.27 156.71,134.27 v2(156.78,134.34) 156.78,135.47 156.14,136.12 156.14,137.12 157.58,138.57 157.58,139.13 CE27.1 RE63.1 158.87,139.91 158.4,140.38 158.4,141.28 157.97,141.71 v3(156.12,141.71) ; v3(187.59,140.74) 186.46,141.87 186.46,145.24 186.15,145.55 JPWR1.27 ; v3(286.67,19.66) 286.95,19.94 288.85,19.94 289.16,20.25 UE5.114
  IN3 w0.091: v3(230.2,53.54) 230.01,53.54 228.76,54.8 219.87,54.8 219.3,55.37 215.05,55.37 214.35,54.67 206.76,54.67 205.22,53.14 204.05,53.14 v3(203.3,53.89)
  IN4 w0.091: v3(187.59,140.74) 186.41,139.56 182.06,139.56 181.65,139.14 177.18,139.14 176.68,138.65 175.24,138.65 174.79,139.09 171.48,139.09 169.62,140.95 165.7,140.95 165.04,140.29 157.65,140.29 156.22,141.71 v3(156.12,141.71) ; v3(156.17,128.39) 156.31,128.39 159.78,124.92 159.78,113.08 160.1,112.75 160.1,99.03 160.7,98.44 160.7,97.54 161.46,96.78 162.38,96.78 162.93,96.23 162.93,94.68 163.53,94.08 163.53,93.39 163.15,93 163.15,91.98 163.45,91.67 163.45,90.83 163.11,90.49 163.11,89.58 163.49,89.19 163.49,88.48 163.08,88.08 163.08,87.43 163.62,86.9 163.62,86.11 163.11,85.6 163.11,83.52 163.96,82.67 163.96,81.38 163.18,80.6 163.18,77.15 v3(162.8,76.77)
  IN6 w0.089: v3(162.8,76.77) 167.22,72.35 170.82,72.35 172.09,71.08 172.09,69.74 173.52,68.3 176.38,68.3 178.22,66.47
  IN6 w0.099: v3(286.67,19.66) 286.67,19.61 286.14,19.09 278.95,19.09 278.09,19.95 275.4,19.95 271.06,24.29 270.6,24.29 264.57,30.31 260.77,30.31 258.37,32.71 258.37,35.88 241.61,52.64 238.54,52.64 238.15,52.25 231.5,52.25 v3(230.2,53.54) ; v3(203.3,53.89) 202.75,53.89 199.55,57.09 198.52,57.09 195.78,59.83 188.92,59.83 186.6,62.16 183.56,62.16 181.12,64.6 180.57,64.6
  IN6 w0.101: 178.22,66.47 178.56,66.12 179.47,66.12 180.11,65.48 180.11,65.06 180.57,64.6
  BOTTOM w0.127: SW1.3 SW1.4 156.57,141.71 v3(156.12,141.71)
OVERT#: length 88.3
  TOP w0.127: QV91.1 149.63,58.51 149.48,58.66 149.21,58.66 148.91,58.36 v3(148.91,58.05) ; RV527.1 153.8,75.91 154.47,75.24 159.64,75.24 160.52,74.36 v2(161.37,74.36) 163.59,74.36 163.97,73.98 165.81,73.98 166.63,73.17 168.8,73.17 v3(169.23,72.73)
  IN5 w0.099: v3(165.91,55.23) 165.69,55.23 165.41,55.52 165.41,65.47 166.7,66.77 166.7,68.12 167.17,68.59 167.17,72.11 167.45,72.39 168.89,72.39 v3(169.23,72.73)
  IN6 w0.099: v3(148.91,58.05) 148.68,57.83 148.68,55.45 150.65,53.48 155.86,53.48 158.71,50.62 163.64,50.62 164.56,51.55 164.56,53.88 v3(165.91,55.23)
  BOTTOM w0.089: UV1.AV7 169.59,72.38 v3(169.23,72.73)
  BOTTOM w0.127: v3(165.91,55.23) 165.68,55.23 163.27,52.83 163.27,50.71 162.77,50.21 160,50.21 159.44,49.65 159.44,46.81 159.62,46.64 159.62,45.35 158.97,44.71 158.97,39.89 160.07,38.79 160.07,37.49 RV553.2
P1: length 60.4
  TOP w0.254: PR701.2 32.96,40.53 PC701.1 34.16,40.92 34.83,40.92 PR706.1 34.74,40.18 v3(34.43,40.18) ; PQ700.3 30.01,37.43 30.58,38 v1(31.18,38) 31.37,37.81 31.37,37.09 31.73,36.73 33.81,36.73 v3(34.27,37.19)
  IN1 w0.254: v3(34.27,37.19) 33.82,37.64 33.82,39.58 v3(34.43,40.18)
  IN2 w0.254: v3(34.27,37.19) 33.63,36.55 22.26,36.55 20.99,35.27 20.2,35.27 19.33,34.41 19.33,28.17 20.26,27.24 20.26,26.38 20.58,26.06 21.32,26.06 23.05,24.33 23.05,22.84 24.02,21.87 27.07,21.87 29.03,19.92 31.99,19.92 34.51,17.4 36.22,17.4 v3(36.63,16.99)
  vias: v3(40.41,15.66) v3(40.74,15.08) v3(41.05,15.66) v3(41.38,15.08) v3(41.68,15.66) v3(42.01,15.08) v3(42.32,15.66) v3(42.65,15.08) v3(42.95,15.66) v3(43.28,15.08) v3(43.56,15.66) v3(43.92,15.08) v3(44.21,15.65) v3(44.54,15.08)
P1_SW: length 26.4
  TOP w0.254: PR553.1 143.39,122.58 PR552.2 143.39,121.95 v3(143.26,121.82)
  IN4 w0.254: v3(143.26,121.82) 142.12,120.68 141.51,120.68 139.5,118.66 137.24,118.66 134.18,115.6 133.36,115.6 v3(133.29,115.67)
  BOTTOM w0.254: v3(133.29,115.67) 133.21,115.6 131.44,115.6 v1(130.78,116.26) 130.04,116.99 128.15,116.99 127.39,116.23 125.61,116.23 125.03,116.8 PL503.3
P2:
  vias: v1(45.39,25.24)
P2_SW: length 49.6
  TOP w0.127: PR536.2 v1(147.23,123.32)
  TOP w0.254: v3(145.08,126) 145.86,125.21 145.86,124.56 ; 145.86,124.56 PR536.2 ; 145.86,124.56 PR538.1
  IN4 w0.254: v3(116.72,116.3) 116.84,116.17 117.89,116.17 120.08,113.98 120.08,110.87 121.45,109.5 128.33,109.5 130.06,111.24 130.06,114.48 130.9,115.32 130.9,116.1 135.04,120.23 137.45,120.23 142.66,125.44 143.35,125.44 143.91,126 v3(145.08,126)
  BOTTOM w0.254: PL502.3 117.48,117.06 v3(116.72,116.3)
P3_SW: length 48.3
  TOP w0.127: v1(139.52,117.7) 140.25,118.43 PR510.2
  TOP w0.254: PR510.2 PR514.2 138.88,119.85 v3(138.62,119.6)
  IN4 w0.254: v3(138.62,119.6) 138.45,119.42 136.73,119.42 135.26,117.95 134.21,117.95 131.66,115.4 131.66,111.76 128.64,108.74 120.81,108.74 120.3,109.25 113.63,109.25 111.64,111.25 111.64,114.99 110.08,116.55 109.03,116.55 v3(108.9,116.68)
  BOTTOM w0.254: PL501.3 109.92,117.69 v3(108.9,116.68)
PANEL_BKLEN: length 106.2
  TOP w0.127: v3(226.38,44.1) 226.58,44.3 226.58,47.94 224.32,50.21 224.32,50.47 223.4,51.4 223.4,52.86 223.84,53.3 v1(224.27,53.3) 227.6,53.3 230.33,50.57 233.36,50.57 234.26,51.47 v3(238.89,51.47) ; v3(281.12,13.07) 280.63,13.07 280.4,12.83 UE5.76
  IN1 w0.099: v3(238.89,51.47) 239.45,52.02 243.15,52.02 249.93,45.24 253.05,45.24 255.23,43.06 255.23,42.38 258.21,39.41 259.28,39.41 259.84,38.85 262.39,38.85 264.26,36.97 268.94,36.97 269.22,37.25 270.46,37.25 271.19,36.53 281.98,36.53 283.26,35.24 v3(283.26,34.98)
  BOTTOM w0.089: UH1.K36 226.38,43.86 v3(226.38,44.1)
  BOTTOM w0.127: v3(281.12,13.07) 282.07,14.02 282.07,14.8 283.19,15.92 283.19,16.87 283.95,17.63 283.95,20.22 283.54,20.63 283.54,22.4 283.89,22.75 283.89,24.22 283.18,24.93 283.18,30.29 282.88,30.58 282.88,34.6 v3(283.26,34.98)
PBTN_OUT#: length 77.3
  TOP w0.127: v3(225.36,26.33) 224.96,25.92 v1(224.96,25.41) 224.96,23.99 RH56.1 ; v3(288.11,17.13) 288.2,17.05 UE5.106
  IN1 w0.099: v3(225.36,26.33) 225.36,26 226.1,25.26 226.56,25.26 228.55,23.27 228.55,22 228.34,21.78 228.34,19.5 230.16,17.67 230.77,17.67 230.99,17.45 232.35,17.45 232.56,17.67 233.61,17.67 234.19,17.08 239.61,17.08 240.85,15.85 258.2,15.85 260.37,18.02 268.33,18.02 269.22,17.13 275.62,17.13 276.52,16.23 281.02,16.23 281.26,15.98 284.28,15.98 284.8,16.5 287.48,16.5 v3(288.11,17.13)
PC_BEEP: length 257.1
  TOP w0.127: CA65.2 26.44,19.64 v1(27.74,18.34) 27.99,18.09 v3(27.99,17.29) ; CA66.2 CA72.2 13.21,12.63 v3(13.34,12.75)
  IN2 w0.099: v3(27.99,17.29) 29.35,17.29 32.55,14.09 36.38,14.09 37.57,12.89 48.17,12.89 50.99,15.71 53.28,15.71 56.33,18.76 70.94,18.76 71.47,19.29 73.28,19.29 73.7,18.88 74.32,18.88 74.99,19.55 74.99,22.75 77.29,25.05 129.47,25.05 130.69,23.83 130.69,19.96 131.59,19.06 150.4,19.06 152.01,17.45 164.93,17.45 165.27,17.11 168.06,17.11 169.32,18.37 172.09,18.37 173.45,17.01 177.83,17.01 177.94,16.89 182.83,16.89 182.97,17.03 214.61,17.03 216.05,15.58 221.16,15.58 v3(223.12,17.54)
  IN5 w0.099: v3(13.34,12.75) 12.44,13.65 8.31,13.65 6.99,14.98 6.99,19.14 10.25,22.4 14.78,22.4 15.24,21.95 17.87,21.95 19.17,20.65 23.81,20.65 27.18,17.29 v3(27.99,17.29)
  BOTTOM w0.127: RA81.2 RA84.2 224.84,16.09 RA80.1 223.98,16.68 v3(223.12,17.54)
PC_BEEP_1: length 4.6
  TOP w0.127: CA65.1 v1(25.26,18.43) 25.26,17.78 24.08,16.6 23.49,16.6 23.48,16.6 UA1.53
PC_BEEP_L: length 39.1
  TOP w0.254: v3(13.54,9.88) 13.54,10.14 13.83,10.43 13.83,10.47 CA66.1
  IN5 w0.254: v3(13.54,9.88) 13.54,9.92 12.81,10.64 10.59,10.64 9.64,9.69 5.16,9.69 2.61,12.25 2.61,13.06 3.46,13.91 3.46,14.89 3.81,15.25 3.81,19.14 4.17,19.5 4.17,22.42 5.21,23.46 5.21,28.39 6.58,29.76 8.71,29.76 v3(9.96,28.51)
  BOTTOM w0.127: v1(11.11,28.92) 10.71,29.32 RA140.1
  BOTTOM w0.254: v3(9.96,28.51) 9.89,28.58 RA140.1
PC_BEEP_R: length 37.3
  TOP w0.254: CA72.1 12.85,10.38 v3(12.85,9.88)
  IN5 w0.254: v3(12.85,9.88) 12.47,10.26 10.75,10.26 9.79,9.31 5.01,9.31 2.22,12.09 2.22,13.21 3.08,14.06 3.08,15.05 3.43,15.41 3.43,19.33 3.79,19.69 3.79,22.71 4.74,23.66 4.74,28.7 5.21,29.17 5.21,31.49 v3(4.13,32.56)
  BOTTOM w0.127: v1(3.23,33.16) 3.53,33.16 v3(4.13,32.56)
  BOTTOM w0.254: v3(4.13,32.56) RA139.1
PCH_AZ_BITCLK: length 6.8
  BOTTOM w0.127: UH1.B25 231.32,39.22 231.82,39.71 232.16,39.71 232.73,40.29 232.81,40.29 233.11,40.58 233.11,41.01 232.67,41.45 232.67,41.68 232.77,41.79 v1(233.3,41.79) 233.53,42.01 RH29.2
PCH_AZ_CODEC_BITCLK: length 263.3
  TOP w0.127: v1(23.09,19.89) 23.49,19.49 v3(24.03,19.49) 24.01,19.52 RA96.1 ; UA1.5 v3(20.53,19.65)
  IN6 w0.099: v3(20.53,19.65) 20.45,19.72 20.45,20.19 20.88,20.61 22.91,20.61 v3(24.03,19.49) 24.25,19.49 25.52,18.22 26.46,18.22 28.36,16.32 28.92,16.32 32.13,13.11 35.67,13.11 37.43,11.35 45.51,11.35 47.91,13.76 52.08,13.76 52.73,14.4 53.45,14.4 53.97,14.93 55.92,14.93 56.59,15.6 58.08,15.6 58.37,15.31 62.63,15.31 63.69,16.36 68.8,16.36 73.2,11.96 87.74,11.96 88.48,11.22 96.13,11.22 97.02,12.11 141.97,12.11 143.2,13.34 149.46,13.34 151.5,11.3 156.34,11.3 158.02,9.62 166.84,9.62 167.35,9.11 172.24,9.11 173.36,10.23 179.13,10.23 180.39,8.98 188.72,8.98 189.19,8.51 192.13,8.51 194.42,10.81 194.42,11.3 196.55,13.42 202.67,13.42 203.15,12.94 205.58,12.94 206.6,11.91 216.42,11.91 217.08,11.26 220.82,11.26 223.98,14.42 229.42,14.42 231.19,16.19 231.19,17.6 230.34,18.46 230.34,19.64 230.09,19.89 230.09,21.77 231.36,23.04 231.36,24.74 232.32,25.71 233.82,25.71 235.08,26.96 235.08,27.43 235.46,27.82 235.83,27.82 236.12,28.11 236.12,33.12 236.55,33.55 236.55,35.56 236.29,35.81 236.29,40.17 236.79,40.67 v3(236.79,41.32)
  BOTTOM w0.127: v3(236.79,41.32) 236.41,41.32 236.02,41.71 CH5.1 RH29.1
PCH_AZ_CODEC_RST#: length 259
  TOP w0.127: v3(22.61,18.32) 22.61,19.29 22.44,19.46 21.91,19.46 21.73,19.28 UA1.2 ; v3(237.62,37.94) 237.62,37.66 v1(237.97,37.3)
  IN6 w0.099: v3(22.61,18.32) 22.61,17.72 23.8,16.52 25.69,16.52 27.74,14.48 31.26,10.96 34.66,10.96 36.35,9.27 46.03,9.27 47,10.25 53,10.25 53.24,10.48 53.24,11.12 54.24,12.12 55.11,12.12 55.46,12.47 57.3,12.47 58.41,13.58 63.29,13.58 64.39,14.67 67.49,14.67 72.45,9.72 87.16,9.72 87.35,9.53 144.57,9.53 145.91,10.87 145.94,10.87 145.97,10.91 146.27,10.91 146.27,10.91 149.41,10.91 153.67,6.64 192.78,6.64 197.87,11.73 201.97,11.73 203.19,10.5 204.32,10.5 205.26,9.56 221.52,9.56 221.84,9.88 224.64,12.68 230.1,12.68 236.5,19.07 236.5,20.36 237.18,21.04 237.18,24.67 237.59,25.08 238.2,25.08 239.87,26.75 239.87,29.52 239.56,29.83 239.56,37.01 239.32,37.25 238.3,37.25 v3(237.62,37.94)
  BOTTOM w0.127: v3(237.62,37.94) 237.62,38.44 237.16,38.9 RP2.4
PCH_AZ_CODEC_SDIN0: length 271.7
  TOP w0.127: RA40.1 20.68,21.24 v3(20.77,21.24) ; v3(238.3,36.72) 238.89,37.3 239.32,37.3 v1(239.68,37.66)
  IN4 w0.091: v3(238.3,36.72) 237.86,37.16 232.52,37.16 231.91,36.55 230.99,36.55 229.62,37.92 226.6,37.92 v3(226.26,37.58)
  IN6 w0.099: v3(20.77,21.24) 19.97,20.44 19.97,19.49 20.35,19.11 22.5,19.11 23.01,18.6 23.01,18.09 23.27,17.83 24.09,17.83 24.99,16.93 25.86,16.93 28.14,14.65 31.02,11.77 35.18,11.77 36.95,10 46.19,10 47.34,11.16 52.64,11.16 54.01,12.53 54.95,12.53 55.29,12.87 57.13,12.87 58.24,13.98 63.13,13.98 64.22,15.07 67.66,15.07 72.61,10.13 87.43,10.13 87.62,9.93 96.79,9.93 97.68,10.82 138.24,10.82 139.13,9.93 144.4,9.93 145.75,11.28 145.77,11.28 145.8,11.31 146.44,11.31 149.58,11.31 151.25,9.64 156.19,9.64 158.68,7.14 192.71,7.14 197.7,12.13 202.14,12.13 203.36,10.91 204.49,10.91 205.43,9.97 221.36,9.97 224.47,13.08 229.94,13.08 236.1,19.24 236.1,20.58 236.78,21.26 236.78,26.1 237.74,27.06 237.93,27.06 238.73,27.86 238.73,32.04 238.47,32.3 238.47,36.55 v3(238.3,36.72)
  BOTTOM w0.089: v3(226.26,37.58) 226.06,37.78 UH1.L22
PCH_AZ_CODEC_SDIN0_R: length 2.4
  TOP w0.127: RA40.2 20.16,20.61 19.67,20.12 v1(19.67,19.88) 19.67,19.27 19.73,19.21 UA1.7
PCH_AZ_CODEC_SDOUT: length 260.8
  TOP w0.127: v3(20.96,20.08) 20.96,19.41 20.93,19.38 UA1.4
  IN6 w0.099: v3(20.96,20.08) 22.76,20.08 23.83,19.01 24.05,19.01 25.33,17.74 26.2,17.74 31.3,12.63 35.47,12.63 37.29,10.81 45.65,10.81 48.11,13.28 52.28,13.28 52.93,13.92 53.65,13.92 54.17,14.45 56.17,14.45 56.84,15.12 57.88,15.12 58.17,14.82 62.83,14.82 63.89,15.88 68.6,15.88 73,11.48 87.52,11.48 88.26,10.74 96.37,10.74 97.26,11.63 142.17,11.63 143.4,12.86 149.16,12.86 151.58,10.44 156.52,10.44 157.82,9.14 166.64,9.14 167.15,8.63 172.44,8.63 173.56,9.75 178.93,9.75 180.19,8.5 188.53,8.5 189.03,7.99 192.29,7.99 194.9,10.61 194.9,11.09 196.76,12.94 202.47,12.94 202.95,12.46 205.37,12.46 207.05,10.78 221.02,10.78 224.17,13.93 229.61,13.93 231.68,16 231.68,16.75 234.12,19.19 234.12,25.28 236.62,27.78 236.62,32.94 237.03,33.34 237.03,35.76 236.77,36.02 236.77,39.94 237.61,40.77 v3(237.61,41.33)
  BOTTOM w0.127: v3(237.61,41.33) 238.19,40.74 238.19,39.97 238,39.78 237.53,39.78 237.41,39.9 RP2.2
PCH_AZ_CODEC_SYNC: length 256.5
  TOP w0.127: UA1.3 21.33,19.59 v3(21.38,19.64) 21.68,19.94 v1(21.81,19.94)
  IN6 w0.099: v3(21.38,19.64) 22.63,19.64 23.67,18.61 23.88,18.61 25.16,17.33 26.03,17.33 31.18,12.18 35.35,12.18 37.12,10.41 46.02,10.41 47.17,11.56 52.47,11.56 53.84,12.93 54.78,12.93 55.12,13.27 56.96,13.27 58.07,14.38 62.96,14.38 64.05,15.48 67.83,15.48 72.77,10.53 87.59,10.53 87.79,10.33 96.54,10.33 97.43,11.23 142.33,11.23 143.57,12.46 149,12.46 151.42,10.04 156.35,10.04 158.68,7.72 166.87,7.72 167.3,8.14 172.52,8.14 173.73,9.35 178.77,9.35 180.03,8.09 188.36,8.09 188.86,7.59 192.56,7.59 197.51,12.53 202.31,12.53 203.52,11.32 204.73,11.32 205.67,10.37 221.19,10.37 224.3,13.49 229.74,13.49 232.08,15.83 232.08,16.58 234.59,19.09 234.59,25.11 237.04,27.55 237.04,32.78 237.43,33.18 237.43,35.97 237.19,36.21 237.19,38.65 v3(237.62,39.08)
  BOTTOM w0.127: RP2.3 237.28,39.4 237.61,39.08 v3(237.62,39.08)
PCH_AZ_RST#: length 13.5
  BOTTOM w0.089: 230.97,38.49 230.23,38.49 229.92,38.79 UH1.C24
  BOTTOM w0.127: 230.97,38.49 231.08,38.38 231.95,38.38 232.39,37.95 233.24,37.95 233.34,38.05 233.34,38.99 233.5,39.16 234.74,39.16 234.9,38.99 234.9,38.19 235.09,38 235.61,38 235.7,37.91 235.7,36.9 235.88,36.72 236.29,36.72 236.41,36.84 v1(236.41,37.25) 236.41,37.96 235.9,38.47 235.43,38.47 235.31,38.6 235.31,38.81 235.4,38.9 RP2.5
PCH_AZ_SDOUT: length 17.1
  TOP w0.127: RH6.2 RH16.2 234.56,40.88 v3(235,41.33)
  BOTTOM w0.127: v3(235,41.33) 235.54,40.79 236.03,40.79 236.22,40.6 236.22,40.16 235.96,39.9 RP2.7 235.04,39.9 234.94,40 234.94,40.85 234.84,40.94 234.63,40.94 234.53,40.85 234.53,39.71 234.41,39.59 234.24,39.59 234.13,39.71 v1(234.13,40.12) 234.13,41.4 234.03,41.49 233.81,41.49 233.72,41.4 233.72,39.91 233.59,39.78 233,39.78 232.88,39.65 232.88,38.52 232.75,38.39 232.57,38.39 232.44,38.52 232.44,39.02 232.32,39.14 231.97,39.14 231.71,38.89 230.48,38.89 UH1.A24
PCH_AZ_SYNC: length 8
  BOTTOM w0.127: UH1.A22 230.51,37.85 231.47,37.85 232.16,37.16 234.14,37.16 234.52,36.78 234.52,36.46 234.96,36.02 234.96,35.64 234.8,35.47 QH1.1 233.69,35.47 v1(233.24,35.93)
PCH_AZ_SYNC_Q: length 8.4
  BOTTOM w0.127: QH1.3 236.59,34.82 RH20.2 237.8,35.6 238.72,36.53 238.72,36.95 238.34,37.33 v1(238.06,37.33) 237.97,37.42 237.44,37.42 237.11,37.75 237.11,38.32 236.98,38.44 236.54,38.44 236.16,38.83 236.16,39.33 236.09,39.4 RP2.6
PCH_BATLOW#: length 22.5
  TOP w0.127: v3(235.69,20.4) 235.69,19.98 v1(235.12,19.41) 234.09,18.38 233.24,18.38 RH58.2
  IN1 w0.099: v3(235.69,20.4) 235.66,20.4 234.39,21.67 234.39,24.07 234,24.46 232.74,24.46 231.18,26.02 231.18,27.36 229.29,29.25 227.89,29.25 226.38,30.76 226.38,31.17 v3(226.72,31.52)
  BOTTOM w0.089: v3(226.72,31.52) 226.35,31.52 UH1.K7
PCH_CLK_BIASREF: length 6.4
  BOTTOM w0.254: UH1.AN44 216.98,48.04 216.98,49.07 216.55,49.49 v1(215.95,49.49) 215.05,49.49 213.44,51.11 RH92.1
PCH_DP_AUXN_C: length 2.1
  BOTTOM w0.127: CV25.1 152.68,138.64 152.68,139.31 152.52,139.47 UV3.5
PCH_DP_AUXP_C: length 2.1
  BOTTOM w0.127: CV24.1 153.94,138.95 154.47,139.48 UV3.2
PCH_DPB_HDMI_CLK: length 203.1
  TOP w0.127: UV4.38 113,140.3 113.21,140.5 113.82,140.5 114.08,140.24 v3(114.14,140.24)
  IN1 w0.099: v3(126.92,134.17) 126.92,133.95 127.14,133.73 128.61,133.73 128.96,133.39 132.29,133.39 132.86,133.96 136.29,133.96 136.87,133.37 139.8,133.37 140.39,133.96 144.55,133.96 145.66,132.84 149.58,132.84 152.94,129.49 160.16,129.49 161.86,131.19 164.03,131.19 164.32,131.48 164.94,131.48 165.29,131.84 166.57,131.84 166.97,132.24 175.49,132.24 175.81,131.92 179.26,131.92 179.52,132.18 179.52,132.53 179.82,132.83 184.98,132.83 185.55,132.26 194.13,132.26 194.72,131.66 197.34,131.66 202.49,126.51 203.4,126.51 206.77,123.15 206.77,113.38 211.96,108.19 215.47,108.19 221.9,101.76 223.63,101.76 229.87,95.53 229.87,70.33 229.41,69.88 229.41,61.81 225.88,58.28 225.88,54.61 224.79,53.51 224.79,47.84 224.9,47.73 224.9,46.23 224.6,45.93 224.6,45.77 v3(224.77,45.61)
  IN4 w0.091: v3(114.14,140.24) 113.91,140.47 113.33,140.47 113.02,140.17 113.02,137.06 113.81,136.27 115.52,136.27 115.7,136.1 124.72,136.1 126.23,134.59 126.64,134.17 v3(126.92,134.17)
  BOTTOM w0.089: v3(224.77,45.61) 224.61,45.77 UH1.R40
PCH_DPB_HDMI_DAT: length 204
  TOP w0.127: v3(114.14,140.82) 114.12,140.79 113.09,140.79 113,140.7 UV4.39
  IN1 w0.099: v3(224.77,45.01) 224.3,45.48 224.3,45.93 224.69,46.32 224.69,47.64 224.58,47.75 224.58,53.6 225.67,54.7 225.67,58.36 229.2,61.89 229.2,69.97 229.66,70.42 229.66,95.44 223.55,101.55 221.81,101.55 215.39,107.98 211.87,107.98 206.55,113.29 206.55,123.07 203.32,126.3 202.4,126.3 197.25,131.45 194.64,131.45 194.04,132.05 185.46,132.05 184.9,132.62 179.91,132.62 179.73,132.44 179.73,132.09 179.35,131.71 175.73,131.71 175.4,132.03 167.06,132.03 166.66,131.63 165.38,131.63 165.02,131.27 164.4,131.27 164.11,130.98 161.94,130.98 160.24,129.28 152.85,129.28 149.5,132.63 145.57,132.63 144.46,133.74 140.47,133.74 139.89,133.16 136.78,133.16 136.2,133.74 132.94,133.74 132.38,133.18 128.87,133.18 128.53,133.52 127.05,133.52 126.81,133.76 v3(126.51,133.76)
  IN4 w0.091: v3(126.51,133.76) 126.51,134.04 126.22,134.32 126.22,134.32 126.03,134.51 124.64,135.9 115.62,135.9 115.44,136.08 113.73,136.08 112.83,136.98 112.83,140.25 113.25,140.67 113.99,140.67 v3(114.14,140.82)
  BOTTOM w0.089: v3(224.77,45.01) 224.61,45.17 UH1.R39
PCH_DPC_AUX: length 155.9
  IN1 w0.099: v3(227.6,48.67) 227.39,48.46 227.22,48.46 227.06,48.63 227.06,49.44 227.5,49.88 227.5,55.96 228.11,56.57 228.11,58.54 230.77,61.2 230.77,69.33 231.22,69.77 231.22,96.19 223.52,103.89 222.44,103.89 216.57,109.76 212.29,109.76 208.19,113.87 208.19,123.77 199.52,132.44 198.86,132.44 198.25,133.05 196.54,133.05 195.58,134.01 190.62,134.01 189.16,135.47 170.22,135.47 169.98,135.23 167.85,135.23 166.31,133.69 161.92,133.69 161.25,134.37 158.13,134.37 157.46,135.04 154.35,135.04 153.57,135.82 153.57,136.23 v3(153.81,136.46)
  BOTTOM w0.089: UH1.K45 226.18,47.7 226.06,47.82 226.06,47.98 226.18,48.1 226.44,48.1 226.76,48.42 227.35,48.42 227.41,48.48
  BOTTOM w0.127: 227.41,48.48 v3(227.6,48.67) ; CV24.2 153.62,137.43 153.47,137.28 153.47,136.8 v3(153.81,136.46)
PCH_DPC_AUX#: length 155.8
  IN1 w0.099: v3(153.17,136.46) 153.39,136.24 153.39,135.74 154.27,134.86 157.38,134.86 158.05,134.19 161.17,134.19 161.85,133.51 166.38,133.51 167.92,135.05 170.06,135.05 170.29,135.29 189.08,135.29 190.54,133.83 195.51,133.83 196.47,132.87 198.17,132.87 198.78,132.26 199.45,132.26 208.01,123.7 208.01,113.8 212.22,109.58 216.5,109.58 222.37,103.71 223.44,103.71 231.04,96.12 231.04,69.85 230.59,69.41 230.59,61.28 227.93,58.61 227.93,56.64 227.32,56.03 227.32,49.95 226.88,49.51 226.88,48.55 227.15,48.28 227.34,48.28 v3(227.57,48.05)
  BOTTOM w0.089: UH1.K43 226.35,47.27 226.68,47.6 226.68,48.03 226.86,48.21 227.41,48.21 v3(227.57,48.05)
  BOTTOM w0.127: v3(153.17,136.46) 153.22,136.52 153.22,137.18 CV25.2
PCH_DPC_CLK: length 163.9
  IN1 w0.099: v3(153.32,139.08) 153.02,139.08 152.85,138.91 152.85,137.96 152.55,137.66 152.55,135.88 154.05,134.38 157.06,134.38 158.41,133.03 166.61,133.03 168.14,134.56 172.6,134.56 172.79,134.75 188.75,134.75 190.17,133.33 194.08,133.33 195.05,132.36 197.94,132.36 202.01,128.28 202.71,128.28 207.53,123.47 207.53,113.6 212.11,109.01 215.63,109.01 222.11,102.53 223.89,102.53 230.56,95.86 230.56,70.05 230.11,69.6 230.11,61.51 226.66,58.06 226.66,52.78 v3(226.84,52.59) 226.84,52.55 226.67,52.38 226.67,50.29 226,49.62 226,47.08 225.4,46.48 225.4,44.13 225.12,43.85 224.91,43.85 224.74,43.68 v3(224.74,43.64)
  BOTTOM w0.089: v3(224.74,43.64) 224.48,43.38 UH1.R35
  BOTTOM w0.127: RV528.2 227.45,52.27 227.16,52.27 v3(226.84,52.59) ; UV3.3 153.82,139.58 v3(153.32,139.08)
PCH_DPC_DAT: length 164
  IN1 w0.099: v3(152.12,139.05) 152.49,139.05 152.64,138.9 152.64,138.04 152.34,137.74 152.34,135.79 153.97,134.17 156.98,134.17 158.32,132.82 166.7,132.82 168.22,134.35 172.68,134.35 172.88,134.54 188.66,134.54 190.08,133.12 194,133.12 194.97,132.15 197.85,132.15 201.92,128.07 202.63,128.07 207.32,123.38 207.32,113.51 212.02,108.8 215.54,108.8 222.02,102.32 223.8,102.32 230.35,95.77 230.35,70.14 229.89,69.68 229.89,61.59 226.44,58.14 226.44,52.77 v3(226.26,52.58) 226.46,52.38 226.46,50.38 225.79,49.71 225.79,47.17 225.19,46.57 225.19,44.22 225.03,44.06 224.92,44.06 v3(224.69,44.29)
  BOTTOM w0.089: UH1.R36 224.38,43.98 v3(224.69,44.29)
  BOTTOM w0.127: UV3.6 151.87,139.3 v3(152.12,139.05) ; v3(226.26,52.58) 226.85,51.98 RV529.2
PCH_DPWROK: length 64.8
  TOP w0.127: v3(237.66,24.57) 237.42,24.34 RH45.2 ; UE5.127 289.14,25.45 287.68,23.99 v3(287.68,23.22)
  IN1 w0.099: v3(287.68,23.22) 287.28,22.81 287.01,22.81 286.79,22.6 283.72,22.6 283.43,22.3 280.69,22.3 280.12,21.73 273.76,21.73 273.36,22.13 264.82,22.13 255.53,31.41 244.88,31.41 238.04,24.57 v3(237.66,24.57)
  BOTTOM w0.127: v3(237.66,24.57) v1(237.66,23.74)
PCH_DRWROK_R: length 15.5
  TOP w0.089: 231.02,28.72 230.84,28.89 230.51,28.89 229.77,29.63 229.77,30.96 229.18,31.56 228.81,31.56 228.39,31.97 227.77,31.97 227.71,31.91 227.21,31.91 226.93,32.18 226.57,32.18 226.15,32.61 226.15,33.31 v3(225.79,33.67)
  TOP w0.127: RH45.1 RH46.1 233.67,25.64 232.45,25.64 v1(232.21,25.88) 232.21,26.13 231.09,27.24 231.09,28.64 231.02,28.72
  BOTTOM w0.089: v3(225.79,33.67) 225.79,33.9 UH1.L13
PCH_ENVDD: length 253.6
  TOP w0.089: v3(227.54,44.04) 227.91,43.68 228.37,43.68 228.83,44.13 229.77,44.13 v1(230.71,45.07) 231.12,45.48 231.12,45.81 231.33,46.03
  TOP w0.127: 231.33,46.03 231.43,46.13 RH54.2
  IN4 w0.091: v3(87.37,118.67) 87.78,119.09 89.56,119.09 91.27,120.8 95.08,120.8 97.49,123.21 97.49,124.27 104.94,131.72 126.05,131.72 129.82,135.49 135.49,135.49 137.09,137.09 137.81,137.09 139.32,138.6 142.62,138.6 143.6,137.62 149.71,137.62 152.23,140.14 156.52,140.14 157.25,139.41 169.65,139.41 171.32,137.75 172.18,137.75 173.78,136.14 174.71,136.14 175.27,135.57 182.22,135.57 185.71,139.06 188.51,139.06 190.14,140.69 193.45,140.69 197.91,136.22 197.91,134.67 199.29,133.29 200.48,133.29 209.6,124.18 209.6,120.64 212.25,117.99 212.25,113.37 214.36,111.26 214.36,110.01 216.04,108.34 222.51,108.34 228.69,102.15 232.76,102.15 233.53,101.39 v3(233.53,101.29)
  IN6 w0.099: v3(233.53,101.29) 233.53,100.76 232.81,100.04 232.81,98.89 234.67,97.03 234.67,71.58 234.01,70.92 234.01,66.7 233.67,66.35 233.67,65.21 228.69,60.24 228.69,56.31 228.13,55.74 228.13,45.97 227.78,45.62 227.78,44.27 v3(227.54,44.04)
  BOTTOM w0.089: v3(227.54,44.04) 227.85,43.74 UH1.G36
  BOTTOM w0.127: v3(87.37,118.67) 86.27,118.67 RV3.1
PCH_GPIO0: length 7.2
  TOP w0.089: RH113.2 210.81,34 v1(211.52,33.29)
  TOP w0.102: v1(211.52,33.29) 212.12,32.69 213.2,32.69 213.61,32.28 215.94,32.28 v3(216.29,31.93)
  BOTTOM w0.089: UH1.AT8 216.02,32.2 v3(216.29,31.93)
PCH_GPIO1: length 8.9
  TOP w0.127: v3(228.33,33.68) 228.33,33.44 v1(228.56,33.21) 228.87,32.91 229.59,32.91 229.96,32.54 231.45,32.54 232.5,31.49 232.5,30.33 RH115.2
  BOTTOM w0.089: v3(228.33,33.68) 228.45,33.79 UH1.F13
PCH_GPIO13: length 4.7
  BOTTOM w0.089: 231.65,38.12 230.68,38.12 230.51,38.29 230.26,38.29 229.94,37.98 UH1.C22
  BOTTOM w0.127: RH60.2 233.69,37.59 v1(232.7,37.59) 232.36,37.59 231.83,38.12 231.65,38.12
PCH_GPIO16: length 47
  IN6 w0.099: v3(208.99,20.14) 208.58,19.73 206.23,19.73 205.96,19.45 200.36,19.45 199.66,18.76 193.86,18.76 192.66,17.56 191.99,17.56 190.88,16.45 189.86,16.45 189.19,15.78 184.37,15.78 v3(183.87,15.28)
  BOTTOM w0.089: 216.36,27.65 216.49,27.77 216.49,28.56 216.89,28.97 216.89,29.39 UH1.AN2
  BOTTOM w0.127: v3(183.87,15.28) 183.11,14.52 180.11,14.52 179.65,14.05 JSSD3.61 ; v3(208.99,20.14) 209.93,20.14 210.91,21.12 v1(211.15,21.12) 211.41,21.12 212.05,21.77 RH132.1 212.05,22.13 212.35,22.42 212.35,23.92 RH130.2 213.13,24.7 213.13,25.22 213.41,25.49 213.94,25.49 214.18,25.73 214.45,25.73 216.36,27.65
PCH_GPIO19: length 10.5
  BOTTOM w0.089: UH1.AU2 215.45,29.48 215.45,28.36 214.95,27.87
  BOTTOM w0.127: RH8.2 208.65,24.92 209.07,24.92 209.27,25.12 v1(209.27,25.73) 209.55,26.01 212.23,26.01 212.93,26.71 213.45,26.71 213.67,26.93 214.02,26.93 214.95,27.87
PCH_GPIO21: length 9.1
  BOTTOM w0.089: 215.06,27.65 215.67,28.27 215.67,28.96 UH1.AT1
  BOTTOM w0.127: RH7.1 210.36,25.74 212.29,25.74 213.01,26.47 213.54,26.47 213.78,26.71 214.11,26.71 215.06,27.65
PCH_GPIO22: length 3.4
  TOP w0.089: v3(213.17,30.96) 212.78,31.35 210.73,31.35 RH118.2
  BOTTOM w0.089: v3(213.17,30.96) 213.08,30.87 UH1.BB4
PCH_GPIO33: length 9.4
  BOTTOM w0.089: UH1.B17 230.02,35.88 230.58,35.88 230.6,35.9 231,35.9 231.21,35.69 231.21,35.39 231.21,35.38 231.21,35.34 231.43,35.12
  BOTTOM w0.127: RH14.2 237.19,32.97 235.35,32.97 235.02,33.3 234.24,33.3 233.99,33.56 233.77,33.56 v1(233.62,33.71) 233.2,34.13 232.79,34.13 231.82,35.1 231.45,35.1 231.43,35.12
PCH_GPIO35: length 7.2
  BOTTOM w0.089: UH1.AP1 216.6,28.94 216.3,28.64 216.3,27.91 216.04,27.65
  BOTTOM w0.127: 216.04,27.65 214.35,25.96 214.09,25.96 213.86,25.73 213.31,25.73 212.34,24.77 212.18,24.77 RH126.1
PCH_GPIO36: length 12.3
  BOTTOM w0.089: UH1.AT3 215.78,29.51 216.09,29.2 216.09,28.98 215.91,28.8 215.91,28.18 215.38,27.65
  BOTTOM w0.127: RH138.1 209.53,22.18 209.53,23.95 RH136.1 210,24.87 v1(210.52,25.39) 210.61,25.48 212.35,25.48 213.09,26.23 213.65,26.23 213.88,26.46 214.19,26.46 215.38,27.65
PCH_GPIO37: length 8.4
  BOTTOM w0.089: 217.67,27.65 217.67,27.86 218.1,28.29 218.1,28.95 UH1.AK1
  BOTTOM w0.127: 217.67,27.65 217.67,27.61 216.21,26.15 v1(216.21,25.78) 216.21,25.44 215.67,24.91 RH137.2 216.14,23.95 216.14,22.54 RH139.1
PCH_GPIO39: length 7.6
  BOTTOM w0.089: 217.01,27.65 217.01,27.74 217.71,28.43 217.71,29.22 217.53,29.4 217.53,29.87 217.42,29.98 UH1.AM3
  BOTTOM w0.127: RH119.2 214.19,24.87 214.58,24.87 214.9,25.18 v1(214.9,25.4) 214.9,25.54 217.01,27.65
PCH_GPIO49: length 25
  BOTTOM w0.089: UH1.AK3 218.17,29.93 218.17,29.43 217.9,29.15 217.9,28.36 217.33,27.79 217.33,27.65
  BOTTOM w0.127: JSSD2.61 205.65,13.87 206.09,14.31 208.35,14.31 210.56,16.52 210.56,19.95 211.01,20.41 212.47,20.41 212.77,20.7 RH158.1 214.05,21.17 214.05,22.04 213.92,22.16 v1(213.92,22.54) 213.92,22.88 214.24,23.2 214.24,23.91 RH157.2 215.22,24.88 215.22,25.53 217.33,27.65
PCH_GPIO65: length 7.2
  TOP w0.089: v3(228.2,45.02) 228.4,45.21 229.83,45.21 230.27,45.65 230.27,47.89 v1(230.62,48.25) 230.66,48.28 231.02,48.28
  TOP w0.127: RPH3.2 231.02,48.28
  BOTTOM w0.089: UH1.F38 228.45,44.78 v3(228.2,45.02)
PCH_GPIO66: length 8
  TOP w0.089: v3(228.2,44.04) 227.9,44.33 v1(227.9,44.52) 227.98,44.59 228.37,44.59 228.79,45.01 230.01,45.01 230.56,45.56 230.56,47.42 230.84,47.7 231.02,47.7
  TOP w0.127: 231.02,47.7 231.8,47.7 231.88,47.78 RPH3.3
  BOTTOM w0.089: UH1.F36 228.45,43.88 228.28,44.04 v3(228.2,44.04)
PCH_GPIO70: length 5.4
  TOP w0.127: RH120.2 231.71,34.47 v1(231.13,34.47) 229.73,34.47 229.12,35.08 228.51,35.08 v3(228.13,34.7)
  BOTTOM w0.089: v3(228.13,34.7) 227.85,34.42 UH1.G13
PCH_GPIO71: length 17.8
  IN1 w0.099: v3(227.29,22.37) 227.31,22.38 227.31,23.08 225.85,24.54 225.44,24.54 225.09,24.89 225.09,25.7 224.86,25.93 224.86,26.6 225.53,27.27 225.53,29.11 225.1,29.53 225.1,32.24 224.35,33 224.35,33.87 224.64,34.17 226.36,34.17 v3(226.92,34.72)
  BOTTOM w0.089: UH1.H15 227.25,35.05 v3(226.92,34.72)
  BOTTOM w0.127: v3(227.29,22.37) 226.95,22.02 RH121.2
PCH_GPIO74: length 14.4
  TOP w0.127: v3(227.77,31.18) 227.99,30.96 227.99,29.63 228.98,28.64 228.98,28.2 229.17,28.01 229.17,26.06 v3(228.62,25.51)
  BOTTOM w0.089: v3(227.77,31.18) 227.41,31.18 UH1.H6
  BOTTOM w0.127: RH101.2 228.16,19.75 v1(228.45,20.04) 228.6,20.2 228.6,22.47 229.28,23.14 229.28,23.95 229.06,24.17 229.06,24.86 228.62,25.29 v3(228.62,25.51)
PCH_HDMI_HPD: length 224.8
  TOP w0.127: UV4.3 v3(111.07,142.66)
  IN3 w0.091: v3(129.99,134.55) 128.77,133.33 v3(125.9,133.33)
  IN4 w0.091: v3(125.9,133.33) 125.34,132.76 113.24,132.76 111.84,134.16 111.84,137.07 112.31,137.54 112.31,142.14 111.79,142.66 v3(111.07,142.66) ; v3(232.08,101.31) 231.93,101.46 228.45,101.46 225.19,104.73 222.31,107.61 215.84,107.61 213.7,109.74 213.7,110.99 211.56,113.13 211.56,117.72 208.85,120.43 208.85,123.77 200.07,132.55 198.91,132.55 197.22,134.25 197.22,135.99 193.26,139.94 190.32,139.94 188.79,138.41 186.21,138.41 185.43,137.63 185.43,136.91 183.44,134.91 175.01,134.91 174.44,135.49 171.27,135.49 170.26,136.5 170.26,137.81 169.31,138.76 156.95,138.76 156.23,139.48 153.12,139.48 152.77,139.12 152.77,138.21 151.52,136.96 143.19,136.96 142.62,137.53 138.87,137.53 137.94,136.6 137.29,136.6 135.64,134.95 130.39,134.95 v3(129.99,134.55)
  IN6 w0.099: v3(232.08,101.31) 232.03,101.26 232.03,98.71 233.93,96.81 233.93,71.84 233.34,71.25 233.34,66.98 232.99,66.63 232.99,65.59 228.01,60.61 228.01,56.59 227.45,56.02 227.45,51.71 226.55,50.81 226.55,46.3 v3(225.8,45.54)
  BOTTOM w0.089: v3(225.8,45.54) 226.02,45.77 UH1.K40
  BOTTOM w0.127: v3(111.07,142.66) 111.07,142.81 v1(111.36,143.1) 111.93,143.66 RV42.2
PCH_INTVRMEN: length 11.4
  TOP w0.127: v3(233.29,26.77) 233.29,29.16 232.25,30.21 232.25,30.9 RH4.1 231.03,32.12 v1(230.44,32.12) 229.87,32.12 229.45,32.54 228.88,32.54 228.66,32.32 228.15,32.32 v3(227.77,32.7)
  BOTTOM w0.089: v3(227.77,32.7) 227.76,32.71 227.76,33.12 227.84,33.19 UH1.G10
  BOTTOM w0.127: v3(233.29,26.77) 233.68,26.38 RH3.2
PCH_INV_PWM: length 306
  TOP w0.127: v3(122.18,107.53) 121.78,107.93 v1(121.78,108.19) 121.78,108.29 RC33.2 ; RV8.1 91.4,120.4 v3(91.46,120.4) 91.53,120.47 91.53,122.67 JEDP1.36
  IN2 w0.099: v3(91.46,120.4) 91.46,116.52 85.75,110.81 85.75,103.59 86.65,102.7 87.67,102.7 88.25,102.12 90.42,102.12 91.93,103.62 110.17,103.62 113.44,106.9 121.54,106.9 v3(122.18,107.53)
  IN4 w0.091: v3(91.46,120.4) 95,120.4 97.76,123.16 97.76,124.19 105.07,131.5 126.14,131.5 129.87,135.23 135.59,135.23 137.19,136.83 137.86,136.83 139.38,138.35 142.49,138.35 143.44,137.4 149.87,137.4 152.39,139.92 156.43,139.92 157.16,139.19 169.56,139.19 171.23,137.53 172.09,137.53 173.69,135.92 174.62,135.92 175.19,135.35 182.31,135.35 185.81,138.84 188.61,138.84 190.2,140.44 193.39,140.44 197.69,136.13 197.69,134.56 199.24,133.01 200.45,133.01 209.35,124.11 209.35,120.58 212.03,117.9 212.03,113.28 214.14,111.17 214.14,109.92 215.98,108.09 222.45,108.09 228.6,101.93 232.62,101.93 233.09,101.46 v3(233.09,100.9)
  IN6 w0.099: v3(233.09,100.9) 232.51,100.32 232.51,98.87 234.41,96.97 234.41,71.63 233.79,71.01 233.79,66.79 233.44,66.44 233.44,65.33 228.46,60.36 228.46,56.4 227.9,55.83 227.9,51.52 227,50.62 227,45.99 226.8,45.79 226.8,43.84 226.6,43.64 v3(225.91,43.64)
  BOTTOM w0.089: v3(225.91,43.64) 225.57,43.98 UH1.N36
PCH_JTAG_TCK: length 8.2
  BOTTOM w0.089: 221.74,27.65 221.36,28.04 221.36,28.56 221.76,28.96 221.76,29.23 221.47,29.52 UH1.AB3
  BOTTOM w0.127: 221.74,27.65 221.89,27.5 221.89,26.49 222.57,25.81 224.2,25.81 v2(224.45,25.56) 224.45,25.56 224.65,25.35 224.65,24.59 RH18.1
PCH_JTAG_TDI: length 8.5
  BOTTOM w0.089: UH1.AE2 220.36,29.44 220.36,28.91 220.46,28.81 220.46,27.59 220.53,27.53
  BOTTOM w0.127: RH21.2 221.19,22.42 221.19,23.93 RH26.1 221.66,25.05 v2(221.19,25.52) 220.98,25.73 220.98,26.39 220.53,26.84 220.53,27.53
PCH_JTAG_TDO: length 9.9
  BOTTOM w0.089: UH1.AD3 220.66,29.52 220.95,29.23 220.95,27.78 220.97,27.76
  BOTTOM w0.127: 220.97,27.76 221.43,27.3 221.43,26.21 222.37,25.28 v1(222.72,25.28) 222.9,25.28 223.09,25.08 223.09,23.93 RH27.1 223.09,23.04 223.09,22.4 RH23.2
PCH_JTAG_TMS: length 8.3
  BOTTOM w0.127: UH1.AD1 220.72,29.02 220.72,27.69 220.91,27.5 v2(220.91,27.24) 221.2,26.94 221.2,26.04 222.14,25.11 222.14,24.89 RH25.1 222.15,23.92 222.15,22.42 RH19.2
PCH_LID_SW_IN#: length 29.8
  TOP w0.127: RH127.1 225.69,15.2 v1(227.99,15.2) 229.1,15.2 RH102.1 229,15.69 229,16.66 229.73,17.4 230.51,17.4 230.79,17.68 231.69,17.68 232.83,18.82 233.82,18.82 235.03,20.03 v3(235.03,20.4)
  IN1 w0.099: v3(235.03,20.4) 234.1,21.33 234.1,23.98 233.89,24.19 232.68,24.19 229.34,27.53 229.34,27.92 228.4,28.87 227.66,28.87 226.34,30.18 226.34,30.48 225.89,30.94 v3(225.89,31.29)
  BOTTOM w0.089: v3(225.89,31.29) 225.57,31.61 UH1.N7
PCH_MDP_HPD: length 190
  TOP w0.089: v3(225.8,44.27) 226.28,44.76 v1(226.28,45.21) 226.28,46.53 RH57.2
  IN4 w0.091: v3(139.61,137.95) 142.51,137.95 143.28,137.18 151.43,137.18 152.55,138.3 152.55,139.22 153.03,139.7 156.34,139.7 157.07,138.98 169.4,138.98 169.59,138.79 169.6,138.79 170.48,137.91 170.48,136.59 171.37,135.7 174.53,135.7 175.1,135.13 183.31,135.13 185.19,137.01 185.19,137.7 186.12,138.63 188.7,138.63 190.26,140.19 193.33,140.19 197.43,136.08 197.43,134.34 199,132.77 200.17,132.77 209.1,123.84 209.1,120.52 211.81,117.81 211.81,113.19 213.92,111.08 213.92,109.83 215.9,107.86 222.37,107.86 228.51,101.72 232.27,101.72 v3(232.67,101.32)
  IN6 w0.099: v3(225.8,44.27) 226.25,44.73 226.25,45.62 226.78,46.14 226.78,50.72 227.67,51.62 227.67,55.93 228.24,56.49 228.24,60.47 233.21,65.45 233.21,66.54 233.56,66.89 233.56,71.13 234.15,71.72 234.15,96.91 232.27,98.79 232.27,100.92 v3(232.67,101.32)
  BOTTOM w0.089: v3(225.8,44.27) 226.09,44.57 UH1.K38
  BOTTOM w0.127: v3(139.61,137.95) 139.8,138.14 JDP1.2
PCH_PCIE_IREF: length 1.6
  TOP w0.254: RH110.1 211.34,42.15 v3(211.34,41.49)
  BOTTOM w0.203: UH1.BE30 211.59,41.23 v3(211.34,41.49)
PCH_PCIE_RCOMP: length 3
  TOP w0.254: v3(210.63,41.49) 210.92,41.79 210.92,42.21 RH111.2
  BOTTOM w0.203: UH1.BD29 212.16,40.76 211.36,40.76 v3(210.63,41.49)
PCH_PLTRST#: length 264.6
  TOP w0.089: 223.33,30.16 223.33,32.79 v3(222.89,33.23)
  TOP w0.127: UH3.2 220.07,21.17 220.21,21.31 220.21,21.63 220.01,21.82 UH3.1 219.25,21.82 219.19,21.88 219.19,23.59 219.53,23.93 219.53,25.54 221.07,27.08 221.07,28.35 222.28,29.55 222.72,29.55 223.33,30.16 ; v3(167.41,21.76) v1(167.41,22.33)
  IN4 w0.091: v3(157.18,54.95) 157.56,54.95 162.08,50.43 164.52,50.43 166.04,48.91 166.04,43.75 167.96,41.84 167.96,32.83 v3(168.82,31.97) ; v3(160.79,74.84) 160.79,76.58 161.38,77.17 161.38,81.13 161.62,81.36 161.62,82.01 161.27,82.36 161.27,85.67 161.56,85.96 161.56,95.79 159.83,97.53 159.83,98.31 159.43,98.72 159.43,100.8 156.98,103.24 156.98,111.95 158.41,113.38 158.41,122.94 156.42,124.93 155.89,124.93 155.37,125.46 154.86,125.46 154.41,125.9 154.41,127.07 155.3,127.96 155.3,130.2 155.66,130.56 155.66,134.05 156.4,134.79 161.46,134.79 162.07,135.4 164.45,135.4 165.38,136.33 166.14,136.33 166.56,135.9 166.56,134.13 168.54,132.15 168.54,131.76 169.69,130.62 174.11,130.62 174.58,131.09 186.3,131.09 188.81,133.61 195.16,133.61 195.89,134.33 v3(195.89,136.58)
  IN5 w0.089: v3(160.79,74.84) 160.79,66.34
  IN5 w0.099: v3(167.41,21.76) 168.23,22.57 168.23,24.44 169.55,25.76 169.55,31.24 v3(168.82,31.97) ; v3(157.18,54.95) 157.89,55.66 157.89,61.34 160.79,64.24 160.79,66.34
  IN6 w0.099: v3(167.41,21.76) 168.87,20.3 175.73,20.3 176.09,19.93 182.3,19.93 182.95,20.58 190.3,20.58 190.61,20.89 191.18,20.89 192.11,21.83 192.11,22.46 193.71,24.05 196.89,24.05 197.84,23.1 200.93,23.1 201.66,23.83 211.52,23.83 216.03,28.34 216.03,28.46 217.16,29.59 220.72,29.59 222.32,31.19 222.32,32.66 v3(222.89,33.23)
  BOTTOM w0.089: UH1.Y11 222.52,33.23 v3(222.89,33.23)
  BOTTOM w0.127: v3(195.89,136.58) 195.59,136.87 195.59,138.18 195.89,138.48 UM3.2 ; UV14.2 155.96,74.54 156.17,74.32 156.78,74.32 157.3,74.84 v3(160.79,74.84)
PCH_PWR_EN: length 93.9
  TOP w0.127: v3(294.28,19.17) 294.27,19.17 RE74.1 ; v3(241.69,13.47) v1(241.69,12.78) ; v3(215.1,11.51) 215.1,11.66 RE62.2
  IN4 w0.091: v3(241.69,13.47) 240.31,13.47 240.09,13.25 227.04,13.25 226.15,12.35 221.65,12.35 220.38,11.08 217.42,11.08 216.5,12 215.6,12 v3(215.1,11.51)
  IN6 w0.099: v3(241.69,13.47) 242.07,13.86 262.24,13.86 264.35,15.97 268.23,15.97 269.12,16.85 272.26,16.85 273.22,15.9 273.22,13.65 272.99,13.43 272.99,12.49 273.88,11.6 290.07,11.6 293.6,15.13 293.6,18.49 v3(294.28,19.17)
PCH_PWROK: length 91.1
  TOP w0.127: UH2.1 214.78,20.46 215.36,21.03 RH49.1 215.65,19.21 v3(215.74,19.12) 215.86,19 217.22,19 RH50.1 ; v3(272.06,15.43) 271.93,15.43 269.1,18.26 v1(269.1,21.29) 269.1,25.26 271.43,27.59 274.14,27.59 CE44.1 RE75.1 276,28.55 UE5.32
  IN1 w0.099: v3(272.06,15.43) 272.06,15.03 271.7,14.67 268.83,14.67 267.98,15.51 261.55,15.51 260.11,14.07 239.57,14.07 239.01,14.64 236.97,14.64 236.35,15.26 233.57,15.26 232.55,14.24 226.25,14.24 224.69,15.8 216.2,15.8 215.74,16.26 v3(215.74,19.12)
PCH_PWROK_R: length 19.5
  TOP w0.127: v2(217.05,22.14) v3(216.35,22.14) 216.16,21.95 RH49.2
  IN6 w0.099: v3(228.37,32.7) 228.37,32.57 227.37,31.57 227.37,31.02 226.95,30.6 226.95,30.06 222.38,25.49 218.95,25.49 216.35,22.89 v3(216.35,22.14)
  BOTTOM w0.089: v3(228.37,32.7) 228.37,33.11 UH1.F10
PCH_RI#: length 6.8
  TOP w0.127: v3(224.83,27.36) v1(224.29,26.83) 224.29,25.05 223.9,24.65 223.81,24.65 RH37.2
  BOTTOM w0.089: 224.83,27.65 225.01,27.83 225.01,29.23 224.82,29.42 224.82,29.63 225.13,29.94 UH1.N4
  BOTTOM w0.127: 224.83,27.65 v3(224.83,27.36)
PCH_RSMRST#: length 70.5
  TOP w0.127: UE5.100 288.93,14.65 288.52,14.24 287.85,14.24 287.63,14.45 287.63,16.3 287.23,16.7 v3(287.23,17.13)
  IN1 w0.099: v3(229.81,19.58) 230.76,18.63 231.08,18.63 231.49,18.23 231.87,18.23 232.1,18.46 234.81,18.46 235.28,17.99 239.71,17.99 241.17,16.52 257.74,16.52 259.99,18.78 268.55,18.78 269.48,17.84 278.59,17.84 279.04,18.3 283.62,18.3 284.79,17.13 v3(287.23,17.13)
  BOTTOM w0.127: RH38.2 230,19.4 v3(229.81,19.58) 229.88,19.65 229.88,20.23 230.08,20.42 RH53.1 231.23,20.04 231.87,19.41 v1(231.94,19.41)
PCH_RSMRST#_R: length 20.4
  TOP w0.127: RH46.2 v3(235.67,22.73)
  BOTTOM w0.089: UH1.J2 226.87,29.43 226.87,28.58
  BOTTOM w0.127: v3(235.67,22.73) v1(234.35,21.41) 234.36,21.4 234.36,20.07 234.05,19.76 231.95,19.76 231.71,20 231.71,20.86 RH53.2 231.23,21.56 230.58,22.21 230.58,25.18 229.15,26.61 228.39,26.61 226.91,28.08 226.91,28.54 226.87,28.58
PCH_RTCRST#: length 161.9
  TOP w0.127: v3(142.47,13.56) 142.47,14.75 v1(143.44,15.72) 144.56,16.84 144.56,22.69 144.96,23.09 144.96,23.88 145.53,24.45 145.53,26.27 145.85,26.58 v3(146.89,26.58)
  IN6 w0.099: v3(234.51,27.92) 234.51,27.27 233.56,26.32 232.02,26.32 230.79,25.08 230.79,23.27 228.73,21.21 228.73,19.23 230.63,17.33 230.63,16.42 229.39,15.18 218.33,15.18 215.62,12.47 206.86,12.47 205.84,13.49 203.38,13.49 202.9,13.97 196.32,13.97 193.87,11.53 193.87,11.04 192.36,9.53 180.62,9.53 179.36,10.79 173.13,10.79 172.01,9.67 167.6,9.67 167.09,10.18 158.25,10.18 156.57,11.86 153,11.86 152.67,12.19 151.52,12.19 149.81,13.9 142.81,13.9 v3(142.47,13.56)
  BOTTOM w0.089: UH1.D9 229.52,32.7 229.83,32.39 230.06,32.39 230.27,32.59 230.76,32.59 231.59,31.76
  BOTTOM w0.127: 231.59,31.76 231.71,31.63 231.71,30.7 233.89,28.53 RH13.2 234.05,28.37 v3(234.51,27.92) 234.62,27.8 236.26,27.8 236.46,28.01 CH4.2 ; CMOS1.2 140.44,47.25 140.98,46.7 140.98,44.27 145.8,39.46 145.8,37.75 145.29,37.24 145.29,31.17 146.89,29.57 v3(146.89,26.58)
PCH_RTCX1: length 8.6
  TOP w0.127: v3(229.37,30.74) 228.97,30.35 v1(228.97,29.54) 229.88,28.63 229.88,26.63 230.6,25.92 230.6,24.77 RH11.1 RH9.1
  BOTTOM w0.089: UH1.B5 229.66,31.04 v3(229.37,30.74)
PCH_RTCX1_R: length 3.6
  TOP w0.127: YH1.1 232.79,21.13 231.7,22.23 231.7,22.35 CH1.2 RH9.2
PCH_RTCX2: length 9.3
  TOP w0.127: YH1.2 232.15,23.83 CH2.2 RH11.2 231.27,26.09 230.49,26.86 v1(230.49,27.52) 230.49,28.49 229.4,29.58 v3(229.4,30.05)
  BOTTOM w0.089: UH1.B4 229.74,30.39 v3(229.4,30.05)
PCH_SATALED#: length 182
  TOP w0.127: v3(165.96,135.89) 166.25,135.6 v1(166.25,135.04)
  IN4 w0.091: v3(165.96,135.89) 165.96,135.89 164.96,134.9 162.19,134.9 161.64,134.35 156.58,134.35 156.1,133.87 156.1,130.38 155.74,130.02 155.74,127.78 154.85,126.89 154.85,126.08 155.04,125.89 155.6,125.89 156.12,125.37 156.63,125.37 158.85,123.15 158.85,112.73 159.23,112.35 159.23,101.61 159.62,101.22 159.62,98.86 160.07,98.4 160.07,97.58 161.28,96.37 162.16,96.37 162.41,96.12 162.41,94.92 161.82,94.34 161.82,85.95 161.47,85.59 161.47,83.65 162.44,82.68 162.44,81.5 161.57,80.63 161.57,77.09 161.15,76.67 161.15,74.56 160.53,73.94 160.53,63.32 158.37,61.15 158.37,58.22 162.3,54.29 163.97,54.29 164.89,53.37 165.5,53.37 165.86,53.01 165.86,51.9 167.13,50.63 199.1,50.63 201.3,48.43 201.3,31.49 205.26,27.52 207.74,27.52 209.44,25.82 210.76,25.82 v3(211.52,25.06)
  BOTTOM w0.089: UH1.AP3 216.6,29.49 216.28,29.17 216.28,28.9 216.11,28.72 216.11,28.04 215.97,27.9 215.93,27.9 215.68,27.65
  BOTTOM w0.127: QE12.2 166.1,135.74 v3(165.96,135.89) ; 215.68,27.65 215.63,27.6 215.63,27.57 214.29,26.23 214,26.23 213.76,25.99 213.2,25.99 212.34,25.13 211.59,25.13 v3(211.52,25.06) RH10.1
PCH_SMBCLK: length 466.4
  TOP w0.127: v3(140.29,12.72) 140.29,13.04 141.68,14.44 141.68,15.94 140.02,17.61 140.02,24.6 139.26,25.36 139.26,28.36 139.59,28.69 140.35,28.69 v3(140.55,28.49) ; UN2.4 268.59,10.24 268.89,10.54 268.89,11.29 268.14,12.04 268.14,13.27 269.67,14.81 269.67,15.78 v3(269.84,15.94) ; JPWR1.24 184.65,147.32 184.79,147.18 184.79,146.73 v3(184.62,146.56) ; RH95.1 224.4,18.65 v3(224.4,17.82) 224.82,17.4 225.3,17.4 RH93.2 225.92,18.02 QH4.1
  IN1 w0.099: v3(105.04,137.33) 105.24,137.14 105.88,137.14 106.47,136.55 109.8,136.55 111.23,135.11 112.67,135.11 113.31,135.75 114.06,135.75 114.67,136.36 131.78,136.36 132.1,136.04 137.19,136.04 137.61,135.63 139.12,135.63 139.53,136.04 140.97,136.04 142.52,137.59 148.79,137.59 150.03,138.83 150.03,139.99 151.33,141.29 155.75,141.29 157.72,139.32 160.08,139.32 161.14,138.26 161.14,137.64 161.57,137.2 164.15,137.2 165.95,139 166.24,139 169.85,142.61 173.99,142.61 178.22,146.84 179.19,146.84 179.95,146.08 182.02,146.08 182.2,145.9 184.61,145.9 184.8,146.09 184.8,146.38 v3(184.62,146.56) ; v3(224.4,17.82) 224.63,17.59 224.63,16.89 226.79,14.72 232.4,14.72 233.39,15.71 239.05,15.71 240.24,14.52 258.95,14.52 260.49,16.05 268.07,16.05 268.84,15.28 269.4,15.28 269.66,15.55 269.66,15.76 v3(269.84,15.94)
  IN6 w0.099: v3(105.04,137.33) 104.86,137.15 103.21,137.15 98.42,132.35 98.42,125.44 97.01,124.04 97.01,118.36 86.02,107.37 86.02,99.02 84.06,97.05 78.28,97.05 76.04,94.81 76.04,65.76 78.36,63.44 78.36,45.37 75.91,42.92 75.91,36.93 74.52,35.53 74.52,33.21 77.34,30.38 80.07,30.38 83.95,26.5 134.17,26.5 134.18,26.51 134.26,26.51 135.97,28.22 138.88,28.22 139.33,28.67 140.37,28.67 v3(140.55,28.49) ; v3(140.29,12.72) 140.09,12.91 140.09,13.04 140.31,13.26 141.38,13.26 142.59,14.47 150.02,14.47 151.75,12.74 152.99,12.74 153.32,12.42 156.8,12.42 157.91,11.31 162.12,11.31 162.13,11.32 162.46,11.32 162.47,11.31 166.81,11.31 167.9,10.22 170.97,10.22 172.19,11.45 174.62,11.45 175.01,11.84 179.1,11.84 180.85,10.09 191.63,10.09 196.08,14.53 203.13,14.53 203.61,14.05 206.07,14.05 207.09,13.03 215.37,13.03 218.33,15.99 219.7,15.99 221.74,18.03 224.18,18.03 v3(224.4,17.82)
  BOTTOM w0.127: v3(140.55,28.49) 141.23,29.17 141.23,29.48 141.34,29.6 JDIMM1.202 ; v3(140.29,12.72) 140.08,12.92 140.08,13.36 140.24,13.51 140.24,14.78 141.18,15.72 141.18,16.4 141.35,16.57 JDIMM2.202
PCH_SMBDATA: length 471
  TOP w0.127: v3(185.2,146.56) 185.04,146.73 185.04,147.19 185.15,147.3 JPWR1.25 ; v3(269.25,15.94) 269.42,15.78 269.42,14.92 267.88,13.38 267.88,12 267.72,11.84 267.02,11.84 266.82,11.64 UN2.6 ; v3(139.69,12.73) 140.03,13.07 140.03,13.15 141.43,14.55 141.43,15.84 139.77,17.5 139.77,24.5 139,25.26 139,28.47 139.48,28.95 140.41,28.95 v3(140.54,29.08) ; v3(225.06,17.83) 224.77,18.12 224.77,20.17 225.02,20.42 225.44,20.42 226.13,19.74 228.11,19.74 RH96.1 228.05,20.28 228.05,21.17 227.54,21.68 RH94.2 227.22,21.68 QH4.4
  IN1 w0.099: v3(185.2,146.56) 185.03,146.38 185.03,146 184.7,145.67 182.1,145.67 181.93,145.85 179.86,145.85 179.1,146.61 178.31,146.61 174.08,142.38 169.94,142.38 166.34,138.78 166.05,138.78 164.24,136.97 161.48,136.97 160.91,137.54 160.91,138.17 159.98,139.1 157.63,139.1 155.66,141.06 151.43,141.06 150.26,139.89 150.26,138.74 148.88,137.37 142.61,137.37 141.06,135.82 139.63,135.82 139.21,135.4 137.51,135.4 137.1,135.82 132.01,135.82 131.69,136.14 114.76,136.14 114.15,135.53 113.41,135.53 112.77,134.89 111.14,134.89 109.7,136.32 106.38,136.32 105.79,136.91 105.21,136.91 v3(105.04,136.74) ; v3(269.25,15.94) 269.44,15.76 269.44,15.64 269.3,15.51 268.94,15.51 268.17,16.28 260.4,16.28 258.86,14.74 240.33,14.74 239.14,15.93 233.29,15.93 232.31,14.95 226.89,14.95 224.86,16.98 224.86,17.63 v3(225.06,17.83)
  IN6 w0.099: v3(140.54,29.08) 140.36,28.9 139.23,28.9 138.78,28.45 135.88,28.45 134.3,26.87 134.29,26.87 134.15,26.73 134.09,26.73 134.08,26.73 84.05,26.73 80.17,30.61 77.44,30.61 74.74,33.3 74.74,35.44 76.14,36.84 76.14,42.83 78.59,45.28 78.59,63.53 76.27,65.85 76.27,94.72 78.37,96.83 84.15,96.83 86.25,98.92 86.25,107.28 97.23,118.26 97.23,123.94 98.64,125.35 98.64,132.26 103.31,136.92 104.86,136.92 v3(105.04,136.74) ; v3(225.06,17.83) 224.63,18.26 221.65,18.26 219.6,16.21 218.23,16.21 215.27,13.25 207.18,13.25 206.16,14.28 203.71,14.28 203.23,14.76 195.98,14.76 191.54,10.32 180.95,10.32 179.2,12.07 174.92,12.07 174.52,11.67 172.1,11.67 170.87,10.45 167.99,10.45 166.9,11.54 162.56,11.54 162.56,11.54 162.03,11.54 162.03,11.54 158,11.54 156.89,12.64 153.42,12.64 153.09,12.97 151.84,12.97 150.12,14.69 142.5,14.69 141.29,13.49 140.22,13.49 139.87,13.14 139.87,12.91 v3(139.69,12.73)
  BOTTOM w0.127: v3(140.54,29.08) 140.68,29.08 140.91,29.3 140.91,29.44 140.74,29.6 JDIMM1.200 ; JDIMM2.200 140.75,16.56 140.91,16.4 140.91,15.8 140,14.9 140,13.61 139.84,13.45 139.84,12.88 v3(139.69,12.73)
PCH_SPI_CLK: length 11.3
  TOP w0.127: v3(218.28,33.1) 218.02,33.1 217.58,32.65 217.35,32.65 216.95,32.26 216.95,30.99 216.64,30.67 216.64,30.14 215.45,28.95 215.45,28.46 214.77,27.77 v1(214.16,27.77) 213.72,27.77 213.13,27.18 RT14.1 212.88,26.84 212.51,26.84 RH104.2
  BOTTOM w0.089: v3(218.28,33.1) 218.51,33.1 UH1.AJ11
PCH_SPI_CLK_R: length 27.9
  TOP w0.127: v3(212.85,22.25) 212.33,22.77 212.33,23.79 RH108.2 212.26,24.98 RH104.1
  IN1 w0.099: v3(212.85,22.25) 213.2,22.25 213.41,22.04 213.41,20.97 213.17,20.73 212.19,20.73 212.07,20.6 212.07,20.23 212.19,20.1 213.29,20.1 213.41,19.98 213.41,19.73 213.29,19.6 212.19,19.6 212.05,19.46 212.05,18.09 211.76,17.8 209.54,15.58 209.54,15.4 209.84,15.1 210.02,15.1 210.18,15.26 210.32,15.26 210.77,14.82 210.91,14.82 211.13,15.04 211.13,15.18 210.68,15.62 210.68,15.76 210.9,15.98 211.04,15.98 211.48,15.53 211.62,15.53 211.84,15.75 211.84,15.89 211.4,16.34 211.4,16.48 211.61,16.69 211.75,16.69 212.2,16.25 212.34,16.25 212.56,16.47 212.56,16.61 212.11,17.05 212.11,17.19 212.73,17.81 212.73,18.82 212.92,19.01 v3(213.11,19.01)
  BOTTOM w0.127: v3(213.11,19.01) 213.04,19.01 212.47,18.44 UH4.6
PCH_SPI_CLK_T: length 51.1
  TOP w0.127: RT14.2 212.97,25.51 212.97,23.36 v3(213.48,22.86)
  IN5 w0.099: v3(238.88,32.76) 239.74,31.89 239.74,26.08 237.49,23.83 237.49,20.94 235.94,19.39 231.87,19.39 230.09,21.17 216.16,21.17 215.18,22.15 214.19,22.15 v3(213.48,22.86)
  BOTTOM w0.127: UT2.21 241.74,36.15 RT16.2 240.12,35.65 238.62,35.65 238.42,35.45 238.42,33.33 238.13,33.03 238.13,32.72 v1(238.39,32.45) 238.57,32.45 v3(238.88,32.76)
PCH_SPI_CS0#: length 38.3
  IN6 w0.099: v3(208.69,25.52) 207.7,26.51 205.36,26.51 205.23,26.63 205.23,27.23 205.36,27.36 207.99,27.36 208.71,26.63 211.91,26.63 213.18,27.91 213.18,28.7 213.45,28.97 216.04,28.97 216.93,29.86 218.45,29.86 219.78,31.18 219.78,31.39 v3(219.32,31.85)
  BOTTOM w0.089: v3(219.32,31.85) 219.08,31.61 UH1.AJ7
  BOTTOM w0.127: UH4.1 202.97,15.9 202.73,16.14 202.73,19.36 205.44,22.06 v1(206.01,22.06) RH107.1 207.63,22.53 207.61,22.56 207.61,24.78 208.35,25.52 v3(208.69,25.52)
