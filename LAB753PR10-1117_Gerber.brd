# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1N: length 27.6
  IN4 w0.254: v3(143.83,121.57) 143.68,121.41 143.57,121.41 143.27,121.12 143.1,121.12 142.27,120.3 141.67,120.3 139.64,118.26 137.4,118.26 134.29,115.15 133.35,115.15 v3(133.29,115.09)
  BOTTOM w0.254: v3(143.83,121.57) 143.83,121.97 143.39,122.41 PR556.1 142.98,122.55 PR516.1 143.54,123.1 PR546.2 ; v3(133.29,115.09) 133.19,115.19 v1(132.7,115.19) 131.22,115.19 129.86,116.55 128.34,116.55 127.57,115.79 125.61,115.79 125.03,115.22 PL503.2
V2N: length 47.4
  IN4 w0.254: v3(116.72,115.66) 116.84,115.79 117.73,115.79 119.7,113.82 119.7,110.71 121.29,109.12 128.49,109.12 130.48,111.12 130.48,114.23 131.28,115.03 131.28,115.94 135.19,119.85 137.61,119.85 142.81,125.06 143.51,125.06 143.88,125.42 v3(144.76,125.42)
  BOTTOM w0.127: v1(145.33,125.25) 145.15,125.42 v3(144.76,125.42)
  BOTTOM w0.254: v3(116.72,115.66) 117.48,114.9 PL502.2 ; v3(144.76,125.42) 144.63,125.42 PR555.2 144.17,124.94 PR544.1 142.95,124.98 PR518.1
V3N: length 49
  TOP w0.127: v1(138.1,118.72) 138.53,119.15 v3(139.07,119.15)
  IN4 w0.254: v3(108.9,116.04) 109.03,116.17 109.92,116.17 111.25,114.84 111.25,111.72 111.25,111.09 113.48,108.87 120.14,108.87 120.65,108.36 128.8,108.36 132.04,111.6 132.04,115.24 134.37,117.57 135.42,117.57 136.89,119.04 138.88,119.04 138.99,119.15 v3(139.07,119.15)
  BOTTOM w0.254: v3(108.9,116.04) 109.92,115.03 PL501.2 ; 141.11,120.65 140.5,120.04 PR547.2 140.5,119.95 PR515.2 139.27,119.35 v3(139.07,119.15)
VCC_PGOOD: length 2
  BOTTOM w0.127: PU500.3 139.04,128.86 139.04,129.1 139.4,129.45 PR522.2
VCCSENSE: length 76
  TOP w0.254: v3(99.63,114.45) 99.6,114.42 98.2,114.42 v2(94.43,110.64) 93.22,109.44 RC45.2 RC44.2 ; PC541.2 139.07,127.93 140.06,127.93 140.44,128.31 140.87,128.31 141.51,128.95 PC545.1 142.74,128.95 v3(143,128.68) 143.03,128.68 143.94,127.76 143.94,126.76 143.31,126.13 PC520.1 142.45,126.11 PR537.1
  IN1 w0.254: v3(99.63,114.45) 99.76,114.58 99.76,118.33 103.19,121.76 103.19,124.43 109.75,130.99 126.79,130.99 128.74,129.04 132.38,129.04 133.97,130.63 139.72,130.63 141.67,128.68 v3(143,128.68)
VCCSENSE_R: length 8.1
  TOP w0.254: v3(95.14,101.02) 95.14,102.38 v2(94.46,103.05) 93.22,104.29 RC45.1
  BOTTOM w0.089: v3(95.14,101.02) CPU1.C50
VCCSENSE_VGA: length 120.6
  TOP w0.254: v3(168.4,84.78) 168.89,84.29 169.84,84.29 RV532.1
  TOP w0.406: PR627.1 187.06,21.71 v1(188.11,22.75) 188.53,23.18 v3(188.53,25.07)
  IN1 w0.406: v3(188.53,25.07) 188.5,25.11 187.95,25.11 186.63,23.79 179.76,23.79 177.69,25.86 177.33,25.86 176.21,26.98 174.49,26.98 173.84,27.63 173.84,27.99 173.13,28.7 173.13,30.34 172.59,30.88 172.27,30.88 171.7,31.45 170.64,31.45 168.71,33.39 167.57,33.39 166.12,34.85 166.12,45.87 164.55,47.44 160.4,47.44 155.83,52.01 154.71,52.01 152.49,54.23 152.49,55.32 151.04,56.77 148.59,56.77 148.45,56.91 147.23,56.91 144.49,59.65 144.49,66.65 146.04,68.2 146.04,77.91 147.82,79.69 154.93,79.69 158.68,83.44 167.72,83.44 167.86,83.3 168.63,83.3 169.04,83.71 169.04,84.15 168.41,84.78 v3(168.4,84.78)
  BOTTOM w0.254: UV1.AY23 v3(168.4,84.78)
VDD_1.35V: length 14.7
  TOP w0.127: v1(154.85,24.37) 154.65,24.37 v3(154.21,24.82)
  TOP w0.203: PR203.2 152.82,28.18 PU200.11
  TOP w0.254: PR203.2 PC212.1 154.05,24.97 v3(154.21,24.82) ; PR201.1 155.51,32.41 v3(155.96,32.41)
  IN4 w0.254: v3(154.21,24.82) 154.21,25.96 155.13,26.89 155.13,31.97 155.58,32.41 v3(155.96,32.41)
VDD_SW: length 1.6
  TOP w0.127: LA9.2 19.71,22.15 20.31,22.75 v1(20.49,22.75)
VDDQ_PLL: length 5.7
  TOP w0.203: UA1.16 15.52,17.4 15.18,17.06 v3(15.18,16.65) 15.18,16.52 15.5,16.2 UA1.19
  BOTTOM w0.127: v1(14.98,15.74) 14.98,16.45 v3(15.18,16.65)
  BOTTOM w0.254: LA10.2 15.99,17.39 CA3.1 15.23,16.65 v3(15.18,16.65)
VIN: length 93.7
  TOP w0.127: v2(45.81,19.71) 46,19.9 v3(46.36,19.9) ; v3(32.74,18.35) 32.74,17.84 v2(32.95,17.63)
  TOP w0.254: v3(59.07,49.01) 59.07,48.85 PR732.1 60.86,47.06 64.89,47.06 66.04,48.21 PR729.2 ; PR716.1 37.05,36.45 v3(36.83,36.67) ; v3(33.02,37.62) 32.75,37.35 PD700.3 32.03,37.86 31.35,38.55 30.15,38.55 PQ700.1 ; PD101.2 v2(18.32,35.74) 18.01,35.74 17.75,35.49 v3(17.75,35.09)
  IN1 w0.254: v3(33.02,37.62) 33.97,36.67 v3(36.83,36.67) ; v3(32.74,18.35) 32.74,19.55 32.09,20.2 28.81,20.2 27.29,21.71 26.57,21.71 22.16,26.11 22.16,27.03 20.33,28.86 20.33,32.51 v3(17.75,35.09)
  IN2 w0.099: v3(59.07,49.01) 58.69,48.63 54.24,48.63 52.68,47.07 51.38,47.07 50.5,46.18 49.87,46.18 48.42,44.73 47.12,44.73 44.94,42.56 42.56,42.56 40.6,40.6 40.6,37.59 39.55,36.54 36.96,36.54 v3(36.83,36.67)
  IN2 w0.254: v3(17.75,35.09) 18.4,35.74 20.92,35.74 22.11,36.93 32.33,36.93 v3(33.02,37.62)
  vias: v3(37.91,21.11) v3(37.92,20.42) v3(38.23,21.81) v3(38.58,20.39) v3(38.61,21.07) v3(38.86,21.81) v3(39.44,21.68) v3(43.82,26.7) v3(43.82,26.06) v3(44.45,26.68) v3(44.43,26.05) v3(45.06,26.67) v3(45.04,26.05) v3(46.99,19.9) v3(47.63,19.9)
VIN1N: length 5.7
  TOP w0.127: RV542.2 158.9,33.92 158.07,33.92 v1(157.48,33.34)
  TOP w0.254: UV20.11 161.24,34.07 160.97,33.81 CV409.1 159.78,33.81 RV542.2
VIN1P: length 4.6
  TOP w0.254: RV540.2 159.53,32.41 CV409.2 160.55,32.41 v1(161.89,33.75) UV20.12
VIN2N: length 5
  TOP w0.127: RV544.2 165.53,35.56 165.23,35.26 v1(164.48,35.26)
  TOP w0.254: UV20.14 164.22,36.91 CV410.1 RV544.2
VIN2P: length 4.1
  TOP w0.127: v1(166,39.08) 165.53,38.61 RV543.2
  TOP w0.254: RV543.2 CV410.2 163.97,37.56 UV20.15
VSSSENSE: length 76.5
  TOP w0.254: v3(100.33,115.28) 97.98,115.28 v2(92.72,110.01) 92.33,109.63 RC46.2 R3.1 ; PC545.2 142.6,128.03 143.18,127.45 v3(143.18,127.08)
  IN1 w0.254: v3(143.18,127.08) 142.39,127.87 141.39,127.87 139.39,129.87 138.81,129.87 138,129.06 133.48,129.06 132.7,128.28 128.35,128.28 126.41,130.23 110.07,130.23 103.95,124.11 103.95,121.38 100.59,118.01 100.59,115.53 v3(100.33,115.28)
  IN6 w0.254: v3(143.18,127.08) 142.5,126.39 142.5,124.68 141.42,123.6 139.85,123.6 139.7,123.74 v3(139.7,123.78)
  BOTTOM w0.203: PU500.13 139.7,123.88 v3(139.7,123.78)
  BOTTOM w0.254: PC546.2 139.7,123.28 v3(139.7,123.78)
VSSSENSE_R: length 9.2
  TOP w0.254: v3(95.08,100.38) 94.69,100.77 94.69,101.74 92.33,104.11 v2(92.33,105.15) RC46.1
  BOTTOM w0.089: v3(95.08,100.38) CPU1.D50
VSSSENSE_VGA: length 120.6
  TOP w0.254: RV533.2 169.95,85.33 v3(169.4,84.78)
  TOP w0.406: v3(188.91,25.58) 189.09,25.4 189.09,22.7 v1(187.47,21.08) 187.2,20.8 PR622.1
  IN1 w0.406: v3(169.4,84.78) 169.4,84.54 169.57,84.37 169.57,83.49 168.85,82.77 167.64,82.77 167.5,82.91 158.9,82.91 155.15,79.16 148.05,79.16 146.57,77.69 146.57,67.98 145.02,66.43 145.02,59.87 147.45,57.44 148.67,57.44 148.81,57.3 151.26,57.3 153.02,55.54 153.02,54.45 154.93,52.54 156.05,52.54 160.62,47.97 164.77,47.97 166.65,46.09 166.65,35.07 167.79,33.92 168.93,33.92 170.86,31.99 171.92,31.99 172.5,31.41 172.81,31.41 173.66,30.56 173.66,28.92 174.37,28.21 174.37,27.85 174.72,27.51 176.43,27.51 177.55,26.39 177.95,26.39 180.02,24.32 186.41,24.32 187.73,25.64 188.85,25.64 v3(188.91,25.58)
  BOTTOM w0.254: UV1.AW23 v3(169.4,84.78)
+EC_VCCA: length 5.1
  TOP w0.127: LE1.2 275.54,7.65 v1(275.15,7.65)
  TOP w0.203: UE5.67 276.8,10.7 276.66,10.56 CE33.1
  TOP w0.508: CE33.1 276.66,9.4 276.61,9.35 LE1.2
+FB_PLLAVDD: length 98
  TOP w0.127: v3(164.38,67.03) 164.28,66.93 v2(163.63,66.93)
  TOP w0.508: CV364.1 177.17,97.35 v3(177.2,97.38) ; CV367.1 183.01,76.39 v3(182.8,76.18) ; CV366.1 190.12,86.79 190.5,87.18 v3(190.6,87.18) 190.6,87.33 190.19,87.74 CV365.1
  IN2 w0.508: v3(177.2,97.38) 178.63,95.95 187.49,95.95 188.33,96.79 189.69,96.79 v3(190.5,95.98) 189.13,94.6 189.13,88.03 189.68,87.48 190.3,87.48 v3(190.6,87.18) 190.54,87.18 189.13,85.76 189.13,78.09 188.39,77.35 183.97,77.35 v3(182.8,76.18) 182.8,76.41 182.25,76.96 181.4,76.96 180.86,77.5 171.62,77.5 170.07,79.05 170.07,80.41 169.7,80.77 169.7,82.01 168.63,83.07 164.87,83.07 164.54,82.74 164.54,81.42 165.79,80.18 165.79,74.37 165.01,73.6 165.01,67.36 164.68,67.03 v3(164.38,67.03)
  BOTTOM w0.254: v3(190.5,95.98) 190.9,95.58 UV1.L36
  BOTTOM w0.35: UV1.AJ39 v3(177.2,97.38) ; UV1.AA11 v3(182.8,76.18) ; UV1.L26 v3(190.6,87.18)
  BOTTOM w0.508: v3(164.38,67.03) 163.63,67.03 163.01,66.41 158.16,66.41 CV148.1 157.64,64.08 LV14.1
+FBA_VREFC: length 52.7
  TOP w0.254: UV6.J14 165.05,121.08 164.41,120.44 v3(163.36,120.44)
  TOP w0.508: v3(160.83,131.07) 160.8,131.1 RV189.2 160.53,131.73 159.7,131.73 159.67,131.76 RV196.1 RV194.2
  IN2 w0.089: 176.92,122.4 v3(176.91,122.39)
  IN2 w0.508: v3(160.57,121.49) 161.09,121.49 161.98,122.38 161.98,123.29 162.55,123.87 162.55,126.88 160.64,128.78 160.64,130.88 v3(160.83,131.07) 161.43,131.66 164.04,131.66 164.44,131.26 166.92,131.26 167.52,131.85 168.19,131.85 169.46,130.58 173.52,130.58 174.17,129.94 176.98,129.94 177.24,129.67 177.24,122.72 176.92,122.4
  IN3 w0.508: v3(160.57,121.49) 162.31,121.49 v3(163.36,120.44)
  BOTTOM w0.089: 176.92,122.4 v3(176.91,122.39)
  BOTTOM w0.127: v3(160.57,121.49) v1(159.84,121.49)
  BOTTOM w0.254: v3(176.91,122.39) 176.91,121.78 UV7.J14
  BOTTOM w0.508: v3(160.57,121.49) 160.59,121.46 CV303.1 ; 176.92,122.4 177.87,122.4 178.32,122.85 CV301.1
+FBA_VREFD: length 54.9
  TOP w0.254: UV6.U10 169.41,127.88 CV302.1 ; v3(169.41,115.08) 169.41,115.08 UV6.A10
  TOP w0.508: v3(168.68,129.8) 168.55,129.93 RV190.1 CV302.1 ; RV193.2 161,128.25 v1(161.23,128.01) 162,127.24 RV195.2 163.14,127.24 v3(163.26,127.36)
  IN2 w0.508: v3(171.96,121.25) 171.96,121.63 172.4,122.07 172.72,122.07 173.17,122.52 173.17,124.55 172.85,124.87 172.4,124.87 171.86,125.41 171.86,127.13 v3(172.61,127.88)
  IN3 w0.508: v3(163.26,127.36) 163.26,128.2 163.83,128.77 164.9,128.77 165.94,129.81 166.93,129.81 167.55,130.43 168.05,130.43 v3(168.68,129.8)
  IN4 w0.508: v3(172.6,129.88) 172.35,129.88 171.66,129.19 169.29,129.19 v3(168.68,129.8) ; v3(169.41,115.08) 169.85,115.08 170.43,115.66 170.43,121.83 170.04,122.21 170.04,124.52 171.69,126.17 171.69,126.96 v3(172.61,127.88)
  BOTTOM w0.254: UV7.U10 v3(172.61,127.88) ; UV7.A10 173.01,114.84 172.17,115.68 172.17,117.8 171.83,118.14 171.83,121.12 v3(171.96,121.25)
  BOTTOM w0.508: CV304.1 172.6,130.17 v3(172.6,129.88) 172.71,129.77 172.71,127.98 v3(172.61,127.88)
+FBB_VREFC: length 15.7
  TOP w0.254: UV8.J14 194.59,121.08 v3(194.76,121.25)
  TOP w0.508: v3(194.76,121.25) 195.23,121.72 195.37,121.72 197.89,124.25 v1(197.89,124.97) 197.89,125.87 197.36,126.41 197.36,127.47 197.56,127.67 CV305.1 RV202.1 198.58,127.68 RV197.2 RV200.2
  BOTTOM w0.254: UV8.J14 194.59,121.08 v3(194.76,121.25)
  BOTTOM w0.508: CV307.1 196.74,123.24 v3(194.76,121.25)
+FBB_VREFD: length 46.1
  TOP w0.254: v3(190.57,127.87) 190.96,127.48 UV8.A10 ; v3(191.45,114.3) 191.07,114.68 UV8.U10
  TOP w0.508: v3(192.59,130.05) 192.55,130.09 CV308.1 ; RV199.2 RV201.2 201.3,129.8 v3(200.87,130.23) ; RV198.1 v3(194.33,130.05)
  IN3 w0.508: v3(200.87,130.23) 200.47,129.83 198.35,129.83 197.39,130.8 194.83,130.8 194.33,130.3 v3(194.33,130.05)
  IN4 w0.381: v3(191.45,114.3) 190.46,114.3 189.23,115.53 189.23,116.87 188.03,118.07 188.03,121.76 187.71,122.07 187.71,122.61 188.31,123.21 188.31,123.55 188.92,124.16 188.92,128.82 187.68,130.05 187.68,130.98 188.1,131.4 191.24,131.4 v3(192.59,130.05)
  IN6 w0.508: v3(190.57,127.87) 190.57,128.56 190.88,128.87 192.31,128.87 192.59,129.15 ; 192.59,129.15 193.43,129.15 v3(194.33,130.05) ; 192.59,129.15 v3(192.59,130.05)
  BOTTOM w0.127: v1(193.59,130.67) 193.57,130.69 CV306.1
  BOTTOM w0.254: v3(191.45,114.3) 191.07,114.68 UV8.U10 ; UV8.A10 190.96,127.48 v3(190.57,127.87)
  BOTTOM w0.508: CV306.1 192.55,130.09 v3(192.59,130.05)
+FBC_VREFC: length 11.2
  TOP w0.254: v3(219.51,98.47) 219.91,98.07 UV12.J14
  BOTTOM w0.127: v1(215.41,105.02) 215.13,104.74 CV179.1
  BOTTOM w0.254: UV12.J14 219.91,98.07 v3(219.51,98.47)
  BOTTOM w0.508: v3(219.51,98.47) 216.53,101.45 CV300.1 ; CV300.1 RV143.2 ; CV300.1 RV145.1 RV164.2 215.67,103.08 215.13,103.62 CV179.1
+FBC_VREFD: length 41.5
  TOP w0.254: v3(213.91,94.36) UV12.A10 ; UV12.U10 v3(225.91,94.36)
  TOP w0.508: CV178.1 228.88,95.51 v3(228.86,95.52) 228.32,95.52 v1(228.23,95.42) 228.22,95.42 226.87,94.08 226.18,94.08 v3(225.91,94.36)
  IN2 w0.508: v3(212.97,103.15) 212.97,103.47 212.53,103.91 209.77,103.91 209.2,103.34 209.2,95.56 210.4,94.36 v3(213.91,94.36) 213.91,94.16 214.38,93.69 217.49,93.69 219.33,91.85 220.79,91.85 222.32,93.37 225.05,93.37 225.91,94.24 v3(225.91,94.36)
  BOTTOM w0.254: UV12.A10 v3(213.91,94.36) ; UV12.U10 v3(225.91,94.36)
  BOTTOM w0.508: v3(228.86,95.52) 228.88,95.5 CV299.1 229.54,95.51 RV158.1 ; RV142.2 RV144.2 v3(212.97,103.15)
+FBD_VREFC: length 39
  TOP w0.127: CV311.1 219.48,65.55 v1(218.98,65.55)
  TOP w0.254: UV15.J14 219.91,80.24 v3(219.6,80.54)
  TOP w0.508: v3(219.43,66.99) 220.1,66.32 CV311.1
  IN4 w0.508: v3(219.43,66.99) 220.54,65.88 226,65.88 228,67.88 228,77.38 228.22,77.6 228.22,79.08 225.45,81.85 222.38,81.85 222.16,81.63 220.7,81.63 v3(219.6,80.54)
  BOTTOM w0.254: UV15.J14 219.91,80.24 v3(219.6,80.54)
  BOTTOM w0.508: RV203.2 RV206.2 RV209.1 CV309.1 219.07,66.63 v3(219.43,66.99)
+FBD_VREFD: length 46.4
  TOP w0.127: v3(221.3,61.69) v1(221.92,61.69)
  TOP w0.254: v3(225.91,76.32) UV15.U10 ; v3(213.91,76.32) UV15.A10
  IN6 w0.508: v3(221.3,61.69) 224.62,61.69 227.78,64.85 227.78,73.46 226.48,74.76 226.48,75.9 226.05,76.32 v3(225.91,76.32) 225.91,76.18 224.63,74.89 215.2,74.89 213.91,76.19 v3(213.91,76.32)
  BOTTOM w0.254: v3(225.91,76.32) UV15.U10 ; UV15.A10 v3(213.91,76.32)
  BOTTOM w0.508: v3(221.3,61.69) 219.71,61.69 219.07,62.33 RV213.1 CV310.1 RV205.2 RV207.2 ; CV312.1 226.26,75.97 v3(225.91,76.32)
+GVDD: length 2.5
  BOTTOM w0.127: v1(7.43,35.92) 7.43,33.39
+HDMI_5V_OUT: length 1
  TOP w0.127: v2(135.32,135.52) 135.08,135.77 v3(135.08,136.46)
  vias: v3(135.47,136.9) v3(136.11,136.9)
+INV_PWR_SRC: length 9.4
  TOP w0.127: v2(81.52,116.4) 81.52,116.94 81.89,117.31
  TOP w1.524: 88.9,123.41 88.46,123.85 83.64,123.85 82.76,122.96 82.76,121.29
+LAN_IO: length 81.1
  TOP w0.203: CL16.1 322.52,34.37 321.68,34.37 321.51,34.2 UL1.16
  TOP w0.508: v3(323.66,35.33) 323.6,35.33 323.14,34.88 CL17.1 ; CL16.1 322.89,33.49 v3(322.52,33.49) ; RL8.2 v3(320.61,87.51) 320.61,78.72 RL14.1 ; LL1.1 326.23,73.58 v3(326.97,74.32)
  IN4 w0.508: v3(320.61,87.51) 320.61,87.91 321.02,88.32 322.49,88.32 323.79,87.02 323.79,78 326.97,74.82 v3(326.97,74.32) 323.85,71.2 323.85,61.94 324.93,60.86 324.93,54.07 323.53,52.67 323.53,48.35 321.16,45.98 321.16,40.63 323.71,38.08 325.02,38.08 326.27,36.83 326.27,36.1
  vias: v2(311.99,26.48) v3(313.82,29.75) v3(314.84,29.81) v3(325.82,35.27) v3(325.82,34.57) v3(326.47,34.56)
+LCDVDD: length 0.6
  BOTTOM w0.127: 83.83,122.82 v2(83.39,123.27)
+LCDVDD_CONN: length 1
  BOTTOM w0.127: 89.04,121.21 89.37,121.21 v1(89.85,120.73)
  vias: v3(87.82,121.44) v3(87.82,120.86) v3(87.82,120.27) v3(95.98,125.96) v3(95.98,125.36) v3(96.45,125.01)
+PAVDD:
  vias: v2(8.32,22.74)
+PCH_DCPRTC: length 1.8
  TOP w0.089: CH49.1 224.74,34.06 v1(225.44,34.06)
  TOP w0.508: CH49.1 224.51,34.44 v3(224.51,35)
+PCH_USB_DCPSUS2: length 7.2
  TOP w0.305: v3(222.84,43.63) 222.38,44.09 222.38,45.89 222.28,45.99 222.28,46.69 CH53.1 222.65,49.57 RH142.2
  BOTTOM w0.089: UH1.Y35 222.59,43.38 v3(222.84,43.63)
+PCH_VCC: length 16.8
  TOP w0.508: CH71.1 216.46,48.12 v3(216.46,48.82) 216.46,49.29 215.97,49.79 v2(214.67,49.79) 211.66,49.79 211.03,50.42 211.03,55.12 CH70.1 213.51,57.61 RH150.2
  BOTTOM w0.254: v3(216.46,48.82) 216.46,48.25 216.6,48.11 UH1.AP45
+PCH_VCCCFUSE: length 17.4
  TOP w0.508: CH65.1 224.67,37.07 224.67,36.92 224.49,36.74 v3(224.49,36.63)
  IN4 w0.254: v3(237.97,34.08) 237.33,33.43 235.76,33.43 235.6,33.6 232.2,33.6 231.66,33.06 230.28,33.06 229.2,34.14 225.44,34.14 224.98,34.6 224.98,35.24 224.49,35.73 v3(224.49,36.63)
  vias: v1(236.96,33.96)
+PCH_VCCCLK: length 7.4
  TOP w0.508: RH147.2 220.31,52.53 v2(219.1,51.32) 219.1,49.27
  vias: v3(219.92,41.48) v3(220.31,44.25) v3(221.81,42.42) v3(221.88,41.49)
+PCH_VCCCLK3_3:
  vias: v2(226.38,40.48) v3(223.85,41.52) v3(225.78,40.16) v3(225.82,41.11) v3(226.41,41.15)
+PCH_VCCDSW: length 14.3
  TOP w0.127: v1(229.71,25.91) 229.78,25.84 v3(229.78,25.35)
  TOP w0.508: RH140.2 229.5,25.07 v3(229.78,25.35)
  IN2 w0.254: v3(229.78,25.35) 229.78,27.3 228.03,29.05 226.57,29.05 225.36,30.26 225.36,31.9 224.27,33 224.27,33.45 223.95,33.77 v3(223.79,33.77)
  BOTTOM w0.254: v3(223.79,33.77) 223.79,34.33 UH1.U14
+PCH_VCCDSW3_3: length 52.5
  TOP w0.457: v3(221.24,19.33) 221.48,19.09 RH36.1
  TOP w0.508: v3(230.81,35.31) 230.33,35.31 CH38.1 ; v3(238.95,15.23) 238.95,15.46 v1(238.51,15.9) RH152.2 ; v3(229.48,16.35) 229.58,16.25 RH156.2 RH58.1 ; RH141.2 233.85,34.2 v3(233.85,34.74) 233.85,35.24 RH145.2
  IN1 w0.508: v3(233.85,34.74) 233.59,34.99 231.13,34.99 v3(230.81,35.31)
  IN2 w0.508: v3(233.85,34.74) 233.57,34.74 231.95,33.12 231.95,28.54 230.94,27.52 230.94,24.94 230.49,24.5 230.49,23.26 227.64,20.41 v3(227.64,20.16)
  IN3 w0.508: v3(227.64,20.16) 225.92,18.44 221.81,18.44 221.24,19.01 v3(221.24,19.33)
  IN6 w0.508: v3(229.48,16.35) 229.48,17.25 227.64,19.08 v3(227.64,20.16)
  BOTTOM w0.254: UH1.A16 230.58,35.54 v3(230.81,35.31)
  BOTTOM w0.508: v3(238.95,15.23) 238.95,15.64 237.81,16.78 234.53,16.78 233.66,15.9 229.92,15.9 v3(229.48,16.35)
+PCH_VCCDSW_R: length 3.1
  TOP w0.127: v1(228.73,20.89) 228.73,22 CH37.1
  TOP w0.508: RH140.1 CH37.1
+PCH_VCCSST: length 1.2
  TOP w0.508: v3(221.24,35) 221.24,34.51 CH42.1
  BOTTOM w0.254: v3(221.24,35) 221.55,34.68 UH1.AA14
+PCH_VPROC: length 49.3
  TOP w0.127: v2(213.76,54.05) 214.37,54.05 v3(214.54,54.23)
  TOP w0.457: CH55.1 218.93,34.39 CH56.1 ; CH56.1 218.27,33.81 v3(218.32,33.76) ; CH56.1 218.47,34.58 218.47,35.26 218.06,35.66 CH57.1
  TOP w0.508: v3(214.54,54.23) 214.54,55.09 214.73,55.29 RH146.1
  IN4 w0.254: 212.77,34.19 217.89,34.19 v3(218.32,33.76)
  IN4 w0.508: 212.77,34.19 212.38,33.81 210.57,33.81 209.55,34.83 v3(203.9,34.83)
  BOTTOM w0.508: v3(203.9,34.83) 202.95,35.78 202.95,45.87 207.56,50.48 207.56,52.78 209.01,54.23 v3(214.54,54.23)
+RBIAS: length 6.4
  TOP w0.127: RL3.1 323.66,31.85 325.16,31.85 v1(325.68,31.33)
  TOP w0.203: UL1.10 320.25,31.16 320.45,30.96 321.07,30.96 321.25,31.14 322.95,31.14 RL3.1
+RTC_CELL: length 309.7
  TOP w0.127: v3(10.33,6.01) 6.31,6.01 RA123.1 ; v3(240.63,7.88) 240.13,8.37 v2(240.13,10) 240.13,12.77 240.67,13.3 240.67,17.73 239.71,18.68 v3(239.71,21.05)
  TOP w0.508: v3(230.91,31.34) 230.91,30.7 230.43,30.22 CH50.1 230.57,29.89 230.99,29.89 231.57,29.3 CH51.1 231.57,28.47 CH52.1 231.87,27.29 233,26.16 235.23,26.16 235.74,25.66 v3(235.74,25.43)
  IN1 w0.127: v3(70.49,9.62) 70.36,9.49 69.53,9.49 68.53,8.48 68.43,7.98 68.39,7.9 68.22,7.48 67.92,7.04 67.54,6.66 67.09,6.36 66.6,6.15 66.07,6.05 65.53,6.05 65,6.15 64.51,6.36 64.38,6.44 64.38,6.44 64.06,6.66 63.68,7.04 63.46,7.36 63.22,7.6 63.11,7.76 62.79,8.09 62.62,8.2 62.16,8.66 59.37,8.66 58.8,9.23 57.28,9.23 56.65,8.61 30.48,8.61 29.07,7.2 v3(29.07,6.88)
  IN2 w0.127: v3(70.49,9.62) 72.73,11.86 110.67,11.86 111.03,11.51 132,11.51 132.26,11.25 141.89,11.25 142.23,11.6 144.48,11.6 144.93,12.05 145.54,12.05 147.47,10.12 149.1,10.12 153.46,5.76 193.12,5.76 198.04,10.68 202.37,10.68 203.23,9.82 206.34,9.82 210.54,5.62 238.36,5.62 v3(240.63,7.88)
  IN4 w0.091: v3(29.07,6.88) 29.07,5.97 28.79,5.69 27.92,5.69 27.7,5.91 27.7,6.08 27.21,6.57 20.89,6.57 19.64,7.83 16.4,7.83 16.21,8.02 12.33,8.02 v3(10.33,6.01)
  IN4 w0.508: v3(239.71,21.05) 239.54,21.22 237.72,21.22 236.68,22.27 236.68,24.93 236.18,25.43 v3(235.74,25.43)
  BOTTOM w0.254: UH1.A6 230.69,31.56 v3(230.91,31.34)
  BOTTOM w0.508: v3(239.71,21.05) 239.71,17.49 241.47,15.74 PD5.1 ; RH12.1 v3(235.59,27.33) ; RH3.1 RH65.2 v3(235.74,25.43) ; v3(235.63,28.26) 235.23,28.26 RH13.1 ; RH15.1 v3(235.65,29.76)
+SA_DIMM_VREFDQ: length 82.5
  IN3 w0.508: v3(78.81,42.06) 80.67,43.93 83.24,43.93 84.75,42.42 89.21,42.42 94.11,47.32 94.11,63.81 99.25,68.95 102.55,68.95 103.44,69.85 103.44,74.26 102.63,75.07 102.63,79.16 103.06,79.59 123.91,79.59 v3(124.29,79.98)
  BOTTOM w0.254: CPU1.AR6 124.72,79.55 v3(124.29,79.98)
  BOTTOM w0.508: RD6.1 C9.1 80.22,42.78 79.5,42.06 v3(78.81,42.06)
+SB_DIMM_VREFDQ: length 112.8
  TOP w0.508: CD38.1 RD12.1 73.36,22.49 73.05,22.8 73.05,25.12 73.87,25.94 74.84,25.94 75.59,26.68 v2(75.59,29.67) 75.59,35.8 76.27,36.48 76.27,46.66 v3(75.27,47.65)
  IN3 w0.508: v3(75.27,47.65) 77.98,44.95 83.67,44.95 85.18,43.44 88.79,43.44 93.09,47.74 93.09,64.23 98.83,69.97 102.13,69.97 102.83,70.68 102.83,74.01 101.98,74.86 101.98,78.26 101.35,78.89 101.35,79.47 102.08,80.2 123.65,80.2 124.06,80.61 124.29,80.61 v3(124.42,80.74)
  BOTTOM w0.254: CPU1.AN6 124.72,80.44 v3(124.42,80.74)
+SM_VREF: length 41.5
  TOP w0.127: v2(128.58,47.27) v3(128.02,47.27)
  IN3 w0.508: v3(128.02,47.27) 128.02,64.54 131.08,67.6 131.08,79.83 130.18,80.74 128.59,80.74
  BOTTOM w0.254: CPU1.AM6 124.72,81.08 v3(125.07,80.73)
  BOTTOM w0.508: v3(128.02,47.27) 127.52,47.77 CD21.1 RD2.1
+USB3_VCCA: length 0.6
  TOP w0.127: v2(325.63,59.01) v3(325.63,58.36)
+USB3_VCCB: length 0.6
  TOP w0.127: v2(324.73,44.25) v3(324.73,43.61)
+V_TP: length 5.3
  BOTTOM w0.127: v1(196.47,129.94) 196.8,130.27 RT5.2
  BOTTOM w0.508: UT1.5 197.88,132.87 RT4.2 198.08,131.78 RT6.1 RT5.2
+VCOMP_OUT: length 0.6
  BOTTOM w0.254: CPU1.AK6 124.72,82.71 v3(125.07,82.36)
  vias: v2(132.76,82.32)
+VGA_CORE: length 37.9
  TOP w0.508: PR629.1 185.74,22.6 187.56,24.41 187.56,25.72 188.28,26.44 189.42,26.44 v3(189.8,26.82)
  IN4 w0.508: v3(197.93,50.01) 198.66,50.01 200.74,47.93 200.74,34.71 192.85,26.82 v3(189.8,26.82)
  vias: v2(198.01,51.77) v3(161.2,100.78) v3(162,101.58) v3(162,100.78) v3(162.8,103.98) v3(162.8,103.18) v3(163.6,100.78) v3(166,104.78) v3(166,103.98) v3(166.8,103.18) v3(167.9,101.6) v3(168.4,99.98) v3(169.23,101.6) v3(169.2,100.78) v3(169.2,99.98) v3(169.2,99.18) v3(169.67,53.37) v3(170,101.58) v3(170,99.98) v3(170,99.18) v3(170.12,53.88) v3(170.44,53.37) v3(170.8,99.18) v3(170.8,98.38) v3(170.82,53.88) v3(171.2,53.37) v3(171.5,95.28) v3(171.5,94.28) v3(171.5,92.28) v3(171.5,90.28) v3(171.5,88.28) v3(171.5,86.28) v3(171.5,84.28) v3(171.5,82.28) v3(171.5,80.28) v3(171.5,78.42) v3(171.58,66.97) v3(171.58,53.88) v3(171.96,53.37) v3(172.02,62.57) v3(172.02,55.97) v3(172.02,55.34) v3(172.28,56.54) v3(172.28,54.76) v3(172.28,53.88) v3(172.37,63.08) v3(172.32,62.04) v3(172.3,61.43) v3(172.3,60.73) v3(172.5,95.28) v3(172.5,91.28) v3(172.5,85.28) v3(172.5,79.28) v3(172.66,62.57) v3(172.66,56.99) v3(172.66,56.1) v3(172.66,55.21) v3(172.66,54.32) v3(172.72,53.37) v3(173.04,56.54) v3(173.04,55.65) v3(173.04,54.76) v3(173.04,53.88) v3(173.1,63.08) v3(173.42,56.99) v3(173.42,56.1) v3(173.42,55.21) v3(173.42,54.32) v3(173.42,53.37) v3(173.5,94.28) v3(173.5,92.28) v3(173.5,90.28) v3(173.5,88.28) v3(173.5,86.28) v3(173.5,84.28) v3(173.5,82.28) v3(173.5,80.28) v3(173.5,78.28) v3(173.74,63.08) v3(173.8,56.54) v3(173.8,55.65) v3(173.8,54.76) v3(173.8,53.88) v3(174.06,62.57) v3(174.18,56.99) v3(174.18,56.1) v3(174.18,55.21) v3(174.18,54.32) v3(174.18,53.37) v3(174.37,63.08) v3(174.45,85.33) v3(174.5,95.28) v3(174.5,91.28) v3(174.5,83.28) v3(174.5,81.28) v3(174.5,79.28) v3(174.56,56.54) v3(174.56,55.65) v3(174.56,54.76) v3(174.56,53.88) v3(174.69,62.57) v3(174.94,56.99) v3(174.94,56.1) v3(174.94,55.21) v3(174.94,54.32) v3(174.94,53.37) v3(175.01,63.08) v3(175.33,62.57) v3(175.33,53.88) v3(175.5,94.28) v3(175.5,90.28) v3(175.5,88.28) v3(175.5,86.28) v3(175.5,78.1) v3(175.64,63.08) v3(175.71,53.37) v3(175.96,62.57) v3(176.09,53.88) v3(176.28,63.08) v3(176.47,53.37) v3(176.5,95.28) v3(176.5,93.28) v3(176.5,87.28) v3(176.5,85.28) v3(176.6,62.57) v3(176.6,61.94) v3(176.6,60.92) v3(176.79,53.88) v3(176.91,61.43) v3(176.91,60.42) v3(177.23,62.57) v3(177.23,61.94) v3(177.23,60.92) v3(177.23,53.37) v3(177.5,92.28) v3(177.5,90.28) v3(177.5,84.28) v3(177.5,82.28) v3(177.5,80.28) v3(177.5,78.28) v3(177.55,61.43) v3(177.55,60.42) v3(177.55,53.88) v3(177.87,60.92) v3(177.93,53.37) v3(178,76.27) v3(178.18,61.43) v3(178.18,60.42) v3(178.31,56.8) v3(178.31,56.16) v3(178.31,55.53) v3(178.31,54.89) v3(178.31,53.88) v3(178.5,95.28) v3(178.5,93.28) v3(178.5,91.28) v3(178.5,89.28) v3(178.5,87.28) v3(178.5,85.28) v3(178.5,83.28) v3(178.54,81.26) v3(178.5,79.28) v3(178.5,60.92) v3(178.63,54.38) v3(178.69,53.37) v3(178.82,60.42) v3(179.2,52.67) v3(179.2,50.23) v3(179.45,53.37) v3(179.5,88.28) v3(179.5,86.28) v3(179.5,84.28) v3(179.5,78.28) v3(180.22,53.37) v3(180.45,95.38) v3(181.13,53.11) v3(181.5,94.28) v3(181.5,92.28) v3(181.5,90.28) v3(181.5,88.28) v3(181.5,86.28) v3(181.5,84.28) v3(181.5,82.28) v3(181.5,80.28) v3(181.5,78.18) v3(181.7,53.7) v3(181.76,53.11) v3(181.93,56.16) v3(181.93,55.27) v3(181.93,54.26) v3(182.31,56.67) v3(182.31,55.72) v3(182.31,54.83) v3(182.34,53.81) v3(182.36,53.19) v3(182.5,95.28) v3(182.5,93.28) v3(182.5,91.28) v3(182.5,89.28) v3(182.5,87.28) v3(182.5,85.28) v3(182.5,83.28) v3(182.5,81.28) v3(182.5,79.28) v3(182.69,56.16) v3(182.69,55.27) v3(182.69,54.38) v3(182.92,53.37) v3(183.07,56.67) v3(183.07,55.72) v3(183.07,54.83) v3(183.07,53.94) v3(183.45,56.16) v3(183.45,55.27) v3(183.45,54.38) v3(183.5,94.28) v3(183.5,78.28) v3(183.52,53.38) v3(183.83,56.67) v3(183.83,55.72) v3(183.83,54.83) v3(183.83,53.88) v3(184.15,53.37) v3(184.22,56.16) v3(184.22,55.27) v3(184.22,54.38) v3(184.5,95.28) v3(184.5,87.28) v3(184.5,85.28) v3(184.5,83.28) v3(184.5,81.28) v3(184.5,79.28) v3(184.53,53.88) v3(184.6,56.67) v3(184.6,55.72) v3(184.6,54.83) v3(184.74,53.3) v3(184.98,56.16) v3(184.98,55.27) v3(185.03,54.43) v3(185.17,53.84) v3(185.33,53.25) v3(185.5,94.28) v3(185.5,92.28) v3(185.5,90.28) v3(185.5,86.28) v3(185.5,80.28) v3(185.5,78.28) v3(185.74,54.07) v3(185.93,53.49) v3(186.37,54.07) v3(186.5,95.28) v3(186.5,93.28) v3(186.5,91.28) v3(186.5,89.28) v3(186.5,87.28) v3(186.5,85.28) v3(186.5,83.28) v3(186.5,81.28) v3(186.5,79.28) v3(186.69,53.56) v3(187.01,54.07) v3(187.29,53.49) v3(187.5,94.28) v3(187.5,88.28) v3(187.5,82.28) v3(187.5,78.28) v3(187.64,54.07) v3(187.89,53.48) v3(188.26,54.38) v3(188.38,53.8) v3(188.5,95.28) v3(188.5,93.28) v3(188.5,91.28) v3(188.5,89.28) v3(188.5,87.28) v3(188.5,85.28) v3(188.5,83.28) v3(188.5,81.28) v3(188.5,79.28) v3(188.85,54.35) v3(189.11,53.81) v3(189.49,54.35) v3(189.87,53.81) v3(190.25,54.26) v3(190.63,53.81) v3(191.01,54.26) v3(191.16,53.24) v3(191.39,53.81) v3(191.76,54.31) v3(191.76,53.35) v3(191.85,52.33) v3(192.15,53.88) v3(192.1,52.86) v3(192.43,54.41) v3(192.45,53.37) v3(192.43,52.29) v3(192.76,53.91) v3(192.74,52.86) v3(193.04,54.43) v3(193.08,53.38) v3(193.03,52.35) v3(193.35,53.91) v3(193.36,52.86) v3(193.68,53.43) v3(193.61,52.29) v3(193.93,54.13)
+VREF_CA: length 99.6
  TOP w0.508: C15.1 100.85,14.81 C14.1 100.9,15.65 v3(101.41,16.16) ; v3(120.96,28.41) 120.96,26.62 119.32,24.98 119.32,17.68 v2(118.94,17.3) 118.55,16.91 v3(118.55,16.21)
  IN2 w0.508: v3(118.55,16.21) 118.55,16.49 118.19,16.85 102.11,16.85 v3(101.41,16.16)
  IN6 w0.508: v3(140.83,48.57) 142.56,46.84 142.56,40.29 143.13,39.71 143.13,36.35 142.56,35.78 142.56,32.03 141.1,30.57 123.36,30.57 121.2,28.41 v3(120.96,28.41)
  BOTTOM w0.356: JDIMM2.126 v3(118.55,16.21) ; v3(120.96,28.41) 119.45,28.41 118.55,29.31 JDIMM1.126
  BOTTOM w0.508: v3(140.83,48.57) 135.54,48.57 132.32,45.35 RD2.2 125.97,45.43 CD20.1 123.97,45.43 RD3.2 CD19.1 121.88,45.35 RD1.1
+VREF_DQ_DIMMA: length 14.2
  BOTTOM w0.127: v1(84.46,41.99) 84.77,42.31 RD5.1
  BOTTOM w0.356: JDIMM1.1 78.65,39.81 77.79,40.67 77.79,41.15
  BOTTOM w0.508: 77.79,41.15 77.79,42.52 79.12,43.86 79.3,43.86 80.06,44.62 RD6.2 RD9.2 CD2.1 82.6,44.54 CD1.1 83.77,44.54 84.61,43.7 RD5.1
+VREF_DQ_DIMMB: length 19.6
  TOP w0.127: v1(75.96,23.13) v3(76.44,23.6)
  TOP w0.508: v3(75.06,15.2) 74.87,15.39 CD24.1 ; v3(76.44,23.6) 76.44,23.61 RD11.1 76.32,24.54 74.92,24.54 CD25.1 RD13.2 RD12.2
  BOTTOM w0.381: JDIMM2.1 78.65,25.05 78.39,24.8 77.63,24.8 v3(76.44,23.6)
  BOTTOM w0.508: v3(76.44,23.6) 75.59,22.76 75.59,20.34 76.65,19.28 76.65,17.05 75.06,15.46 v3(75.06,15.2)
A52_B52: length 0.7
  BOTTOM w0.089: CPU1.A52 CPU1.B52
A53_B53: length 5.2
  BOTTOM w0.089: 91.8,103.47 91.8,102.73 92.46,102.07 CPU1.A53 CPU1.B53
  BOTTOM w0.127: 91.8,103.47 91.8,105.67 v1(91.82,105.69)
AC/DC: length 5.5
  TOP w0.254: RA101.1 22.71,6.16 22.96,5.91 v3(22.96,5.78)
  IN1 w0.254: v3(22.96,5.78) 23.71,5.78 24.82,6.89 v3(24.82,9.3)
AC_BATT#: length 40.7
  TOP w0.089: 166.84,69.65 167.31,69.18 168.77,69.18 v3(169.19,69.59)
  TOP w0.127: 166.84,69.65 159.67,69.65 v2(158.9,68.89) 158.76,68.75 154.38,68.75 v3(154.31,68.67) 153.98,68.67 RV61.2
  IN6 w0.099: v3(154.31,68.67) 153.62,69.36 151.37,69.36 148.49,72.24 148.49,74.23 143.28,79.44 v3(143.28,80.52)
  BOTTOM w0.089: UV1.AV4 169.57,69.98 v3(169.19,69.59)
  BOTTOM w0.127: UV19.4 139.06,80.17 139.22,80.01 RV93.1 140.07,80 140.54,79.53 142.29,79.53 v3(143.28,80.52)
ACDET_CHG: length 4.2
  TOP w0.203: PR716.2 v1(39.5,36.45) 40.18,36.45 40.33,36.59 PU700.6
  TOP w0.254: PR719.1 37.53,35.57 PC719.1 38.39,36.43 PR716.2
ACDRV_CHG: length 5.5
  TOP w0.203: PR705.2 37.1,38.76 38.71,38.76 39.13,38.34 v3(39.13,37.61) 39.34,37.39 PU700.4
ACIN: length 373.4
  TOP w0.127: v3(295.2,18.16) 294.98,18.38 CE40.2 294.55,19.74 292.28,19.74 291.19,18.65 UE5.110 ; v1(241.74,15.92) DH1.1 242.46,17.68 v3(242.88,18.1)
  TOP w0.203: PR715.1 38.72,36.99 v3(39.12,36.99) PU700.5
  TOP w0.254: PR715.1 38.4,38.2 PR714.2 ; v3(59.07,49.62) 59.27,49.62 PR731.1
  IN2 w0.099: 59.08,49.62 58.32,48.86 54.13,48.86 52.56,47.29 51.28,47.29 50.39,46.41 49.78,46.41 48.33,44.96 47.02,44.96 44.84,42.78 42.47,42.78 40.38,40.69 40.38,37.73 39.64,36.99 v3(39.12,36.99) ; 59.08,49.62 v3(59.07,49.62) ; 59.08,49.62 62.11,49.62 64.16,47.56 68.71,47.56 78.44,37.83 78.74,37.83 79.44,37.13 79.44,33.57 82.69,30.32 129.03,30.32 132.72,26.63 142.92,26.63 144.54,25.01 148.47,25.01 v3(149.13,24.35) 149.94,23.54 151.14,23.54 153.98,20.7 164.68,20.7 165.67,19.71 172.52,19.71 173.15,19.08 179.92,19.08 180.27,18.73 182.7,18.73 183.26,19.29 191.07,19.29 191.23,19.45 199.39,19.45 204.33,24.39 v3(206.44,24.39) ; v3(268.01,16.8) 268.44,17.24 278.47,17.24 280.27,19.03 285.27,19.03 285.69,18.61 294.76,18.61 v3(295.2,18.16)
  IN4 w0.091: v3(140.34,82.32) 135.59,77.57 135.59,67.82 136.81,66.6 136.81,45.03 141.97,39.87 141.97,32.43 142.9,31.5 142.9,29.1 143.25,28.75 144.15,28.75 147.69,25.21 148.26,25.21 v3(149.13,24.35) ; v3(242.88,18.1) 242.21,18.77 240.29,18.77 238.98,20.08 236.29,20.08 236.04,19.84 234.63,19.84 234.39,20.08 234.39,23.54 233.88,24.04 230.86,24.04 230.08,23.27 228.59,23.27 227.94,23.92 206.91,23.92 v3(206.44,24.39)
  IN6 w0.099: v3(268.01,16.8) 267.64,17.17 263.37,17.17 262.3,16.09 244.89,16.09 v3(242.88,18.1)
  BOTTOM w0.127: v3(140.34,82.32) 140.34,82.33 UV19.1 ; v3(268.01,16.8) 268.95,17.74 270.56,17.74 QE4.2
ACIN#: length 6.7
  BOTTOM w0.127: QE4.1 269.49,20.07 270.48,20.07 RE17.2 270.51,20.55 268.81,20.55 v1(268.45,20.9) UE1.24
ACIN_D: length 33.7
  TOP w0.127: DH1.2 239.14,18.14 RH152.1 238.25,18.39 238.25,21.21 v1(238.99,21.95) 238.99,21.99 v3(239.73,22.72)
  IN4 w0.091: v3(239.73,22.72) 238.99,23.46 238.99,26.09 242.84,29.94 242.84,31.84 241.52,33.16 238.44,33.16 238.03,32.75 235.65,32.75 235.39,33 232.75,33 231.59,31.84 229.58,31.84 v3(228.93,31.2)
  BOTTOM w0.089: UH1.E6 228.64,31.49 v3(228.93,31.2)
AD0: length 1.8
  BOTTOM w0.127: RE33.1 183.2,135.26 182.45,136 UE8.31
AD0_1: length 1.5
  TOP w0.127: RE27.1 153.51,19.76 UE4.31
AD0_2: length 4.5
  TOP w0.127: UE3.31 222.02,118.24 RE43.2 222.77,117.49 224.55,117.49 v1(224.67,117.38)
AD1: length 2.3
  BOTTOM w0.127: UE8.32 182.41,135.5 182.84,135.07 182.84,134.6 183.07,134.37 RE34.1
AD1_1: length 4
  TOP w0.127: UE4.32 153.15,20.26 RE26.2 153.93,21.13 154.42,21.63 154.42,22.48 v1(154.85,22.91)
AD1_2: length 4.5
  TOP w0.127: v1(224.65,119.04) 223.92,119.04 223.64,119.32 222.77,119.32 RE40.2 222.2,118.74 UE3.32
AD2: length 2.5
  BOTTOM w0.127: RE35.2 182.22,133.78 181.92,134.09 181.37,134.09 181.18,134.28 UE8.1
AD2_1: length 3.1
  TOP w0.127: UE4.1 151.74,22.08 RE29.1 153.01,23.36 v1(153.33,23.36)
AD2_2: length 3.6
  TOP w0.127: UE3.1 219.68,119.99 220.27,120.58 v1(221.25,120.58) 221.52,120.58 RE42.1
AD3: length 3.1
  BOTTOM w0.127: v1(179.56,132.4) 180.12,132.96 RE36.1 180.86,133.36 180.86,133.92 180.68,134.1 UE8.2
AD3_1: length 1.4
  TOP w0.127: RE30.1 151.24,22.47 UE4.2
AD3_2: length 5.2
  TOP w0.127: UE3.2 219.18,120.09 220.02,120.92 222.06,120.92 RE44.1 222.3,121.46 v1(222.53,121.69)
AD_BID0: length 6
  TOP w0.127: v1(272.14,9.2) 272.7,9.76 RE64.1 RE66.2 CE28.1 276.4,10.75 UE5.66
ADP_I: length 349.8
  TOP w0.127: PR23.2 293.19,12.44 v3(293.17,12.41) ; UE5.65 276,10.96 275.73,10.7 275.09,10.7 v3(274.7,11.08)
  TOP w0.254: v3(39.36,35.52) PR717.1
  IN1 w0.099: v3(17.19,36.34) 20.04,39.19 27.26,39.19 30.1,36.35 36.58,36.35 37.41,35.52 v3(39.36,35.52)
  IN2 w0.099: v3(17.19,36.34) 13.24,36.34 11.47,34.57 11.47,26.43 15.3,22.6 15.3,20.77 17.4,18.67 21.68,18.67 22.49,17.86 25.22,17.86 27.19,15.89 27.6,15.89 29.87,13.62 30.86,13.62 31.99,12.49 35.51,12.49 36.86,11.14 49.2,11.14 49.52,11.45 52.82,11.45 53.39,12.02 56.73,12.02 58.74,14.03 64.28,14.03 65.3,13.02 69.7,13.02 70.36,12.35 93.81,12.35 95,13.54 127.4,13.54 128.66,14.8 144.09,14.8 145.01,13.89 145.74,13.89 147.18,12.45 147.18,11.52 147.81,10.9 149.41,10.9 153.82,6.49 192.69,6.49 197.57,11.37 202.72,11.37 203.54,10.56 206.58,10.56 210.75,6.39 237.29,6.39 240.68,9.77 251.82,9.77 253.99,11.95 260.44,11.95 261.12,12.63 269.53,12.63 271.3,10.86 274.48,10.86 v3(274.7,11.08) 278.19,11.08 279.15,10.12 279.66,10.12 280.61,11.08 285.75,11.08 286.96,9.87 287.97,9.87 289.89,11.79 292.55,11.79 v3(293.17,12.41)
  BOTTOM w0.127: v3(17.19,36.34) 17.13,36.39 v1(16.46,36.39)
ADPIN: length 1.9
  TOP w0.127: v2(50.74,20.39) 50.42,20.07 v3(50.42,19.9) ; v3(49.15,19.9) v2(48.57,19.9) ; v3(52.33,19.9) v2(53,19.9)
  vias: v3(49.79,19.9) v3(51.06,19.9) v3(51.69,19.9)
ALERT#: length 4
  BOTTOM w0.127: PR503.1 136.1,131.75 136.07,131.73 PR506.2 136.07,131.03 v1(136.74,130.35) 136.74,129.1 PU500.32
ALIEN_LED_B_DRV#: length 4.1
  TOP w0.127: UE3.5 217.68,120.97 217.11,121.54 v2(217.11,121.83) 217.11,122.2 216.7,122.61 JLOGO1.10
ALIEN_LED_G_DRV#: length 4.4
  TOP w0.127: UE3.4 218.18,120.22 218.61,120.64 v2(218.61,120.87) 218.61,121.38 217.5,122.49 JLOGO1.9
ALIEN_LED_R_DRV#: length 5.7
  TOP w0.127: JLOGO1.8 218.3,122.5 218.91,121.88 219.99,121.88 v2(220.11,121.77) 220.11,121.52 218.68,120.09 UE3.3
AM0: length 13.4
  IN6 w0.254: v3(9.39,24.92) 9.15,24.92 8.66,24.44 8.66,22.35 7.06,20.75 7.06,17.38 7.6,16.84 9.1,16.84 v3(9.29,17.03)
  BOTTOM w0.127: v3(9.39,24.92) v1(9.92,24.92)
  BOTTOM w0.254: UA4.10 8.88,24.92 v3(9.39,24.92) ; v3(9.29,17.03) 9.06,16.8 RA85.1
AM1: length 15.8
  IN6 w0.254: v3(9.58,25.59) 9.22,25.59 8.28,24.65 8.28,22.51 6.38,20.61 6.38,16.67 5.67,15.97 v3(5.35,15.97)
  BOTTOM w0.127: v1(11.58,24.3) 10.57,25.31 9.86,25.31 v3(9.58,25.59)
  BOTTOM w0.254: UA4.9 9.09,25.41 9.4,25.41 v3(9.58,25.59) ; RA86.1 5.83,15.97 v3(5.35,15.97)
AM2: length 15
  IN6 w0.254: v3(5.34,16.58) 5.74,16.58 6,16.83 6,20.77 7.9,22.67 7.9,24.84 v3(9.48,26.42)
  BOTTOM w0.127: v3(9.48,26.42) 10.14,25.76 v1(11.72,25.76)
  BOTTOM w0.254: v3(5.34,16.58) 5.49,16.73 RA87.1
AMD#_NV: length 44.2
  TOP w0.127: v1(266.64,28.55) 266.65,28.54 RE19.1 265.97,26.73 265.97,25.52 v3(265.94,25.49) ; UE6.22 237.16,45.27 v3(237.07,45.35)
  IN4 w0.091: v3(237.07,45.35) 237.86,45.35 242.42,40.79 242.42,39.14 244.69,36.87 244.69,34.25 246.77,32.17 254.5,32.17 258.98,27.69 261.35,27.69 263.99,25.06 265.51,25.06 v3(265.94,25.49)
AMD#_NV_R: length 8.7
  TOP w0.127: RE19.2 267.56,26.67 v3(267.39,26.49)
  BOTTOM w0.127: v1(274.09,26.19) 273.32,26.19 272.54,25.41 271.86,25.41 271.19,26.08 UE1.17 270.44,26.84 267.73,26.84 v3(267.39,26.49)
AMGND: length 7.5
  BOTTOM w0.127: v1(2.26,34.24) 2.73,33.77 v3(3.55,33.77)
  BOTTOM w0.508: RA54.2 2.4,17.24 v3(2.42,17.22) ; v3(9.3,30.72) 9.3,30.9 CA100.2 ; RA117.1 9.97,32.23 v3(9.92,32.29) 9.78,32.43 RA53.2 ; CA70.1 10.28,26.63 v3(10.09,26.44) ; RA116.2 v3(3.55,33.77) ; CA98.2 9.29,24.07 v3(9.29,24.31)
AMP_LEFT: length 14
  TOP w0.127: JIO.40 12.77,13.53 v1(13.06,13.24)
  TOP w0.203: v3(15.14,14.38) 15.37,14.6 UA1.23
  TOP w0.254: v3(10.48,12.64) 10.48,13.06 10.95,13.53 JIO.40
  TOP w0.508: CA105.1 11.62,9.07 11.19,9.5 11.19,11.33 10.48,12.04 v3(10.48,12.64)
  IN1 w0.508: v3(10.48,12.64) 10.72,12.64 11.53,13.45 12.92,13.45 13.5,14.04 14.49,14.04 14.84,14.38 v3(15.14,14.38)
AMP_LEFT-1: length 1.4
  TOP w0.508: CA105.2 11.95,7.46 RA118.1
AMP_LEFT_C: length 34.6
  TOP w0.508: v3(14.2,9.88) 14.2,9.6 14.49,9.31 CA103.2
  IN1 w0.508: v3(14.2,9.88) 14.2,10.52 13.25,11.47 11.86,11.47 10.52,10.12 7.89,10.12 7.18,9.41 5.29,9.41 4.64,10.06 4.64,11.25 4.89,11.51 4.89,12.61 4.69,12.82 4.69,18.23 5.02,18.56 5.63,18.56 5.95,18.87 5.95,19.6 8.47,22.13 8.47,24.97 8.84,25.34 8.84,25.35 8.87,25.38 8.87,27.97 v3(8.93,28.03)
  BOTTOM w0.254: UA4.6 8.75,28.03 v3(8.93,28.03)
  BOTTOM w0.508: v3(8.93,28.03) 9.24,28.34 RA140.2
AMP_RIGHT: length 14.8
  TOP w0.203: UA1.22 v1(14.67,15) 14.34,15 v3(14.16,14.82)
  TOP w0.254: v3(9.73,11.86) 9.73,13.03 10.73,14.03 JIO.39
  TOP w0.508: v3(9.73,11.86) 9.73,11.61 10.42,10.93 CA106.1
  IN1 w0.508: v3(9.73,11.86) 9.69,11.9 9.69,13.01 11.51,14.82 v3(14.16,14.82)
AMP_RIGHT-1: length 2.7
  TOP w0.127: CA106.2 10.43,7.46 10.8,7.09 v1(10.8,6.38)
  TOP w0.508: RA119.1 9.57,6.5 10.42,7.36 CA106.2
AMP_RIGHT_C: length 37.8
  TOP w0.127: v1(8.71,8.84) 9.02,8.54 v3(9.02,8.39)
  TOP w0.508: CA104.2 9.39,7.61 9.02,7.98 v3(9.02,8.39)
  IN1 w0.508: v3(9.02,8.39) 9.02,8.77 8.65,9.13 8.04,9.13 7.52,8.61 5.27,8.61 5.03,8.37 3.22,8.37 2.64,8.94 2.64,9.96 3.1,10.42 3.1,11.29 2.64,11.75 2.64,13.13 3.38,13.87 3.38,15.43 3.84,15.89 3.84,18.72 7.71,22.6 7.71,25.3 8.1,25.69 8.1,27.61 5.57,30.15 v3(4.27,30.15)
  BOTTOM w0.254: v3(4.27,30.15) 4.62,29.8 4.62,29.19 4.92,28.89 UA4.31
  BOTTOM w0.508: RA139.2 4.13,30.29 v3(4.27,30.15)
AOAC_WLAN: length 149.6
  TOP w0.127: v3(155.87,8.94) 155.82,8.94 153.99,10.78 153.99,12.75 155.36,14.12 v1(156,14.12) 157.67,14.12 v3(158.69,15.15) ; UE5.85 284,12.72 283.95,12.77 283.95,13.27 v3(284.07,13.39)
  IN2 w0.099: v3(284.07,13.39) 282.46,11.77 271.18,11.77 269.83,13.12 260.92,13.12 260.21,12.42 253.76,12.42 251.61,10.27 240.48,10.27 237.09,6.88 210.92,6.88 206.76,11.05 203.68,11.05 202.82,11.91 197.41,11.91 192.53,7.03 158.85,7.03 156.94,8.94 v3(155.87,8.94)
  BOTTOM w0.127: UM1.4 158.67,15.13 v3(158.69,15.15)
AUD_HP_OUT_L_C: length 8.6
  IN4 w0.254: v3(1.54,7.99) 1.54,8.42 4.6,11.48 5.7,11.48 v3(6,11.19)
  BOTTOM w0.254: v3(6,11.19) 6.05,11.24 RA50.1 ; UA3.9 1.69,8.68 1.54,8.52 v3(1.54,7.99)
AUD_HP_OUT_L_CN: length 7.8
  TOP w0.254: JIO.35 10.96,16.03 10.64,15.71 9.23,15.71 v3(9.2,15.75)
  IN4 w0.254: v3(9.2,15.75) 6.68,13.24 v3(5.39,13.24)
  BOTTOM w0.254: v3(5.39,13.24) 5.46,13.16 RA50.2
B3_A3: length 6.3
  BOTTOM w0.089: CPU1.B3 CPU1.A3 129.77,102.07 129.8,102.1
  BOTTOM w0.127: 129.8,102.1 130.67,102.97 132.07,102.97 v1(132.09,102.95)
B54_C54: length 6.7
  BOTTOM w0.089: CPU1.C54 CPU1.B54 92.14,101.37 91.01,102.5 91.01,103.47
  BOTTOM w0.127: 91.01,103.47 91.01,105.7 v1(90.4,106.31)
B+: length 264.6
  TOP w1.016: 246,35.73 246,42.97 247.32,44.29 247.32,49.85 243.71,53.46 238.54,53.46 238.54,53.46 235.14,53.46 232.68,55.93 232.68,58.5 229.17,62 223.51,62 222.66,62.85 214.01,62.85 206.4,55.25 206.4,53.77 205.64,53.01 202.45,53.01 200.78,51.34 200.78,49.68 197.74,46.64
  TOP w1.524: 63.44,19.33 62.99,19.78 55.98,19.78 52.17,23.59
  TOP w3.556: 72.33,61.11 72.33,70.39 73.6,71.66 73.6,100.67 75.69,102.77
  IN2 w1.016: 166.42,50.71 170.44,50.71 170.86,51.13 179.83,51.13 179.9,51.07 195.44,51.07 196.92,49.6 196.92,46.83
  IN5 w1.016: 164.75,50.33 163.4,48.99 148.73,48.99
  IN6 w3.556: 73.28,62.57 73.28,98.71 77.03,102.45
  BOTTOM w3.302: 76.61,103.44 73.38,100.21 73.38,68.02
  vias: v2(145.57,52.9) v3(47.25,30.13) v3(47.25,29.49) v3(47.25,28.86) v3(47.25,28.22) v3(47.25,27.59) v3(47.88,30.13) v3(47.88,29.49) v3(47.88,28.86) v3(47.88,28.22) v3(47.88,27.59) v3(47.94,26.51) v3(48.26,27.01) v3(48.52,30.13) v3(48.58,26.51) v3(48.9,27.01) v3(49.15,30.13) v3(49.21,26.51) v3(49.53,27.01) v3(49.79,30.13) v3(49.85,26.51) v3(50.17,27.01) v3(50.48,26.51) v3(50.8,27.01) v3(51.12,26.51) v3(51.44,27.01) v3(72.9,58.64) v3(72.9,58) v3(72.9,57.37) v3(72.9,56.73) v3(72.9,56.1) v3(73.54,59.02) v3(73.54,58.38) v3(73.54,57.75) v3(73.54,57.11) v3(73.54,56.48) v3(74.11,58.64) v3(74.11,58) v3(74.11,57.37) v3(74.11,56.73) v3(74.11,56.1) v3(74.68,59.02) v3(74.68,58.38) v3(74.68,57.75) v3(74.68,57.11) v3(74.68,56.48) v3(75.25,58.64) v3(75.25,58) v3(75.25,57.37) v3(75.25,56.73) v3(75.25,56.1) v3(78.18,106) v3(78.18,105.36) v3(78.36,104.68) v3(78.84,106.07) v3(78.84,105.44) v3(78.96,106.76) v3(79.45,107.18) v3(79.45,105.81) v3(79.49,106.47) v3(79.69,107.76) v3(80.02,108.35) v3(80.06,106.21) v3(80.15,106.86) v3(80.22,107.47) v3(80.33,108.87) v3(80.72,108.35) v3(80.75,107.75) v3(80.81,109.39) v3(80.8,106.96) v3(81.21,108.71) v3(81.32,107.46) v3(81.4,109.58) v3(81.49,108.05) v3(143.26,51.07) v3(143.58,50.56) v3(143.89,51.07) v3(143.89,50) v3(144.21,50.56) v3(144.53,51.07) v3(144.53,50) v3(144.85,50.56) v3(145.16,51.07) v3(145.16,50) v3(145.48,50.56) v3(145.48,49.49) v3(145.8,51.07) v3(145.8,50) v3(145.8,48.99) v3(146.12,50.56) v3(146.12,49.49) v3(146.43,50) v3(146.43,48.99) v3(146.75,49.49) v3(147.07,50) v3(147.07,48.99) v3(147.39,49.49) v3(147.7,48.99) v3(165.01,51.16) v3(165.62,51.16) v3(196.66,45.87) v3(197.3,45.87) v3(246.57,35.4) v3(247.21,35.4)
B+_BIAS: length 341.1
  TOP w0.254: JIO.27 10.49,20.03 v3(10.47,20.05)
  TOP w0.508: v3(74.13,19.32) 75.25,18.2 75.25,17.34 74.89,16.98 74.04,16.98 73.54,16.47 v2(73.54,14.63) 71.25,12.35 69.66,12.35 68.2,13.81 67.76,13.81
  IN2 w0.508: v3(144.37,23.46) 148.58,23.46 152.61,19.43 161.65,19.43 163.13,17.95 166.26,17.95 166.99,18.68 167.96,18.68 168.56,19.28 172.34,19.28 173.19,18.43 179.72,18.43 180.14,18.01 182.98,18.01 183.76,18.79 199.87,18.79 200.47,19.38 206.75,19.38 207.55,18.58 207.55,17.94 208.02,17.46 217.13,17.46 217.78,16.82 220.11,16.82 221.48,18.19 223.42,18.19 223.76,17.85 223.76,17.41 224.13,17.05 225.16,17.05 226.15,18.04 227.42,18.04 228.39,19 228.39,20.25 231.18,23.04 231.18,24.27 232.78,25.87 235.24,25.87 236.27,26.9 236.27,28.39 237.72,29.83 238.25,29.83 238.8,30.38 238.8,31.23 239.46,31.89 242.51,31.89 243.51,32.9 244.01,32.9 244.53,33.42 244.53,35.54 246.51,37.52 246.51,47.04 240.16,53.4 236.43,53.4 v3(233.62,56.2)
  IN3 w0.508: v3(74.13,19.32) 74.13,23.01 77.28,26.16 129.95,26.16 130.82,25.29 142.54,25.29 v3(144.37,23.46)
  IN4 w0.508: v3(233.62,56.2) 232.58,57.25 232.58,60.43 234,61.85 234,67.44 234.98,68.42 234.98,100.99 233.39,102.58 228.87,102.58 222.62,108.83 216.15,108.83 214.82,110.16 214.82,111.44 212.67,113.59 212.67,118.19 v3(210.62,120.25)
  IN5 w1.524: 53.14,9.31 33.82,9.31 33.4,9.73
  BOTTOM w0.508: R179.2 210.95,119.92 v3(210.62,120.25)
  vias: v3(9.55,18.24) v3(9.88,20.05) v3(10.14,18.23) v3(66.3,13.93) v3(66.93,13.93)
BAT_ALERT: length 8
  TOP w0.127: v2(69.95,24.45) 70.27,24.76 PD3.3
  TOP w0.254: PD3.3 v3(71.51,24.22)
  BOTTOM w0.254: PBATT1.9 66.63,22.78 66.64,22.78 70.08,22.78 v3(71.51,24.22)
BATDRV_CHG: length 25.5
  TOP w0.127: v2(66.99,51.74) v3(66.99,51.08)
  IN1 w1.016: 65.47,50.76 64.77,50.76 61.51,47.5 54.94,47.5 52.55,45.11 51.37,45.11 48.83,42.57 48.83,39.97 47.26,38.39
  vias: v3(45.98,37.34) v3(46.56,37.34) v3(66.99,50.45)
BATT+: length 25.7
  TOP w0.127: v3(68.9,48.86) v2(68.9,48.08)
  IN1 w1.016: 48.33,37.78 49.98,39.44 49.98,41.94 52.01,43.97 53.02,43.97 55.39,46.33 62.18,46.33 64.01,48.16 67.44,48.16
  vias: v3(45.98,36.73) v3(46.57,36.73) v3(68.9,49.49)
BATT++: length 61.1
  TOP w0.254: v3(33.02,38.32) 32.69,38.65 PD700.2
  IN1 w0.254: v3(69.95,36.24) 69.95,50.34 66.8,53.49 62.02,53.49 56.96,48.44 53.9,48.44 53.55,48.08 53.24,48.08 52,46.84 51.45,46.84 50.6,45.99 49.94,45.99 48.23,44.29 47.32,44.29 45.1,42.06 40,42.06 38.71,40.77 33.66,40.77 32.7,39.82 32.7,38.64 v3(33.02,38.32)
  vias: v2(66.93,37.71) v2(68.21,39.49) v2(69.62,37.72) v3(64.56,36.43) v3(64.56,35.74) v3(65.45,36.43) v3(65.45,35.74) v3(66.33,36.43) v3(66.33,35.74) v3(67.22,36.43) v3(67.22,35.74) v3(68.11,36.43) v3(68.11,35.74) v3(69,36.43) v3(69,35.74)
BATT_CHG_LED: length 8.4
  BOTTOM w0.127: UE1.25 264.2,21.25 264.2,20.48 v1(264.62,20.06) QE7.1 267.49,17.19 267.49,16.67 267.96,16.2 RE23.2
BATT_CHG_LED#: length 29.3
  TOP w0.127: UE5.90 286,9.36 285.43,8.8 v1(285.43,6.87) 285.43,6.63 v3(284.95,6.15)
  BOTTOM w0.127: v3(284.95,6.15) 284.55,5.74 276.25,5.74 267.12,14.87 266.41,14.87 QE7.2
BATT_LOW_LED: length 14.5
  BOTTOM w0.127: QE6.1 273.12,17.55 RE21.2 271.97,18.31 270.82,19.46 269.99,19.46 269.05,18.52 268.57,18.52 v1(267.26,19.83) 266.14,20.94 266.14,22.54 267.44,23.84 267.79,23.84 268.37,23.27 UE1.22
BATT_LOW_LED#: length 24.8
  TOP w0.127: UE5.93 287.2,12.82 286.98,13.03 286.98,13.82 286.87,13.93 286.87,15.95 285.75,17.07 285.75,21.07 283.97,22.85 282.92,22.85 v3(282.51,23.26)
  BOTTOM w0.127: v3(282.51,23.26) 282.51,21.78 278.78,18.05 278.78,17.54 v1(278.64,17.4) 277.54,16.3 QE6.2
BATT_PRS: length 7.9
  TOP w0.127: PR22.1 69.38,26.39 68.37,25.38 v2(68.37,25.28)
  TOP w0.254: PR22.1 69.87,26.39 v3(70.35,26.87)
  BOTTOM w0.254: PBATT1.7 66.54,25.78 66.55,25.78 69.86,25.78 70.35,26.27 v3(70.35,26.87)
BATT_TEMP: length 260.8
  TOP w0.127: UE5.63 273.33,13.85 273.29,13.88 CE35.2 272.4,13.88 271.48,14.81 v3(271.48,15.24) ; 73.69,28.32 73.69,29.31 v1(73.92,29.54)
  TOP w0.254: v3(48.73,35.69) 48.16,35.12 47.6,35.12 PR727.1 ; 73.69,28.32 PC14.1 73.13,28.32 72.6,27.79 PR16.1 71.09,27.79 PR15.2 70.91,27.97 v3(70.91,28.4)
  IN1 w0.254: v3(48.73,35.69) 49.41,35.02 51.78,35.02 52.29,34.51 61.61,34.51 68.56,27.56 70.35,27.56 70.91,28.12 v3(70.91,28.4)
  IN2 w0.099: v3(271.48,15.24) 271.19,14.96 271.1,14.86 262.08,14.86 259.87,12.65 253.64,12.65 251.56,10.56 240.42,10.56 236.98,7.13 210.99,7.13 206.82,11.31 203.77,11.31 202.94,12.14 197.29,12.14 194.51,9.36 173.74,9.36 172.95,8.57 170.53,8.57 169.22,7.26 158.94,7.26 156.58,9.61 151.4,9.61 149.61,11.39 148.11,11.39 147.8,11.7 147.8,12.6 146.02,14.38 145.21,14.38 144.3,15.3 128.46,15.3 127.78,14.62 121.31,14.62 120.7,14.01 90,14.01 89.22,13.22 79.33,13.22 v3(77.47,15.08)
  IN6 w0.099: v3(70.91,28.4) 70.89,28.4 73.36,25.94 74.77,25.94 78.04,22.66 78.04,18.71 77.47,18.14 v3(77.47,15.08)
BBS_BIT1: length 5.6
  BOTTOM w0.089: 231.59,33.49 231.38,33.49 231.09,33.2 230.69,33.2 230.5,33.39 230.22,33.39 229.93,33.1 UH1.C10
  BOTTOM w0.127: 231.59,33.49 231.92,33.49 232.53,32.88 v1(232.61,32.88) 232.79,32.69 232.79,32.57 233.42,31.94 RH71.1
BE1_BD1: length 4.4
  BOTTOM w0.127: v1(131.61,72.9) 130.89,72.17 CPU1.BE1 CPU1.BD1
BE2_BF2: length 6
  BOTTOM w0.127: v1(132.63,71.78) 132.33,71.48 CPU1.BF2 127.49,71.49 CPU1.BE2
BE3_BF3: length 6.3
  BOTTOM w0.127: CPU1.BE3 126.75,72.14 CPU1.BF3 126.75,71.08 127.21,70.63 v1(131.78,70.63)
BE52_BF52: length 5.9
  BOTTOM w0.127: v1(88.85,70.68) 92.93,70.68 CPU1.BF52 93.73,72.15 CPU1.BE52
BE53_BF53: length 6.4
  BOTTOM w0.127: CPU1.BE53 93.03,72.15 CPU1.BF53 87.54,71.48 v1(87.42,71.6)
BE54_BD54: length 4.5
  BOTTOM w0.127: v1(88.84,72.7) 89.44,72.09 CPU1.BE54 CPU1.BD54
BEEP#: length 86.9
  TOP w0.127: UE5.23 279.6,26.55 279.81,26.34 280.46,26.34 281.27,25.53 281.27,23.31 281.99,22.58 282.37,22.58 285.46,19.5 285.46,15.98 286.26,15.18 v3(286.26,13.25)
  IN6 w0.099: v3(237.84,15.2) 237.84,13.82 238.33,13.32 240.54,13.32 241.4,14.19 262.19,14.19 264.23,16.22 268.04,16.22 269.12,17.3 272.21,17.3 273.46,16.05 273.46,13.57 273.22,13.32 273.22,12.69 274.08,11.83 284.84,11.83 v3(286.26,13.25)
  BOTTOM w0.127: v3(237.84,15.2) 237.4,14.76 236.81,14.76 236.12,15.45 v1(235.46,15.45) 234.81,15.45 234.22,14.85 227.89,14.85 CA67.1
BKOFF#: length 326.1
  TOP w0.127: 90.83,116.56 89.82,115.55 v3(89.45,115.55) ; v3(287.31,18.19) 287.68,17.81 287.68,16.88 287.91,16.65 UE5.105
  IN2 w0.099: v3(89.45,115.55) 85.51,111.6 85.51,103.5 86.53,102.47 87.54,102.47 88.14,101.87 90.79,101.87 92.05,103.12 110.18,103.12 113.39,106.34 130.67,106.34 133.63,103.38 133.63,90.68 135.07,89.24 135.07,84.23 136.43,82.87 136.43,68.02 139.73,64.72 139.73,58.35 144.02,54.05 148.54,54.05 157.59,45.01 157.59,41.99 159,40.58 159,39.83 161.95,36.87 161.95,35.24 169.51,27.68 169.51,26.07 170.65,24.93 172.49,24.93 174.84,22.58 179.31,22.58 179.89,23.16 189.58,23.16 200.5,34.08 200.5,44.93 202.01,46.44 203.91,46.44 208.75,51.28 208.75,52.61 211.23,55.08 214.39,55.08 215.11,55.8 223.79,55.8 226.48,53.11 227.77,53.11 229.31,51.57 v3(231.55,51.57)
  IN6 w0.099: v3(231.55,51.57) 231.78,51.8 238.34,51.8 238.72,52.19 241.2,52.19 250.47,42.92 250.64,42.92 253.84,39.71 253.84,38.73 257.92,34.65 257.92,31.67 260.1,29.49 260.54,29.49 263.57,26.47 266.84,26.47 272.51,20.8 273.75,20.8 275.66,18.88 276.74,18.88 277.56,18.06 279.28,18.06 279.85,18.63 286.86,18.63 v3(287.31,18.19)
  BOTTOM w0.127: v3(231.55,51.57) 231.55,51.58 v1(232.6,51.58)
BOOT1:
  vias: v1(135.94,123.17)
BOOT2:
  vias: v1(134.61,128.3)
BOOT3:
  vias: v1(102.87,114.61)
BOOT_1.35V: length 6
  TOP w0.127: v2(149.02,34.67) 148.76,34.41 PR200.2
  TOP w0.254: PR200.2 148.76,32.96 149.11,32.6 150.56,32.6 150.89,32.27 PU200.18
BSPL:
  vias: v1(6.75,21.63)
BST_1.35V: length 2.6
  TOP w0.127: PC204.1 151.17,32.72 v2(151.82,32.07)
  TOP w0.254: PC204.1 PR200.1
BST_3V: length 2.5
  TOP w0.127: v1(26.86,24.86) 25.82,24.86 25.06,25.62 PR108.2
BST_5V: length 2
  TOP w0.127: v1(25.94,33.15) 24.94,32.16 PR109.1
BST_+1.05VSP: length 3.7
  BOTTOM w0.127: v1(244.53,24.31) 245.52,24.31 245.87,24.67 PR302.1
  BOTTOM w0.254: PU300.10 245.72,26.51 245.87,26.35 PR302.1
BST_+1.35VS_VGAP: length 4.1
  BOTTOM w0.127: v1(134.38,105.5) 133.94,105.95 PR309.1
  BOTTOM w0.254: PR309.1 134.56,107.53 134.56,108.74 134.69,108.87 PU301.10
BT_LED#: length 6.9
  TOP w0.254: QN4.3 168.39,33.64 RN25.2 v1(170.84,33.64) 171.36,33.64 v3(171.71,33.99)
  BOTTOM w0.254: JWLAN1.6 172.5,34.78 v3(171.71,33.99)
BT_OFF#: length 82.9
  TOP w0.089: v3(227.61,35.64) 227.16,35.18 v1(226.71,35.18)
  TOP w0.102: v3(227.61,35.64) 228,36.03 229.21,36.03 229.52,36.34 230.39,36.34
  TOP w0.127: RH59.2 231.51,34.97 231.27,35.21 231.27,35.46 230.39,36.34
  IN6 w0.099: v3(227.61,35.64) 227.15,36.1 225.49,36.1 225.08,35.69 225.08,34.19 225.16,34.11 225.16,30.43 224.35,29.62 221.63,29.62 220.93,28.92 218.7,28.92 215.36,25.58 215.36,25.13 214.2,23.98 214.2,21.86 213.1,20.75 212.26,20.75 211,19.5 206.33,19.5 206.05,19.23 200.45,19.23 199.76,18.53 193.95,18.53 192.76,17.34 192.09,17.34 190.97,16.23 189.96,16.23 188.57,14.84 183.68,14.84 182.66,15.86 180.05,15.86 179.57,15.38 177.01,15.38 176.21,16.18 175.72,16.18 v3(175.26,15.72)
  BOTTOM w0.089: UH1.G17 227.85,35.88 v3(227.61,35.64)
  BOTTOM w0.127: v3(175.26,15.72) 175.54,16 175.54,20.86 175.07,21.33 175.07,22.49 174.78,22.78 JWLAN1.46
