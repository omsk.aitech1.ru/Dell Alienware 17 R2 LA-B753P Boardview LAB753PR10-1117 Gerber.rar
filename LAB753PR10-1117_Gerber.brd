# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VALW_PCH_GATE on TOP (solid shape): 216.72,13.12 217.68,13.12 217.76,13.04 217.76,12.93 217.71,12.88 216.96,12.88 216.51,12.43 215.95,11.87 215.87,11.86 215.82,11.84 215.26,11.84 215.19,11.91 215.19,13.71 215.31,13.84 216,13.84
+3VALWP on BOTTOM (solid shape): outline of 329 points within 21.72,17.71 29.24,27.59
+3VLP on TOP (solid shape): 21.05,29.14 22.39,29.14 22.44,29.09 22.44,28.98 22.39,28.93 21.3,28.93 20.82,28.45 19.74,28.45 19.58,28.62 19.58,29.13 19.78,29.34 20.84,29.34
+3VLP on BOTTOM (solid shape): 18.58,40.61 18.58,38.4 18.1,37.92 16.56,37.92 16.33,38.15 16.33,40.73 16.5,40.91 18.28,40.91
+3VS on TOP (solid shape): 283.16,7.73 283.16,6.89 282.97,6.7 282.34,6.7 281.38,7.67 281.38,8.29 281.48,8.39 282.5,8.39
+3VS on TOP (solid shape): 207.79,20.33 207.8,20.33 207.88,20.25 207.88,18.77 207.72,18.6 206.73,18.6 206.63,18.7 206.17,19.16 206.17,19.93 206.64,20.4 207.73,20.4
+3VS on TOP (solid shape): 222.7,7.71 222.7,7.23 222.54,7.08 222.54,5.82 222.45,5.73 221.43,5.73 221.37,5.79 221.37,7.71 221.53,7.87 222.54,7.87
+3VS on TOP (solid shape): 266.49,13.41 266.49,10.99 266.41,10.91 265.58,10.91 265.37,11.12 264.64,11.12 264.46,11.3 264.46,13.59 264.63,13.76 266.14,13.76
+3VS on TOP (solid shape): 152.66,57.81 152.66,55.07 152.57,54.98 152.03,54.98 151.78,55.22 150.4,55.22 150.39,55.22 149.91,55.22 149.69,55.45 149.69,56.44 150.2,56.95 151.19,56.95 151.4,57.16 151.4,57.55 151.77,57.92 152.56,57.92
+3VS on TOP (solid shape): 196.69,7.88 196.74,7.8 196.79,7.73 196.8,7.71 196.8,7.47 196.66,7.33 196.64,7.33 196.64,7.31 196.47,7.14 196.47,5.74 196.41,5.68 195.33,5.68 195.14,5.87 195.14,7.9 195.26,8.03 196.54,8.03
+3VS on TOP (solid shape): 87.88,127.32 87.88,126.59 87.67,126.38 86.97,126.38 86.79,126.55 84.97,126.55 81.83,123.41 81.83,120.8 81.38,120.36 81.29,120.36 81.29,120.27 81.07,120.05 81.07,119.64 80.78,119.34 80.42,119.34 80.37,119.4 80.64,121.64 81.01,124.61 83.82,127.42 87.77,127.42
+3VS on TOP (solid shape): 229.98,9.23 229.98,8.6 230.35,8.24 230.35,7.47 230.28,7.41 227.92,7.41 227.86,7.47 227.86,7.8 227.86,7.82 227.95,8.25 227.86,8.68 227.86,8.69 227.86,9.1 228.1,9.35 229.86,9.35
+3VS on TOP (solid shape): 206.71,9.21 206.71,8.42 206.89,8.24 206.89,7.5 206.74,7.34 204.47,7.34 204.33,7.49 204.33,7.75 204.34,7.76 204.45,8.25 204.34,8.73 204.33,8.75 204.33,8.9 204.82,9.39 206.54,9.39
+3VS on TOP (solid shape): 179.73,10.7 179.73,10.25 179.99,9.98 179.99,8.6 180.27,8.33 180.6,8.33 180.71,8.22 180.71,7.41 180.54,7.25 178.36,7.25 178.25,7.36 178.25,7.62 178.26,7.64 178.44,8.1 178.39,8.6 178.38,8.64 178.75,9.01 178.75,10.85 178.87,10.96 179.47,10.96
+3VS on TOP (solid shape): 61.09,12.41 61.09,11.65 61.29,11.45 61.65,11.45 61.76,11.34 61.76,11.03 61.55,10.82 61.55,10.41 61.26,10.12 60.87,10.12 60.64,9.9 60.64,9.58 60.62,9.56 60.02,9.56 59.82,9.35 59.82,9.18 59.71,9.08 58.73,9.08 58.62,9.08 58.54,9.12 58.48,9.14 58.46,9.14 58.46,9.73 57.9,9.73 57.9,9.98 58.46,9.98 58.46,10.53 57.9,10.53 57.9,10.77 57.91,10.78 58.45,10.78 58.46,10.79 58.46,11.92 59.27,12.73 60.77,12.73
+3VS on TOP (solid shape): 155.51,8.98 155.51,8.95 155.95,8.59 156.18,9.11 156.18,9.24 156.29,9.3 157.61,9.3 157.69,9.22 157.69,7.4 157.57,7.27 154.93,7.27 154.69,7.51 154.69,7.55 154.95,8.24 154.71,8.93 154.69,8.94 154.69,9.02 154.97,9.3 155.2,9.3
+3VS on TOP (solid shape): 209.98,28.62 209.98,26.4 210.24,26.14 210.24,26.14 210.31,26.07 210.31,23.11 210.5,22.92 210.5,22.54 210.2,22.24 209.04,22.24 208.81,22.47 208.81,23.94 208.43,24.31 208.43,24.71 207.94,25.2 207.94,25.52 208.33,25.52 208.34,25.47 208.35,25.42 208.37,25.37 208.39,25.32 208.43,25.28 208.47,25.24 208.51,25.21 208.56,25.19 208.61,25.17 208.66,25.17 208.72,25.17 208.77,25.17 208.82,25.19 208.87,25.21 208.91,25.24 208.95,25.28 208.98,25.32 209.01,25.37 209.03,25.42 209.04,25.47 209.05,25.52 209.04,25.58 209.03,25.63 209.01,25.68 208.98,25.72 208.95,25.77 208.91,25.8 208.87,25.83 208.82,25.85 208.77,25.87 208.72,25.88 208.66,25.88 208.61,25.87 208.56,25.85 208.51,25.83 208.47,25.8 208.43,25.77 208.39,25.72 208.37,25.68 208.35,25.63 208.34,25.58 208.33,25.52 207.94,25.52 207.94,28.53 208.25,28.84 209.76,28.84
+3VS on TOP (solid shape): outline of 104 points within 231.9,33.66 238.72,40.57
+3VS on BOTTOM (solid shape): 90.38,127.85 90.38,127.49 88.18,125.29 88.07,125.29 86.79,126.56 86.79,127.04 88.9,129.15 89.08,129.15
+3VS on BOTTOM (solid shape): 104.88,141.79 104.88,139.89 104.74,139.74 104.15,139.74 104.08,139.82 104.08,141.3 103.86,141.52 103.86,141.76 104,141.9 104.78,141.9
+3VS on BOTTOM (solid shape): 246.1,8.03 246.1,5.86 245.96,5.72 245.3,5.72 245.23,5.79 245.23,7.24 244.87,7.6 244.87,7.96 245.06,8.16 245.98,8.16
+3VS on BOTTOM (solid shape): 162.61,28.08 162.61,26.98 162.52,26.89 160.92,26.89 160.92,26.89 160.11,26.89 159.96,27.04 159.96,27.99 160.13,28.16 162.53,28.16
+3VS on BOTTOM (solid shape): 173.08,8.02 173.08,5.86 172.95,5.73 172.33,5.73 172.23,5.83 172.23,7.3 171.95,7.58 171.95,8.08 172.05,8.18 172.91,8.18
+3VS on BOTTOM (solid shape): 82.46,121.06 82.46,118.7 81.24,117.48 81.24,117 80.82,116.59 80.68,116.59 80.27,117 80.27,118.59 80.28,118.7 80.61,121.37 81.2,121.95 81.56,121.95
+3VS on BOTTOM (solid shape): 196.66,7.89 196.66,7.14 196.59,7.07 196.59,5.84 196.46,5.72 195.84,5.72 195.73,5.82 195.73,7.29 195.62,7.41 195.62,7.81 195.77,7.96 196.59,7.96
+3VS on BOTTOM (solid shape): 222.59,8.1 222.59,5.83 222.49,5.73 221.85,5.73 221.72,5.86 221.72,7.21 221.63,7.3 221.6,7.34 221.56,7.38 221.35,7.59 221.35,8.09 221.46,8.21 222.49,8.21
+3VS on BOTTOM (solid shape): 149.15,133.17 149.49,132.83 150.28,132.83 150.47,133.02 151.92,133.02 152,132.95 152,132.79 151.92,132.72 150.94,132.72 150.62,132.39 150.62,131.86 150,131.24 150,130.82 149.87,130.7 148.33,130.7 148.22,130.8 148.22,135.1 148.24,135.15 148.28,135.17 148.31,135.17 149.15,135.17
+3VS on BOTTOM (solid shape): 156.05,8.41 156.05,5.86 155.93,5.74 154.8,5.74 154.69,5.86 154.69,7.55 154.91,7.95 154.94,8.4 154.97,8.5 155.07,8.55 155.91,8.55
+3VS on BOTTOM (solid shape): 179.57,8.24 179.57,7.93 179.58,7.93 179.58,5.84 179.47,5.73 178.34,5.73 178.14,5.93 178.14,7.49 178.38,7.86 178.45,8.29 178.49,8.38 178.58,8.42 179.39,8.42
+3VS on BOTTOM (solid shape): 219.68,34.72 220.12,34.72 220.16,34.74 220.3,34.74 220.32,34.73 220.37,34.68 220.38,34.66 220.38,34.52 220.38,34.35 219.62,33.59 219.59,33.56 219.39,33.36 219.2,33.36 219.05,33.51 219.05,33.74 219.39,34.07 219.39,34.64 219.49,34.74 219.64,34.74
+3VS on BOTTOM (solid shape): 31.08,12.6 31.08,11.21 31.41,10.87 32.32,10.87 32.66,10.53 32.66,8.73 32.53,8.59 31.04,8.59 30.9,8.73 30.9,9.39 29.92,10.37 29.92,10.73 29.74,10.92 28.22,10.92 28.07,11.08 28.07,11.98 27.83,12.21 27.83,14.01 27.91,14.1 29.58,14.1
+3VS on BOTTOM (solid shape): 205.56,8.32 205.56,5.83 205.45,5.72 204.32,5.72 204.11,5.93 204.11,7.46 204.38,7.86 204.45,8.34 204.48,8.44 204.58,8.48 205.41,8.48
+3VS on BOTTOM (solid shape): 229.08,8.24 229.08,7.93 229.08,7.93 229.08,5.84 228.97,5.73 227.71,5.73 227.55,5.89 227.55,7.42 227.87,7.83 227.95,8.35 227.98,8.44 228.08,8.48 228.83,8.48
+3VS on IN1 (solid shape): outline of 897 points within 233.52,37.69 240.07,49.08
+3VS on IN2 (solid shape): 73.66,51.54 73.66,50.7 73.07,50.11 71.85,50.11 70.03,51.93 70.03,52.27 70.96,53.2 72,53.2
+3VS on IN2 (solid shape): outline of 102 points within 80.27,110.66 82.69,121.32
+3VS on IN2 (solid shape): outline of 295 points within 232.56,28.6 237.68,34.23
+3VS on IN2 (solid shape): outline of 4250 points within 207.98,26.88 235.02,42.05
+3VS on IN3 (solid shape): 159.84,28.63 159.84,26.84 159.54,26.54 158.02,26.54 157.66,26.89 157.66,28.69 157.89,28.91 159.56,28.91
+3VS on IN3 (solid shape): 151.17,56.5 151.17,55.41 150.95,55.18 150.45,55.18 150.24,55.18 150.01,54.95 150.01,54.12 149.82,53.93 148.06,53.93 147.93,54.05 147.93,55.05 147.67,55.31 147.67,56.23 148.95,56.23 148.95,56.17 148.96,56.12 148.97,56.07 148.99,56.02 149.02,55.98 149.06,55.94 149.1,55.9 149.15,55.88 149.2,55.86 149.25,55.85 149.3,55.84 149.36,55.85 149.41,55.86 149.46,55.88 149.5,55.9 149.55,55.94 149.58,55.98 149.61,56.02 149.64,56.07 149.65,56.12 149.66,56.17 149.66,56.23 149.65,56.28 149.64,56.33 149.61,56.38 149.58,56.42 149.55,56.46 149.5,56.49 149.46,56.52 149.41,56.54 149.36,56.55 149.3,56.56 149.25,56.55 149.2,56.54 149.15,56.52 149.1,56.49 149.06,56.46 149.02,56.42 148.99,56.38 148.97,56.33 148.96,56.28 148.95,56.23 147.67,56.23 147.67,57.18 147.93,57.44 147.93,57.44 148.16,57.67 150.01,57.67
+3VS on IN4 (solid shape): 33.97,10 33.97,8.63 33.91,8.57 30.98,8.57 30.87,8.68 30.87,9.93 30.99,10.05 33.92,10.05
+3VS on IN4 (solid shape): outline of 155 points within 52.2,8.55 61.91,12.41
+3VS on IN4 (solid shape): outline of 859 points within 217.49,110.28 225.15,126.19
+3VS on TOP: 107.94,141 107.11,141 106.85,141.26 105.63,141.26 105.03,140.67 104.18,140.67 103.82,141.02 103.82,141.78 104,141.96 106.42,141.96 107.19,142.74 107.58,142.74 107.98,142.34 107.98,141.04
+3VS on VCC: 63.57,5.55 63.57,6.28 62.91,7.88 61.3,8.55 54.29,8.55 54.29,42.21 68.5,56.42 79.28,56.42 79.28,47.5 74.17,42.4 74.17,32.22 75.63,30.76 75.63,27.07 74.86,26.29 74.86,18.77 78.23,15.39 141.52,15.39 142.69,16.56 142.69,26.44 145.51,29.26 145.51,30.51 190.18,30.51 190.18,20.12 192.49,17.81 203.75,17.81 209.09,23.14 230.85,23.14 234.91,19.08 243.5,19.08 244.79,20.37 244.79,32.79 300.17,32.79 300.17,5.55 202.95,5.55 202.95,8.03 200.43,10.55 197.91,8.03 197.91,5.55 145.67,5.55 145.67,6.28 145.01,7.88 143.4,8.55 70.3,8.55 68.69,7.88 68.03,6.28 68.03,5.55 ; 1 cut-out
+3VS on IN3: 103.58,142.54 103.58,136.83 104.96,135.45 107.75,135.45 107.97,135.67 107.97,141.15 108.18,141.36 111.96,141.36 112.31,141.01 112.31,139.82 112.44,139.69 113.54,139.69 113.8,139.95 113.8,142.2 114.3,142.71 114.3,143.78 113.93,144.14 108.94,144.14 108.92,144.12 105.17,144.12
+3VS_CARD on TOP (solid shape): 323.82,20.15 323.83,20.15 323.96,20.01 323.96,19.6 323.43,19.06 322.89,19.06 322.88,19.06 321.17,19.06 321.06,19.17 321.06,20.13 321.15,20.22 323.76,20.22
+3VS_CARD on TOP (solid shape): 334.37,18.85 334.37,17.82 334.22,17.67 330.61,17.67 330.33,17.95 330.33,18.41 330.47,18.54 331.04,18.54 331.11,18.61 333.04,18.61 333.41,18.98 334.23,18.98
+3VS_CARD on IN6 (solid shape): 333.23,19.07 334.29,19.07 334.5,18.86 334.5,18.07 334.31,17.88 332.87,17.88 331.79,18.96 331.79,19.28 332.26,19.75 332.54,19.75
+3VS_CARD on IN6 (solid shape): 323.91,20.12 323.91,19.23 323.66,18.98 321.93,18.98 321.26,18.31 320.16,18.31 320.03,18.44 320.03,19.26 321.05,20.27 323.76,20.27
+3VS_DP on BOTTOM (solid shape): 146.31,140.89 146.31,139.47 147.45,138.33 147.82,138.33 147.96,138.19 147.96,136.22 147.82,136.08 146.52,136.08 146.3,135.86 146.28,135.86 146.12,135.76 146.03,135.59 146.01,135.56 146.01,134.55 145.83,134.36 145.36,134.36 145.18,134.55 145.18,136.35 145.35,136.53 146,136.53 146.09,136.62 146.09,137.41 145.82,137.68 145.82,138.84 145.6,139.07 145.13,139.07 145.03,139.17 145.03,140.94 145.15,141.06 146.14,141.06
+3VS_VGA on TOP (solid shape): 155.82,60.46 155.82,59.96 155.01,59.15 154.09,59.15 154.02,59.23 154.02,59.98 154.69,60.65 155.63,60.65
+3VS_VGA on TOP (solid shape): 172.17,76.37 172.17,75.75 171.85,75.43 171.85,74.36 171.75,74.26 170.94,74.26 170.88,74.32 170.88,75.78 170.91,75.81 170.96,75.81 171.62,76.47 172.07,76.47
+3VS_VGA on TOP (solid shape): 169.79,79.54 169.79,78.67 169.59,78.46 169.59,78 169.54,77.95 169.23,77.95 169.04,77.76 169.04,77.33 169.09,77.28 169.09,76.28 169.02,76.21 167.39,76.21 167.2,76.4 167.2,79.23 167.55,79.58 169.75,79.58
+3VS_VGA on BOTTOM (solid shape): 149.66,76.72 149.66,73.15 149.53,73.03 148.71,73.03 148.55,73.18 148.55,76.73 148.73,76.9 149.48,76.9
+3VS_VGA on BOTTOM (solid shape): 152.52,81.24 152.91,81.24 153.39,80.76 153.39,80.34 153.32,80.27 152.75,80.27 152.51,80.02 152.51,77.74 152.47,77.71 152.36,77.67 152.27,77.75 152.24,77.81 152.2,77.86 152.17,77.94 152.2,78.03 151.93,78.62 151.66,78.03 151.69,77.94 151.66,77.86 151.61,77.77 151.58,77.66 151.57,77.6 150.09,77.6 149.73,77.96 149.73,79.55 149.86,79.69 149.86,81.17 150.05,81.36 152.4,81.36
+3VS_VGA on BOTTOM (solid shape): outline of 83 points within 167.37,77.37 169.22,79.01
+3VS_VGA on IN2 (solid shape): outline of 281 points within 167.05,74.07 177.45,81.86
+3VS_VGA on IN5 (solid shape): outline of 213 points within 152.86,59.39 157.57,64.62
+3VS_VGA on IN5 (solid shape): outline of 554 points within 148.41,74.14 168.8,79.55
+3VS_VGA on IN6 (solid shape): outline of 327 points within 167.28,74.03 177.64,79.58
+3VS_WLAN_NGFF on TOP (solid shape): outline of 167 points within 162.93,16.16 173.7,24.77
+3VS_WLAN_NGFF on BOTTOM (solid shape): 171.51,35.99 171.6,35.98 171.69,35.99 175.12,35.99 175.3,35.8 175.3,35.4 174.99,35.09 171.14,35.09 171.02,35.21 171.02,35.77 171.24,35.99
+3VS_WLAN_NGFF on BOTTOM (solid shape): 164.57,19.5 164.57,18.53 163.6,17.57 163.6,15.01 163.18,14.59 161.14,14.59 160.97,14.76 160.97,16.32 160.65,16.64 160.06,16.64 159.85,16.85 161.88,16.85 161.88,16.53 162.06,16.35 162.09,16.35 162.11,16.33 162.4,16.33 162.42,16.35 162.46,16.35 162.69,16.58 162.69,17.48 162.69,17.73 161.93,17.73 161.93,16.9 161.88,16.85 159.85,16.85 159.82,16.88 159.82,17.98 160.64,18.81 161.42,18.81 161.63,19.03 161.65,19.03 162.31,19.69 164.38,19.69
+3VS_WLAN_NGFF on BOTTOM (solid shape): outline of 95 points within 169.52,15.15 174.66,21.62
+5VALW on TOP (solid shape): 12.01,21.67 12.17,21.63 12.33,21.67 12.55,21.67 12.78,21.44 12.78,20.71 12.94,20.55 12.94,19.97 12.89,19.93 12.03,19.93 11.89,20.07 11.89,20.16 11.69,20.37 10.97,20.37 10.87,20.47 10.87,21.58 10.96,21.67
+5VALW on TOP (solid shape): 53.98,18.22 53.98,14.38 53.91,14.31 53.25,14.31 52.6,14.32 52.53,14.38 52.53,14.4 52.45,14.59 52.26,14.67 52.24,14.67 52,14.91 52,14.93 51.33,14.99 51.8,14.51 51.84,14.53 51.97,14.4 51.97,14.38 52.05,14.19 52.24,14.11 52.26,14.11 52.44,13.93 53.02,13.93 53.22,13.74 53.91,13.74 53.98,13.68 53.98,13.55 53.91,13.49 53.09,13.49 53.02,13.55 50.61,13.55 50.32,13.85 50.32,15.43 49.47,16.28 49.47,17.03 50.25,17.81 51.02,17.81 51.76,18.55 53.64,18.55
+5VALW on BOTTOM (solid shape): 266.72,39.07 266.72,38.6 266.46,38.34 266.21,38.34 266.04,38.52 265.92,38.52 265.36,37.96 265.28,37.96 264.85,38.38 264.85,38.56 265.77,39.48 266.31,39.48
+5VALW on BOTTOM (solid shape): 318.44,58.83 318.44,58.1 318.77,57.77 318.77,56.86 317.56,55.65 316.63,55.65 315.76,56.52 315.76,57.7 316.04,57.99 317.5,57.99 317.64,58.12 317.64,58.95 317.69,59 318.26,59
+5VALW on BOTTOM (solid shape): 31.63,40.45 31.63,38.76 31.37,38.51 30.67,38.51 30.67,39.02 29.94,39.02 29.94,38.51 29.5,38.51 29.5,39.02 28.77,39.02 28.77,38.51 27.94,38.51 27.69,38.76 27.69,40.65 28.02,40.99 31.09,40.99
+5VALW on BOTTOM (solid shape): 316.85,45.64 317.41,45.64 317.95,45.1 317.95,43.78 317.5,43.33 314.5,43.33 314.01,42.84 314.01,41.17 314.41,40.77 314.41,39.1 314.04,38.73 312.51,38.73 312.15,39.09 312.15,44.1 313.4,45.35 314.69,45.35 314.99,45.65 316.84,45.65
+5VALW on VCC: outline of 120 points within 1.27,12.79 318.84,138.54 ; 5 cut-outs
+5VALWP on BOTTOM (solid shape): 29.37,38.37 30.07,38.37 30.07,38.9 30.52,38.9 30.54,38.87 30.54,38.33 31.37,38.33 31.63,38.08 31.63,36.54 30.04,34.95 30.04,31.33 29.72,31.02 26.16,31.02 23.75,33.43 23.75,34.73 23.24,35.24 23.24,37.68 23.89,38.33 28.86,38.33 28.89,38.36 28.89,38.9 29.37,38.9
+5VS on TOP (solid shape): 165.79,25.99 165.79,22.77 165.74,22.72 164.99,22.72 164.75,22.96 162.32,22.96 162.09,23.19 162.09,23.19 162.04,23.25 162.04,25.85 162.31,26.13 165.65,26.13
+5VS on TOP (solid shape): 224.16,125.03 224.16,122.1 224.42,121.84 225.26,121.84 225.36,121.73 225.36,120.9 225.32,120.86 223.79,120.86 223.57,121.07 223.57,121.08 223.09,121.56 223.09,122.43 222.83,122.68 222.83,124.61 222.87,124.65 222.87,125.55 223.01,125.69 223.5,125.69
+5VS on TOP (solid shape): 62.23,18.25 62.23,14.44 62.11,14.31 58.87,14.31 58.46,14.72 58.46,15.69 57.91,15.69 57.91,15.95 58.45,15.95 58.45,16.49 57.91,16.49 57.91,16.73 57.93,16.75 58.45,16.75 58.45,16.75 58.45,18.09 58.87,18.51 61.98,18.51
+5VS on BOTTOM (solid shape): 139.07,136.93 139.07,136.2 139.45,135.82 139.45,134.9 139.19,134.65 137.92,134.65 137.67,134.9 137.67,136.93 137.92,137.19 138.81,137.19
+5VS on BOTTOM (solid shape): 66.17,59.6 66.17,57.25 66.16,57.23 66.16,56.5 65.92,56.27 65.07,56.27 64.88,56.45 64.88,57.19 64.99,57.3 64.99,59.58 65.14,59.73 66.04,59.73
+5VS on BOTTOM (solid shape): 163.76,25.33 163.76,23.86 163.5,23.6 162.82,23.6 162.53,23.88 161.36,23.88 161.28,23.97 161.28,25.1 161.36,25.17 162.56,25.17 162.84,25.45 163.63,25.45
+5VS on BOTTOM (solid shape): 214.12,126.2 214.12,125.82 214.38,125.57 215.06,125.57 215.2,125.43 215.2,122.84 214.77,122.41 212.35,122.41 212.1,122.65 212.1,126.15 212.34,126.38 213.94,126.38
+5VS on BOTTOM (solid shape): outline of 286 points within 125.04,8.55 130.48,15.06
+5VS on IN1 (solid shape): 65.88,16.03 65.77,15.92 59.07,15.92 58.58,16.41 58.58,18.2 59.26,18.89 65.88,18.89
+5VS on IN1 (solid shape): outline of 260 points within 211.84,121.12 225.3,127.24
+5VS on IN1 (solid shape): outline of 4147 points within 69.09,13.62 166.25,26.47
+5VS on IN2 (solid shape): outline of 2226 points within 161.97,19.47 243.8,51.83
+5VS on IN3 (solid shape): 213.13,124.75 213.13,123.83 212.97,123.68 211.17,123.68 210.99,123.85 210.99,124.63 211.24,124.87 213.01,124.87
+5VS on IN3 (solid shape): 192.11,134.41 192.62,134.41 193.07,133.97 193.07,133.62 192.59,133.15 191.87,133.15 191.02,134 191.02,134.41 191.3,134.68 191.84,134.68
+5VS on IN4 (solid shape): 63.81,19.15 63.81,18.55 62,16.74 59.91,16.74 59.7,16.96 59.7,18.6 59.97,18.88 61.04,18.88 62.21,20.05 62.91,20.05
+5VS on IN4 (solid shape): 66.98,58.61 66.98,57.31 65.82,56.16 65.82,54.03 66.45,53.41 66.45,49.28 67.44,48.29 67.44,48.29 67.44,46.64 67.05,46.25 66.1,46.25 63.53,48.82 63.53,52.17 63.11,52.59 63.11,56.36 64,57.25 64,58.27 64.76,59.03 66.55,59.03
+5VS on IN4 (solid shape): outline of 318 points within 99.6,131.15 106.09,137.5
+5VS_TP_LED on TOP (solid shape): 173.79,147.02 173.62,146.85 170.49,146.85 168.76,145.12 166.32,145.12 166.13,145.32 166.13,146.52 166.35,146.74 168.1,146.74 169.72,148.36 173.79,148.36
+5VS_TP_LED on BOTTOM (solid shape): 211.79,126.16 211.79,124.93 211.51,124.66 208.98,124.66 208.87,124.77 208.87,125.78 208.95,125.86 210.76,125.86 211.2,126.3 211.65,126.3
+5VS_TP_LED on BOTTOM (solid shape): 203.73,133.61 203.78,133.02 203.94,132.46 203.94,131.73 203.9,131.69 202.88,131.69 202.8,131.78 202.8,133.24 202.83,133.28 202.83,134.09 203,134.25 203.73,134.25
+5VS_TP_LED on IN6 (solid shape): 203.67,133.96 203.67,133.09 203.52,132.94 202.2,132.94 202.09,133.05 202.09,133.98 202.25,134.14 203.49,134.14
+5VS_TP_LED on IN6 (solid shape): 168.8,146.3 168.8,145.37 168.64,145.21 166.47,145.21 166.25,145.43 166.25,146.17 166.56,146.48 168.61,146.48
+DV33_18 on TOP (solid shape): 328.61,23.5 328.61,23.04 328.81,22.85 328.81,21.95 328.39,21.53 328.39,20.65 328.35,20.61 328.21,20.61 328.17,20.65 328.17,21.83 328.26,21.92 328.26,22.57 328,22.83 328,23.45 328.09,23.54 328.58,23.54
+PVDD on BOTTOM (solid shape): 3.04,32.92 3.04,32.91 3.43,32.52 3.43,30.47 3.51,30.39 3.51,28.35 4.22,27.65 4.22,27.54 3.78,27.1 3.69,27.1 2.96,27.83 2.96,29.71 2.73,29.94 2.73,31.88 2.3,32.32 1.48,32.32 1.38,32.43 1.38,33.33 1.55,33.5 2.46,33.5
+PVDD on BOTTOM (solid shape): 7.88,23.98 7.88,20.89 7.81,20.82 7.81,18.46 7.81,17.45 7.66,17.3 6.52,17.3 6.36,17.15 5.63,17.15 5.49,17.01 5.27,17.01 5.17,17.11 5.17,18.1 5.3,18.22 5.91,18.22 7.11,19.43 7.11,20.9 7.2,20.99 7.21,21 7.21,22.28 7.43,22.51 7.43,23.36 6.76,24.02 6.76,24.14 7.19,24.56 7.29,24.56
+PVDD on IN2 (solid shape): 5.77,18.06 5.77,17.14 5.58,16.95 4.13,16.95 3.85,17.23 3.85,17.84 4.2,18.2 5.63,18.2
+PVDD on IN2 (solid shape): 3.14,33.46 3.14,33.15 3.61,32.68 3.61,32.16 3.78,32 3.81,31.96 3.81,31.14 3.75,31.08 3.74,31.08 3.66,31 2.81,31 2.75,31.07 2.75,31.86 2.45,32.15 2.06,32.15 1.82,32.39 1.82,33.48 1.93,33.58 3.02,33.58
+VCC_3IN1 on TOP (solid shape): 303.76,31.4 303.76,27.29 303.32,26.85 303.32,25.98 304.49,24.8 304.51,24.8 305.31,24.01 305.31,23.42 304.78,22.89 304.35,22.89 303.58,23.66 302.65,23.66 302.51,23.8 302.51,24.7 302.01,25.2 302.01,27.77 302.28,28.05 302.28,31.47 302.39,31.58 303.57,31.58
+VCC_3IN1 on IN2 (solid shape): 309.19,20.01 317.38,20.01 320.51,16.88 327.55,16.88 330.31,19.65 330.56,19.65 331.03,19.18 331.03,18.83 327.77,15.57 319.44,15.57 316.64,18.37 308.79,18.37 308.78,18.38 308.53,18.38 303.61,23.3 303.61,23.6 304.37,24.36 304.84,24.36
+VCC_CORE on TOP (solid shape): outline of 3384 points within 93.86,79.34 127.94,117.76
+VCC_CORE on BOTTOM (solid shape): outline of 5298 points within 93.47,79.01 127.64,116.87
+VCC_CORE on IN3 (solid shape): outline of 8398 points within 93.28,79.47 127.95,117.12
+VCC_CORE on IN4 (solid shape): outline of 7196 points within 93.79,79.66 122.62,117.38
+VCC_CORE on IN5 (solid shape): outline of 8055 points within 93.66,79.53 127.83,117.5
+VCC_CORE on IN6 (solid shape): outline of 8436 points within 93.16,78.58 127.94,117.12
+VCC_CORE on VCC: 118.28,79.02 117.52,79.78 98.21,79.78 97.22,80.78 97.22,84.46 95.95,85.73 95.95,101.99 93.54,104.4 93.54,110.16 100.25,116.87 126.58,116.87 128.46,114.98 128.46,108.84 124.4,104.78 124.4,81.79 121.63,79.02
+VCCIO2PCH on TOP (solid shape): 126.2,108.8 127,108.8 127.32,108.49 127.32,107.22 127.13,107.02 123.64,107.02 123.32,107.34 123.32,108.74 123.51,108.93 126.07,108.93
+VDD_TOUCH on TOP (solid shape): 95.05,130.91 96.61,130.91 96.79,130.74 96.79,130.39 95.95,129.55 94.32,129.55 93.76,130.11 93.76,130.42 94.46,131.12 94.85,131.12
+VDD_TOUCH on BOTTOM (solid shape): 95.07,130.84 95.07,130.11 94.76,129.8 93.14,129.8 92.22,128.88 91.66,128.88 91.21,128.43 90.94,128.43 90.4,128.97 90.4,129.15 92.32,131.07 94.85,131.07
+VDDCT_L on TOP (solid shape): 336.52,80.69 336.52,79.86 336.27,79.6 325.76,79.6 325.7,79.66 325.7,80.94 325.84,81.08 336.13,81.08
AGND on TOP (solid shape): 28,11.1 28.01,11.1 28.19,10.91 29.11,10.91 29.32,10.7 29.32,9.83 29.14,9.65 27.62,9.65 27.13,10.14 27.13,11.01 26.98,11.16 26.59,11.16 26.43,11.32 26.41,11.4 26.38,11.46 26.38,11.95 26.49,12.06 27.04,12.06
AGND on TOP (solid shape): 15.69,9.99 15.69,9.55 16.26,8.98 16.26,8.43 15.73,7.9 14.27,7.9 14.16,8.01 14.16,8.47 14.29,8.6 14.73,8.6 14.84,8.7 14.87,8.7 14.87,8.74 14.92,8.79 14.92,9.47 14.59,9.81 14.59,10 14.74,10.15 15.52,10.15
AGND on TOP (solid shape): 20.72,8.95 21.26,8.95 21.33,9.03 21.95,9.03 22.2,8.9 22.46,9.01 22.5,9.05 23.14,9.05 23.22,8.97 23.22,8.52 23,8.3 22.74,8.3 22.72,8.33 22.45,8.52 22.13,8.4 22.06,8.36 21.97,8.37 21.47,8.25 21.61,7.76 21.64,7.74 21.64,6.1 21.63,6.09 21.56,6.03 21.5,5.96 21.31,5.77 19.81,5.77 19.54,6.03 19.54,6.88 19.31,7.11 18.19,7.11 18.11,7.19 18.11,7.94 18.17,8 19.64,8 19.88,8.24 19.88,8.95 19.99,9.06 20.61,9.06
AGND on BOTTOM (solid shape): 15.63,10.01 15.63,9.24 15.31,8.92 13.85,8.92 13.77,8.99 13.77,9.48 13.82,9.53 14.32,9.53 14.36,9.56 14.37,9.57 14.53,9.74 14.55,9.97 14.54,10.01 14.68,10.15 15.5,10.15
AGND on BOTTOM (solid shape): outline of 120 points within 1.68,5.8 6.92,10.9
AGND on GND1: 3.5,4.53 1.21,5.48 0.26,7.78 0.26,17.73 0.26,17.74 0.29,17.74 2.88,15.14 8.3,15.14 9.97,16.81 9.97,18.22 10.64,18.89 13.36,18.89 13.97,18.27 13.97,15.61 14.44,15.14 16.6,15.14 16.7,15.04 16.7,12.62 17.04,12.28 22.08,12.28 22.42,12.62 22.42,14.27 22.52,14.38 24.79,14.38 28.28,10.89 28.92,10.89 29.72,10.08 29.72,7.64 30.43,6.93 30.29,6.62 30.25,6.28 30.25,5.28 30.03,4.75 29.5,4.53 19.79,4.53 19.45,4.61 19.19,4.84 15.32,6.83 11.45,4.84 11.19,4.61 10.84,4.53
AGND on VCC: 3.5,5.55 1.92,6.2 1.27,7.78 1.27,16.75 2.88,15.14 8.3,15.14 9.97,16.81 9.97,18.21 10.65,18.89 13.36,18.89 13.97,18.27 13.97,15.61 14.44,15.14 16.6,15.14 16.7,15.04 16.7,12.62 17.04,12.28 22.08,12.28 22.42,12.62 22.42,14.27 22.52,14.38 24.79,14.38 28.28,10.89 28.92,10.89 29.72,10.08 29.72,7.69 29.36,7.02 29.23,6.28 29.23,5.55 19.93,5.55 15.32,7.85 10.71,5.55
AGND on GND2: 3.5,4.53 1.21,5.48 0.26,7.78 0.26,17.73 0.28,17.73 2.88,15.14 8.3,15.14 9.97,16.81 9.97,18.21 10.65,18.89 13.36,18.89 13.97,18.27 13.97,15.61 14.44,15.14 16.6,15.14 16.7,15.04 16.7,12.62 17.04,12.28 22.08,12.28 22.42,12.62 22.42,14.27 22.52,14.38 24.79,14.38 28.28,10.89 28.92,10.89 29.72,10.08 29.72,7.64 30.43,6.93 30.29,6.62 30.25,6.28 30.25,5.28 30.03,4.75 29.5,4.53 19.79,4.53 19.45,4.61 19.19,4.84 15.32,6.83 11.45,4.84 11.19,4.61 10.84,4.53
AGND on GND3: 3.5,4.53 1.21,5.48 0.26,7.78 0.26,17.77 2.88,15.14 8.3,15.14 9.97,16.82 9.97,18.21 10.64,18.89 13.36,18.89 13.97,18.27 13.97,15.61 14.44,15.14 16.6,15.14 16.7,15.04 16.7,12.62 17.04,12.28 22.08,12.28 22.42,12.62 22.42,14.27 22.52,14.38 24.79,14.38 28.28,10.89 28.92,10.89 29.72,10.08 29.72,7.64 30.43,6.93 30.29,6.62 30.25,6.28 30.25,5.28 30.03,4.75 29.5,4.53 19.79,4.53 19.45,4.61 19.19,4.84 15.32,6.83 11.45,4.84 11.19,4.61 10.84,4.53
GND on TOP (solid shape): 341.25,31.91 341.25,11.59 339.47,11.59 339.47,31.91
GND on TOP (solid shape): 55.37,11.39 55.37,9.23 55.25,9.11 54.29,9.11 53.99,9.41 53.99,11.35 54.17,11.52 55.25,11.52
GND on TOP (solid shape): 97.6,128.09 97.6,127.45 97.2,127.04 96.87,127.04 95.4,128.51 95.4,128.74 96.07,129.41 96.28,129.41
GND on TOP (solid shape): 103.85,84.32 103.85,82.8 103.59,82.54 100.09,82.54 99.91,82.72 99.91,83.99 100.29,84.37 103.8,84.37
GND on TOP (solid shape): 185.86,52.57 185.86,50.13 185.66,49.92 183.15,49.92 182.99,50.08 182.99,52.53 183.24,52.78 185.66,52.78
GND on TOP (solid shape): 197.12,132.81 197.12,131.82 196.99,131.69 194.96,131.69 194.83,131.82 194.83,132.94 195.14,133.25 196.68,133.25
GND on TOP (solid shape): 197.32,53.4 197.32,50.29 197.08,50.05 194.46,50.05 194.1,50.41 194.1,53.34 194.3,53.53 197.19,53.53
GND on TOP (solid shape): 37.85,22.57 37.85,22.13 37.4,21.68 35.69,21.68 35.69,22.32 35.82,22.44 36.39,22.44 36.64,22.7 37.72,22.7
GND on TOP (solid shape): 177.03,52.96 178.68,52.96 178.8,52.84 178.8,49.99 178.69,49.87 176.21,49.87 176.21,52.99 177.03,52.99
GND on TOP (solid shape): 183.83,82.52 183.83,81.27 184.73,80.37 184.73,80.18 184.41,79.85 183.39,79.85 183.2,80.04 183.2,82.51 183.29,82.6 183.75,82.6
GND on TOP (solid shape): 186.76,82.45 186.76,82.13 186.57,81.94 184.47,81.94 184.28,82.13 184.28,82.45 185.36,83.53 185.68,83.53
GND on TOP (solid shape): 223.97,15.71 223.97,14.05 223.74,13.82 222.09,13.82 221.9,14 221.9,14.59 221.69,14.8 221.69,15.76 221.77,15.84 223.84,15.84
GND on TOP (solid shape): 255.15,38.32 255.15,36.29 254.48,35.62 252.95,35.62 252.73,35.84 252.73,36.16 254.07,37.49 254.07,38.32 254.13,38.38 255.08,38.38
GND on TOP (solid shape): 44.2,38.67 44.2,36.1 44.13,36.03 41.59,36.03 41.53,36.1 41.53,38.64 41.59,38.7 44.17,38.7
GND on TOP (solid shape): 334.2,35.66 334.2,33.51 333.97,33.28 332.34,33.28 332.23,33.38 332.23,35.52 332.6,35.88 333.98,35.88
GND on TOP (solid shape): 104.65,117.31 104.65,115.53 104.59,115.47 104.33,115.47 104.27,115.53 104.27,116.42 104.14,116.55 102.87,116.55 102.81,116.61 102.81,117.31 102.94,117.44 104.52,117.44
GND on TOP (solid shape): 145.04,116.94 145.04,116.09 144.81,115.86 143.65,115.86 141.73,113.94 138.92,113.94 138.75,114.11 138.75,115.97 140.08,117.31 142.25,117.31 142.25,117.31 144.68,117.31
GND on TOP (solid shape): 159.67,8.95 159.67,7.22 158.02,5.57 156.15,5.57 155.97,5.75 155.97,6.47 156.14,6.64 157.38,6.64 158.06,7.32 158.06,9.28 158.17,9.4 159.23,9.4
GND on TOP (solid shape): 93.95,120.36 93.95,119.1 92.54,117.68 91.15,117.68 90.44,118.39 90.44,118.62 91.95,120.13 91.95,120.42 92.73,121.19 93.11,121.19
GND on TOP (solid shape): 147.89,109.12 147.89,107.53 148.15,107.28 148.15,105.93 148,105.78 146.57,105.78 146.43,105.92 146.43,106.77 146.62,106.96 146.62,109.06 146.81,109.25 147.77,109.25
GND on TOP (solid shape): 169.47,97.76 169.47,96.49 170.87,95.09 170.87,94.3 170.6,94.03 168.57,94.03 168.34,94.26 168.34,97.7 168.57,97.93 169.29,97.93
GND on TOP (solid shape): 189.55,80.61 189.55,80.16 189.36,79.97 188.53,79.97 187.58,79.02 187.33,79.02 186.25,80.1 186.25,80.35 186.37,80.48 188.28,80.48 188.47,80.67 189.49,80.67
GND on TOP (solid shape): 259.94,10.13 259.94,4.71 259.77,4.55 252.81,4.55 252.71,4.65 252.71,9.89 253.88,11.06 259.01,11.06
GND on TOP (solid shape): 267.2,8.28 267.97,8.28 268.51,7.75 268.51,6.59 268.25,6.34 266.66,6.34 266.47,6.53 266.47,7.55 266.16,7.86 266.16,8.47 266.22,8.53 266.95,8.53
GND on TOP (solid shape): 311.04,29.97 311.04,27.88 310.96,27.79 309.2,27.79 309.07,27.92 309.07,29.89 309.22,30.04 310.97,30.04
GND on TOP (solid shape): 104.86,65.16 104.86,62.19 105.82,61.24 107.06,61.24 107.84,60.47 107.84,52.06 107.62,51.84 96.13,51.84 93.2,54.76 93.2,64.2 93.32,64.32 97.76,64.32 98.97,65.53 104.49,65.53
GND on TOP (solid shape): 146.62,34.24 146.62,29.33 146.28,28.99 146.28,26.97 146.19,26.88 144.62,26.88 143.74,27.76 143.74,32.19 144.11,32.56 145.15,32.56 145.43,32.84 145.43,34.25 145.58,34.41 146.46,34.41
GND on TOP (solid shape): 231.77,8.56 231.77,6.72 230.7,5.65 228.75,5.65 228.66,5.74 228.66,6.69 228.79,6.82 230.24,6.82 230.65,7.22 230.65,8.19 230.22,8.62 230.22,9.26 230.26,9.31 231.02,9.31
GND on TOP (solid shape): 168.1,54.49 168.1,53.15 168.43,52.82 169.51,52.82 169.6,52.73 169.6,51.34 169.45,51.18 167.64,51.18 167.38,51.45 167.38,52.25 166.64,52.99 166.64,54.41 166.8,54.57 168.01,54.57
GND on TOP (solid shape): 55.81,17.54 55.81,15.48 55.84,15.42 55.84,15.25 55.81,15.19 55.81,15.16 55.74,15.1 55.29,15.1 55.27,15.07 54.31,15.07 54.2,15.18 54.2,17.64 54.35,17.79 55.56,17.79
GND on TOP (solid shape): 173.36,93.82 173.67,93.82 174.37,94.52 174.56,94.52 174.75,94.32 174.75,92.23 174.56,92.04 174.31,92.04 173.93,92.42 173.93,92.67 173.61,92.99 172.21,92.99 172.09,93.12 172.09,94.2 172.4,94.52 172.66,94.52
GND on TOP (solid shape): 182.01,8.43 182.01,6.31 181.29,5.59 179.28,5.59 179.11,5.76 179.11,6.59 179.2,6.69 180.67,6.69 180.86,6.87 180.86,8.37 180.69,8.53 180.39,8.53 180.3,8.62 180.3,9.21 180.48,9.39 181.04,9.39
GND on TOP (solid shape): 193.95,86.62 194.14,86.62 194.28,86.48 194.28,85.51 193.85,85.08 193.26,85.08 193.21,85.08 193.17,85.08 192.84,85.08 192.74,85.17 192.74,86.49 192.75,86.49 192.75,86.77 192.81,86.83 193.74,86.83
GND on TOP (solid shape): 208.07,8.91 208.07,6.19 207.51,5.62 205.34,5.62 205.14,5.82 205.14,6.55 205.36,6.77 206.8,6.77 206.98,6.95 206.98,7.41 207.02,7.44 207.02,8.29 206.98,8.32 206.98,9.26 207.08,9.36 207.62,9.36
GND on TOP (solid shape): 226.09,103.33 228.69,103.33 228.81,103.21 228.81,102.55 228.67,102.41 227,102.41 226.65,102.06 219.97,102.06 219.88,102.15 219.88,102.62 219.92,102.66 221.32,102.66 222,103.33 225.53,103.33 225.63,103.43 225.99,103.43
GND on TOP (solid shape): 231.98,92.23 231.98,66.02 231.73,65.77 230.69,65.77 230.39,66.08 230.39,81.09 230.49,81.19 230.49,89.37 231.23,90.11 231.23,92.25 231.42,92.44 231.77,92.44
GND on TOP (solid shape): 242.46,46.82 242.46,46.65 242.38,46.57 241.43,46.57 241.18,46.32 241.18,44.29 238.7,44.29 238.7,46.76 241.18,46.76 241.27,46.86 241.28,46.86 241.35,46.9 241.41,46.95 242.33,46.95
GND on TOP (solid shape): 217.1,104.17 217.1,103.67 217.34,103.43 218.49,103.43 218.66,103.27 218.66,103.04 217.84,102.22 214.49,102.22 214.35,102.36 214.35,103.4 214.16,103.59 212.11,103.59 211.37,102.85 210.14,102.85 209.7,103.28 209.7,104.23 209.84,104.37 216.89,104.37
GND on TOP (solid shape): 63.76,14.44 63.76,13.11 63.18,12.54 63.06,12.54 62.17,11.65 61.47,11.65 61.41,11.71 61.41,12.66 61.18,12.89 59.09,12.89 58.83,12.64 58.36,12.64 58.23,12.77 58.23,14.08 58.3,14.15 58.85,14.15 58.94,14.06 62.42,14.06 62.93,14.57 63.63,14.57
GND on TOP (solid shape): 175.7,89.36 175.7,89.17 174.77,88.24 174.77,88.15 174.65,88.04 174.31,88.04 173.67,88.67 173.23,88.67 172.98,88.42 172.98,87.15 172.85,87.02 170.63,87.02 170.56,87.09 170.56,87.53 170.63,87.59 171.64,87.59 171.89,87.85 171.89,89.3 172.1,89.5 175.56,89.5
GND on TOP (solid shape): 125.04,64.69 126.52,64.69 131.29,59.92 131.29,50.49 128.51,47.7 126.87,47.7 126.54,47.37 121.1,47.37 118.73,49.74 118.73,50.79 118.8,50.85 125.55,50.85 126.12,51.41 126.12,54.25 122.69,57.68 122.69,65.1 122.87,65.28 124.46,65.28
GND on TOP (solid shape): 130.88,128.04 130.88,119.92 130.69,119.72 129.48,119.72 129.1,120.11 129.1,122.53 128.75,122.88 127.68,122.88 127.48,123.07 127.48,125.9 127.66,126.07 129.1,126.07 129.35,126.33 129.35,127.41 128.97,127.79 124.91,127.79 124.65,128.04 124.65,131.22 124.78,131.35 127.57,131.35
GND on TOP (solid shape): 177.75,95.89 177.75,95.47 178.76,94.46 178.76,94.14 178.59,93.97 178.35,93.97 178.14,94.17 177.09,94.17 176.96,94.3 176.96,95.36 176.71,95.61 176.26,95.61 175.64,94.99 175.36,94.99 175.22,95.13 175.22,95.36 175.52,95.65 175.52,95.8 175.92,96.2 177.44,96.2
GND on TOP (solid shape): 221.52,48.03 221.52,47.92 221.72,47.72 221.85,47.72 222.01,47.55 222.01,46.76 221.28,46.03 220.97,46.03 220.88,46.08 220.78,46.1 220.75,46.1 220.6,46.26 220.6,48.05 220.71,48.16 221.39,48.16
GND on TOP (solid shape): 117.65,94.09 117.65,92.96 118.58,92.03 118.58,86.67 119.14,86.1 120.05,86.1 120.75,85.41 120.75,84.49 119.65,83.4 107.57,83.4 107.38,83.59 107.38,85.36 108.02,86 108.02,92.39 108.17,92.54 112.96,92.54 113.54,93.12 113.54,94.02 113.98,94.46 117.28,94.46
GND on TOP (solid shape): 167.08,25.83 167.08,21.89 167.08,21.88 167.06,21.76 167.08,21.64 167.09,21.6 166.56,21.06 166.08,21.06 165.73,21.41 164.42,21.41 164.36,21.47 164.36,22.4 164.51,22.54 165.85,22.54 166.05,22.75 166.05,25.84 166.22,26.01 166.91,26.01
GND on TOP (solid shape): 183.9,88.42 183.9,85.12 183.77,84.99 183.39,84.99 182.95,85.43 182.95,85.69 182.63,86.01 182.37,86.01 182.25,86.13 182.25,86.45 182.37,86.58 182.38,86.58 182.81,87.01 182.82,87.03 182.85,87.06 182.85,87.47 182.25,88.07 182.25,88.36 182.4,88.51 183.81,88.51
GND on TOP (solid shape): 52.39,38.13 52.39,37.43 53.15,36.67 55.56,36.67 55.69,36.54 55.69,35.71 56.01,35.4 56.9,35.4 57.08,35.22 57.08,34.68 56.9,34.51 55.37,34.51 55.25,34.38 50.74,34.38 50.48,34.63 50.48,37.05 50.61,37.17 51.5,37.17 51.75,37.43 51.75,38.13 51.82,38.19 52.33,38.19
GND on TOP (solid shape): 173.74,83.4 173.74,83.09 173.48,82.83 173.29,82.83 173.04,82.58 173.04,81.88 173.29,81.62 173.67,81.62 173.8,81.5 173.8,81.12 173.67,80.99 171.39,80.99 171.26,81.12 171.26,81.43 171.45,81.62 171.77,81.62 171.96,81.82 171.96,82.58 171.52,83.02 171.35,83.02 171.26,83.11 171.26,83.39 171.4,83.53 173.61,83.53
GND on TOP (solid shape): 138.8,128.91 138.8,128.81 137.64,127.64 137.64,127.51 137.7,127.45 137.69,127.45 138.23,126.91 138.24,126.91 138.6,126.55 138.6,126.08 138.88,125.79 138.88,125.73 137.95,124.8 137.86,124.8 137.61,125.06 137.2,125.06 136.83,124.69 136.73,124.69 135.25,126.16 135.25,127.22 136.79,128.76 137.1,128.76 137.1,128.77 137.32,128.77 138.02,129.46 138.26,129.46
GND on TOP (solid shape): 176.91,89.56 176.91,89.05 177.29,88.67 177.68,88.67 177.8,88.55 177.8,85.18 177.61,84.99 177.29,84.99 176.98,85.31 176.98,85.69 176.66,86.01 176.41,86.01 176.26,86.16 176.26,86.41 176.43,86.58 176.79,86.58 177.04,86.83 177.04,87.34 176.21,88.17 176.21,89.56 176.28,89.63 176.85,89.63
GND on TOP (solid shape): 189.55,92.99 189.55,91.59 189.49,91.53 188.85,91.53 188.72,91.66 188.37,91.66 188.14,91.43 188.14,90.97 188.72,90.39 188.72,90.13 188.6,90.01 186.44,90.01 186.25,90.2 186.25,90.45 186.85,91.05 186.86,91.07 186.86,91.56 186.25,92.17 186.25,92.36 186.44,92.55 188.28,92.55 188.79,93.05 188.83,93.1 189.44,93.1
GND on TOP (solid shape): 155.77,41.98 155.77,39.65 155.96,39.46 155.96,35.4 155.87,35.31 155.22,35.31 155.15,35.38 155.15,35.99 155.39,36.22 155.39,39.21 154.92,39.68 151.51,39.68 151.41,39.78 151.41,40.82 151.16,41.06 149.96,41.06 149.86,40.96 149.86,40.78 149.82,40.74 149.24,40.74 149.1,40.88 149.1,42.15 149.46,42.51 155.23,42.51
GND on TOP (solid shape): 152.14,100.9 152.14,95.46 152.39,95.21 153.73,95.21 153.97,95.45 153.97,96.42 154.13,96.59 154.86,96.59 154.99,96.46 154.99,94.23 154.82,94.06 154.55,94.06 153.88,93.39 150.33,93.39 150.08,93.64 150.08,98.75 149.91,98.93 149.91,100.75 150.18,101.02 152.03,101.02
GND on TOP (solid shape): 105.26,14.4 118.23,14.4 118.48,14.15 118.48,12.33 118.62,12.19 118.62,11.33 118.42,11.13 118.16,11.13 118.02,11.27 118.02,11.72 117.35,12.39 115.79,12.39 115.43,12.76 114.93,12.76 114.27,12.1 109.89,12.1 109.78,12.21 109.78,12.85 109.78,12.86 109.78,13.15 109.58,13.35 105.07,13.35 104.74,13.68 103.53,13.68 103.43,13.78 103.43,14.57 103.55,14.68 104.98,14.68
GND on TOP (solid shape): 176.91,84.29 176.91,80.04 176.66,79.78 176.21,79.78 175.9,79.47 175.9,78.64 175.76,78.5 175.36,78.5 175.14,78.27 175.13,78.27 175.13,77.86 175.29,77.7 175.64,77.7 175.69,77.66 175.69,76.8 175.61,76.72 174.81,76.72 174.68,76.85 174.17,76.85 174.07,76.95 174.07,78.23 174.39,78.55 174.39,78.55 174.88,79.04 174.88,79.59 175.15,79.86 175.15,84.59 175.23,84.67 176.53,84.67
GND on TOP (solid shape): 27.32,32.38 27.32,31.63 27.82,31.13 32.45,31.13 32.64,30.94 32.64,29.55 32.83,29.36 34.42,29.36 34.67,29.62 34.67,29.94 34.8,30.06 35.94,30.06 36.07,29.94 36.07,27.71 35.88,27.52 34.04,27.52 33.4,26.89 33.4,25.24 33.09,24.92 29.97,24.92 29.85,25.05 29.85,26.63 28.61,27.87 28.29,27.87 27.44,28.72 27.43,28.74 27.43,31.02 26.97,31.48 26.38,31.48 26.18,31.68 26.18,32.43 26.29,32.54 27.16,32.54
GND on TOP (solid shape): 339,61.4 339.53,61.18 339.75,60.65 339.75,57.85 339.53,57.32 339,57.11 329.32,57.11 328.93,57.49 328.93,61.18 329.15,61.4
GND on TOP (solid shape): 112.97,130.71 112.97,127.14 113.16,126.95 113.16,126.03 113.12,125.99 113.12,123.5 112.81,123.19 112.81,122.23 113.1,121.95 113.41,121.95 113.6,121.76 113.6,120.23 113.48,120.11 112.46,120.11 111.51,121.06 111.51,122.36 111.51,122.37 111.55,122.52 111.51,122.67 111.51,122.68 111.51,122.77 111.39,122.89 110.76,122.89 110.59,123.05 110.59,125.99 110.81,126.2 111.13,126.2 111.38,126.46 111.38,126.96 111.57,127.15 111.57,127.85 111.25,128.17 109.31,128.17 109.05,127.91 107.84,127.91 107.72,128.03 107.72,131.2 107.8,131.28 112.4,131.28
GND on TOP (solid shape): 121.03,129.9 121.03,126.65 121.22,126.46 121.41,126.46 121.54,126.33 121.54,123.22 121.16,122.84 121.16,122.14 121.22,122.07 121.54,122.07 121.67,121.95 121.67,120.42 121.54,120.3 120.59,120.3 120.21,120.68 120.21,122.52 119.89,122.84 119.82,122.84 119.81,122.85 119.57,122.94 119.34,122.85 119.32,122.84 119.24,122.84 119.22,122.85 119.13,122.91 119.03,122.94 119,122.96 119,125.88 119,125.89 119,125.94 119.17,126.1 119.59,126.1 119.83,126.34 119.83,127.79 119.45,128.17 118.11,128.17 117.73,127.79 116.21,127.79 115.95,128.04 115.95,131.22 119.71,131.22
GND on TOP (solid shape): 19.43,19.14 19.43,18 19.48,17.96 21.87,17.96 22.01,18.1 22.01,19.14 22.08,19.2 22.16,19.2 22.23,19.14 22.23,18.06 22.29,18 22.29,15.2 22.38,15.11 23.47,15.11 23.53,15.05 23.53,14.96 23.46,14.89 22.42,14.89 22.29,14.76 22.29,12.45 22.28,12.44 16.78,12.44 16.77,12.45 16.77,15.14 16.61,15.29 15.59,15.29 15.53,15.35 15.53,15.46 15.59,15.52 16.64,15.52 16.77,15.65 16.77,16.35 16.61,16.5 15.59,16.5 15.53,16.56 15.53,16.6 15.53,16.67 15.52,16.75 15.52,17.03 15.6,17.11 16.64,17.11 16.77,17.24 16.77,19.1 16.87,19.2 17.37,19.2 17.44,19.14 17.44,18.02 17.5,17.96 19.14,17.96 19.22,18.04 19.22,19.14 19.28,19.2 19.37,19.2
GND on TOP (solid shape): 180.9,67.81 182.19,67.81 182.35,67.97 182.56,67.97 182.7,67.84 182.7,67.43 182.9,67.23 183.77,67.23 183.89,67.11 183.89,66.5 183.81,66.41 179.14,66.41 179.04,66.51 179.04,67.12 179.1,67.18 179.96,67.18 180,67.22 180.85,67.22 180.85,67.17 180.86,67.12 180.87,67.07 180.9,67.02 180.93,66.98 180.96,66.95 181.01,66.92 181.05,66.89 181.1,66.88 181.15,66.87 181.21,66.87 181.26,66.88 181.31,66.89 181.35,66.92 181.4,66.95 181.43,66.98 181.46,67.02 181.49,67.07 181.5,67.12 181.51,67.17 181.51,67.22 181.5,67.28 181.49,67.32 181.46,67.37 181.43,67.41 181.4,67.45 181.35,67.48 181.31,67.5 181.26,67.52 181.21,67.53 181.15,67.53 181.1,67.52 181.05,67.5 181.01,67.48 180.96,67.45 180.93,67.41 180.9,67.37 180.87,67.32 180.86,67.28 180.85,67.22 180,67.22 180.13,67.35 180.13,68.07 180.3,68.24 180.47,68.24
GND on TOP (solid shape): 339.8,92.52 340.33,92.3 340.55,91.78 340.55,77.55 340.47,77.38 340.3,77.31 339.4,77.31 338.87,77.09 338.65,76.55 338.65,75.65 338.57,75.48 338.4,75.41 329.5,75.41 329.25,75.66 329.25,75.67 329.18,75.74 329.18,76.7 329.6,77.12 336.78,77.12 338.56,78.89 338.56,90.52 338.35,90.73 333.9,90.73 333.74,90.89 333.74,92.36 333.9,92.52
GND on TOP (solid shape): 189.49,86.96 189.49,81.94 189.36,81.82 188.57,81.82 188.26,82.13 188.26,82.37 188.85,82.96 188.85,83.47 188.22,84.1 186.7,84.1 186.63,84.04 186.38,84.04 186.25,84.17 186.25,84.61 186.37,84.74 186.82,84.74 187.01,84.93 187.01,85.3 188.14,85.3 188.14,85.25 188.15,85.2 188.16,85.14 188.19,85.1 188.22,85.05 188.25,85.01 188.3,84.98 188.34,84.95 188.39,84.93 188.45,84.92 188.5,84.91 188.56,84.92 188.61,84.93 188.66,84.95 188.71,84.98 188.75,85.01 188.79,85.05 188.82,85.1 188.84,85.14 188.86,85.2 188.86,85.25 188.86,85.3 188.86,85.36 188.84,85.41 188.82,85.46 188.79,85.5 188.75,85.54 188.71,85.58 188.66,85.6 188.61,85.62 188.56,85.64 188.5,85.64 188.45,85.64 188.39,85.62 188.34,85.6 188.3,85.58 188.25,85.54 188.22,85.5 188.19,85.46 188.16,85.41 188.15,85.36 188.14,85.3 187.01,85.3 187.01,85.82 186.82,86.01 186.37,86.01 186.25,86.13 186.25,86.32 186.44,86.51 188.28,86.51 188.85,87.09 189.36,87.09
GND on TOP (solid shape): 185.74,96.1 185.74,95.52 185.71,95.5 185.71,95.16 184.89,94.34 184.89,89 184.78,88.89 184.23,88.89 184.05,89.06 184.05,89.89 183.96,89.98 183.36,89.98 183.23,90.11 183.23,90.28 183.23,90.28 183.23,93.5 184.88,95.14 184.88,95.39 184.85,95.42 184.85,95.53 184.72,95.66 184.28,95.66 184.24,95.62 184.21,95.62 182.62,94.03 182.38,94.03 182.21,94.21 182.21,94.38 183.03,95.2 183.03,95.41 182.82,95.63 182.78,95.63 182.76,95.66 182.37,95.66 182.35,95.63 182.31,95.63 181.08,94.4 181.08,93.95 180.79,93.66 180.79,78.68 180.68,78.57 179.78,78.57 179.14,79.21 179.14,79.21 178.91,79.44 178.91,83.18 179.9,84.16 179.9,84.43 179.26,85.07 179.26,85.4 179.92,86.06 179.92,86.52 179.29,87.16 179.29,87.42 179.86,87.99 179.86,88.43 179.01,89.28 179.01,93.21 179.47,93.67 180.03,93.67 180.37,94 180.37,94.81 180.49,94.94 180.5,94.94 180.81,95.25 180.81,95.54 180.72,95.63 180.72,96.1 180.79,96.17 185.68,96.17
GND on TOP (solid shape): 198.4,44.47 198.4,34.18 197.52,33.31 190.52,33.31 190.39,33.44 190.39,38.39 192.36,38.39 192.46,38.34 192.49,38.24 192.66,37.88 193.06,37.91 193.14,37.94 193.22,37.91 193.8,38.19 193.22,38.47 193.14,38.44 193.06,38.47 192.96,38.52 192.85,38.55 192.76,38.59 192.73,38.67 192.73,42.16 192.88,42.31 194.41,42.31 194.81,42.71 194.81,43.88 194.65,44.03 194.38,44.03 194.19,44.22 194.19,44.86 194.45,45.13 197.74,45.13
GND on TOP (solid shape): 134.4,150.02 134.57,149.95 134.65,149.78 134.65,148.43 134.67,148.24 134.74,148.06 135.02,147.78 135.4,147.67 137.54,147.67 137.71,147.6 137.78,147.43 137.78,143.55 138.62,142.71 138.62,139.28 137.54,138.2 136.08,138.2 134.24,140.04 133.1,140.04 132.37,139.31 132.37,137.85 132.02,137.5 130.81,137.5 130.43,137.89 130.43,140.87 130.63,141.07 131.8,141.07 132.54,141.7 132.05,142.54 132.05,149.28 132.27,149.8 132.8,150.02
GND on TOP (solid shape): outline of 106 points within 175.2,32.54 182.89,43.61
GND on TOP (solid shape): outline of 81 points within 166.5,65.93 176.13,84.99
GND on TOP (solid shape): outline of 198 points within 146.56,125.17 151.88,134.27
GND on TOP (solid shape): outline of 138 points within 30.73,0.25 341.75,43.1
GND on TOP (solid shape): outline of 170 points within 0.25,37.79 118.62,150.02
GND on TOP (solid shape): outline of 982 points within 146.43,38.52 319.1,150.02
GND on BOTTOM (solid shape): 341.25,31.91 341.25,11.59 339.47,11.59 339.47,31.91
GND on BOTTOM (solid shape): 88.06,13.68 88.06,8.55 85.64,8.55 85.64,13.59 85.85,13.8 87.94,13.8
GND on BOTTOM (solid shape): 9.25,20.72 9.25,18.63 9.15,18.54 8.1,18.54 7.95,18.69 7.95,20.68 8.07,20.81 9.15,20.81
GND on BOTTOM (solid shape): 62.36,28.67 62.36,25.68 60.39,23.71 52.71,23.71 52.71,28.98 62.04,28.98
GND on BOTTOM (solid shape): 72.97,49.47 72.97,44.77 72.8,44.6 71.51,44.6 71.41,44.71 71.41,49.62 71.47,49.69 72.76,49.69
GND on BOTTOM (solid shape): 119.59,45.21 119.59,44.38 119.33,44.12 102.42,44.12 102.27,44.27 102.27,46.08 102.6,46.41 118.39,46.41
GND on BOTTOM (solid shape): 120.59,108.68 120.59,106.71 120.02,106.14 117.22,106.14 116.84,106.52 116.84,108.87 117.29,109.31 119.95,109.31
GND on BOTTOM (solid shape): 138.64,93.71 138.64,92.18 138.33,91.87 135.35,91.87 135.11,92.12 135.11,93.72 135.33,93.94 138.4,93.94
GND on BOTTOM (solid shape): 140.48,97.9 140.48,90.79 140.31,90.63 139.17,90.63 139,90.79 139,97.88 139.21,98.09 140.29,98.09
GND on BOTTOM (solid shape): 181.55,57.24 181.55,54.1 181.21,53.76 179.12,53.76 178.99,53.88 178.99,57.19 179.13,57.32 181.47,57.32
GND on BOTTOM (solid shape): 184.09,18.98 184.09,17.35 183.95,17.21 181.89,17.21 181.66,17.44 181.66,19.27 181.73,19.33 183.73,19.33
GND on BOTTOM (solid shape): 227.01,102.57 227.01,102.11 226.86,101.96 223.69,101.96 223.12,102.53 223.12,103.2 223.33,103.42 226.16,103.42
GND on BOTTOM (solid shape): 247.63,19.44 247.63,17.77 247.37,17.5 244.95,17.5 244.7,17.76 244.7,19.42 244.8,19.52 247.55,19.52
GND on BOTTOM (solid shape): 316.78,42.87 316.78,41.61 316.33,41.16 314.51,41.16 314.3,41.37 314.3,42.78 314.48,42.96 316.69,42.96
GND on BOTTOM (solid shape): 58.04,9.87 58.04,8.55 56.33,8.55 56.33,9.43 55.88,9.87 55.88,10.12 55.95,10.19 57.72,10.19
GND on BOTTOM (solid shape): 322.9,71.4 322.9,70.39 322.84,70.32 319.41,70.32 319.28,70.45 319.28,71.18 319.32,71.38 319.41,71.46 322.84,71.46
GND on BOTTOM (solid shape): 21.91,36.86 21.91,35.21 21.47,34.76 18.54,34.76 18.16,35.14 18.16,36.73 18.61,37.17 21.59,37.17
GND on BOTTOM (solid shape): 62.55,24.79 69.6,24.79 69.66,24.73 69.66,23.97 69.53,23.84 62.04,23.84 61.79,24.09 61.79,24.79 62.04,25.05 62.3,25.05
GND on BOTTOM (solid shape): 64.47,58.57 64.47,57.2 64.35,57.09 63.12,57.09 62.94,57.27 62.94,58.04 63.51,58.61 64.43,58.61
GND on BOTTOM (solid shape): 148.21,109.12 148.21,105.98 148.07,105.84 146.75,105.84 146.62,105.96 146.62,109.13 146.79,109.29 148.03,109.29
GND on BOTTOM (solid shape): 171.64,57.24 171.64,54.45 171.52,54.33 168.54,54.33 168.34,54.53 168.34,56.99 168.68,57.32 171.55,57.32
GND on BOTTOM (solid shape): 316.19,59.17 317.36,59.17 317.46,59.07 317.46,58.2 317.42,58.16 315.57,58.16 315.39,58.33 315.39,59.11 315.6,59.31 316.05,59.31
GND on BOTTOM (solid shape): 323.88,42.29 323.88,41.08 323.34,40.54 320.99,40.54 320.55,40.98 320.55,42.25 320.87,42.57 323.6,42.57
GND on BOTTOM (solid shape): 8.11,16.99 8.11,16.45 8.34,16.22 8.34,15.92 7.89,15.48 6.61,15.48 6.48,15.61 6.48,16.93 6.64,17.09 8.01,17.09
GND on BOTTOM (solid shape): 48.45,18.32 48.45,17.48 48.27,17.3 45.79,17.3 45.4,17.68 45.4,18.25 47.69,18.25 47.9,18.46 48.32,18.46
GND on BOTTOM (solid shape): 49.85,18.19 51.19,18.19 51.22,18.17 51.22,17.66 49.93,17.66 49.6,17.32 49.26,17.32 49.15,17.42 49.15,18.32 49.28,18.44 49.6,18.44
GND on BOTTOM (solid shape): 83.35,43.61 83.94,43.61 84.09,43.46 84.09,42.28 83.82,42.01 82.31,42.01 81.9,42.42 81.49,42.42 81.38,42.53 81.38,43.94 81.42,43.98 82.99,43.98
GND on BOTTOM (solid shape): 138.79,47.25 138.79,46.79 138.91,46.68 140.13,46.68 140.28,46.53 140.28,44.42 140.12,44.26 136.45,44.26 136.31,44.4 136.31,47.32 136.64,47.65 138.39,47.65
GND on BOTTOM (solid shape): 157.53,100.32 157.53,98.74 156.93,98.15 150.18,98.15 149.99,98.34 149.99,100.05 150.29,100.34 153.86,100.34 154.53,101.02 156.83,101.02
GND on BOTTOM (solid shape): 158.16,53.85 158.16,47.99 156.84,46.67 155.62,46.67 155.08,47.21 155.08,50.66 154.71,51.03 154.71,53.84 155.08,54.21 157.8,54.21
GND on BOTTOM (solid shape): 160.47,94.2 160.47,93.25 159.07,91.85 157.99,91.85 157.23,92.61 151.84,92.61 151.75,92.7 151.75,93.82 151.94,94.01 159.2,94.01 159.51,94.32 160.34,94.32
GND on BOTTOM (solid shape): 163.17,49.32 163.17,46.01 162.97,45.82 160.19,45.82 159.86,46.15 159.86,46.7 159.71,46.85 159.71,49.15 160.34,49.78 162.7,49.78
GND on BOTTOM (solid shape): 195.7,49.37 198.1,49.37 198.19,49.27 198.19,47.13 197.89,46.83 194.12,46.83 193.79,47.16 193.79,49.74 193.88,49.83 195.23,49.83
GND on BOTTOM (solid shape): 217.93,51.58 217.93,51.02 217.87,50.95 217.3,50.95 217.11,50.76 216.85,50.76 216.66,50.95 216.22,50.95 216.09,51.08 216.09,51.59 216.17,51.67 217.85,51.67
GND on BOTTOM (solid shape): 324.09,56.42 324.09,54.71 323.67,54.29 321.5,54.29 321.29,54.5 321.29,56.34 321.45,56.5 324.01,56.5
GND on BOTTOM (solid shape): 259.94,10.13 259.94,4.68 259.81,4.55 252.82,4.55 252.71,4.66 252.71,9.89 253.88,11.06 259.01,11.06
GND on BOTTOM (solid shape): 101,130.24 101,128.11 99.4,126.51 98.67,126.51 96.75,128.44 96.75,129.06 97.85,130.16 98.7,130.16 99.07,129.79 99.61,129.79 100.28,130.46 100.78,130.46
GND on BOTTOM (solid shape): 123.68,49.6 123.68,48.99 124.64,48.04 125.32,48.04 125.46,47.9 125.46,46.47 125.3,46.31 124.57,46.31 124.21,45.95 122.54,45.95 122.01,46.47 122.01,49.71 122.19,49.88 123.41,49.88
GND on BOTTOM (solid shape): 173.68,62.19 176.05,62.19 176.11,62.14 176.11,59.36 176.06,59.31 173.15,59.31 172.86,59.6 172.86,62.27 173.07,62.48 173.4,62.48
GND on BOTTOM (solid shape): 83.47,117.49 83.47,116.88 82.31,115.72 82.31,115.23 81.86,114.78 80.81,114.78 80.58,115.01 80.58,116.11 80.8,116.33 82.63,118.16 82.8,118.16
GND on BOTTOM (solid shape): 94.1,129.43 94.1,129.03 93.2,128.13 92.12,128.13 91.82,127.84 91.62,127.84 91.39,128.07 91.39,128.31 91.77,128.68 92.27,128.68 93.24,129.65 93.88,129.65
GND on BOTTOM (solid shape): 217.81,103.46 218.9,103.46 219.75,102.61 219.75,102.22 219.61,102.08 218.52,102.08 217.72,101.28 217.25,101.28 217.1,101.44 217.1,102.85 216.99,102.95 216.33,102.95 215.69,103.6 215.69,104.17 215.84,104.32 216.94,104.32
GND on BOTTOM (solid shape): 155.39,80.86 155.39,80.16 155.13,79.91 155.13,78.58 154.75,78.2 152.91,78.2 152.66,78.45 152.66,79.9 152.78,80.02 153.41,80.02 153.67,80.28 153.67,80.82 153.84,80.99 155.26,80.99
GND on BOTTOM (solid shape): 200.22,68.62 200.2,68.6 200.2,68.39 199.92,68.11 198.45,68.11 198.27,68.28 197.89,68.28 197.89,68.42 198.05,68.58 199.75,68.58 199.87,68.7 200.19,68.7
