# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT8813AGQW_WQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.515x2.515 smd: 25(1.25,1.975)
RT9041E-15GQW_WDFN8_2X2
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.15) 6(1,2.15) 7(0.5,2.15) 8(0,2.15)
  rect 1.118x0.533 smd: 9(0.75,1.075)
RTS5227-GR_QFN32_4X4
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.1) 18(2.4,4.1) 19(2,4.1) 20(1.6,4.1) 21(1.2,4.1) 22(0.8,4.1) 23(0.4,4.1) 24(0,4.1)
  oval 0.889x0.203 smd: 9(3.45,0.65) 10(3.45,1.05) 11(3.45,1.45) 12(3.45,1.85) 13(3.45,2.25) 14(3.45,2.65) 15(3.45,3.05) 16(3.45,3.45) 25(-0.65,3.45) 26(-0.65,3.05) 27(-0.65,2.65) 28(-0.65,2.25) 29(-0.65,1.85) 30(-0.65,1.45) 31(-0.65,1.05) 32(-0.65,0.65)
  rect 2.692x2.692 smd: 33(1.4,2.05)
S-5711ACDL-M3T1S_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SANTA_130456-511_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(13.095,-6.42) 16(-5.955,-6.42)
  rect 0.889x1.803 smd: 15(12.32,-9.92) 17(-5.18,-9.92)
SDM10U45-7_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2301CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI7170DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SI7326DN-T1-E3_PAK1212-8
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SN74CBT3257CPWR_TSSOP16
  oval 0.381x1.651 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(4.55,5.775) 10(3.9,5.775) 11(3.25,5.775) 12(2.6,5.775) 13(1.95,5.775) 14(1.3,5.775) 15(0.65,5.775) 16(0,5.775)
SN74LVC1G06DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002F_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STARC_107K30-000001-G2_30P
  round 1.092 hole 1.092 unplated: (-2.3,-1.95) (16.8,-1.95)
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 1.549x3.404 smd: 31(-4.125,-5.85) 32(18.625,-5.85)
  rect 2.007x6.198 smd: 33(3.5,-7.65) 34(11,-7.65) 35(-2,-7.65) 36(16.5,-7.65)
STARC_111H20-100000-G2-R_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 24(11.9,1.95)
  rect 2.311x1.295 smd: 22(0.85,3.9) 23(8.65,3.9)
SW_SMT1-05-A_4P
  rect 0.61x0.991 smd: 1(0,0) 2(0,-4.4) 3(3.7,0) 4(3.7,-4.4)
  rect 0.457x0.991 smd: 5(-0.675,-2.2) 6(4.375,-2.2)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8036DBC_DFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.388x1.575 smd: 11(1,1.55)
T-SOL_143-2300302602_22P_RV
  round 1.194 hole 1.194 unplated: (0.5,-2.69) (20.5,-2.69)
  oval 0.508x1.854 smd: 1(0,0) 2(0.76,0) 3(1.52,0) 4(2.28,0) 5(3.8,0) 6(4.56,0) 7(5.32,0) 8(6.84,0) 9(7.6,0) 10(8.36,0) 11(9.12,0) 12(9.88,0) 13(11.4,0) 14(12.16,0) 15(12.92,0) 16(14.44,0) 17(15.2,0) 18(16.72,0) 19(19,0) 20(19.76,0) 21(20.52,0) 22(21.28,0)
  oval 1.092x2.997 hole 0.508x1.803: 23(-6.6,-23.63) 24(22.7,-23.63)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SZ14FU_SSOP5
  oval 0.381x1.448 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.675) 5(0,1.675)
TDK_MMZ1608R301AT_2P
  rect 0.61x0.787 smd: 1(0,0) 2(1.4,0)
TE_2260531-1_46P-T
  oval 0.508x1.803 smd: 1(0,0) 2(0.8,0) 45(18.6,0) 46(19.4,0)
  oval 0.203x1.803 smd: 3(1.55,0) 4(1.95,0) 5(2.35,0) 6(2.75,0) 7(3.15,0) 8(3.55,0) 9(3.95,0) 10(4.35,0) 11(4.75,0) 12(5.15,0) 13(5.55,0) 14(5.95,0) 15(6.35,0) 16(6.75,0) 17(7.15,0) 18(7.55,0) 19(7.95,0) 20(8.35,0) 21(8.75,0) 22(9.15,0) 23(9.55,0) 24(9.95,0) 25(10.35,0) 26(10.75,0) 27(11.15,0) 28(11.55,0) 29(11.95,0) 30(12.35,0) 31(12.75,0) 32(13.15,0) 33(13.55,0) 34(13.95,0) 35(14.35,0) 36(14.75,0) 37(15.15,0) 38(15.55,0) 39(15.95,0) 40(16.35,0) 41(16.75,0) 42(17.15,0) 43(17.55,0) 44(17.95,0)
  custom 0.688x0.688 hole 0.787x2.007: 47(25.8,0) 50(-6.7,0)
  oval 1.549x2.769 hole 0.787x2.007: 48(25.8,-4.6) 49(-6.7,-4.6)
TLC59116FIRHBR_VQFN32_5X5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TOKO_1239AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPA3131D2DAPR_QFN32_5X5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS22969DNYR_SON8-7_3X3
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51285BRUKR_QFN20_3X3
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.702x1.702 smd: 21(0.8,1.488)
TS3A225ERTER_PWQFN16_3X3
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.95) 10(1,2.95) 11(0.5,2.95) 12(0,2.95)
  oval 1.041x0.254 smd: 5(2.225,0.725) 6(2.225,1.225) 7(2.225,1.725) 8(2.225,2.225) 13(-0.725,2.225) 14(-0.725,1.725) 15(-0.725,1.225) 16(-0.725,0.725)
  rect 1.651x1.651 smd: 17(0.75,1.475)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_5YEA27000163IF50Q5_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_FSX3M-25PM20FDO_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)

## Nets
1.35V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP203.2 PQ200.5 PR206.1
2.5VOUT: CM9.1 CM32.1 CM34.1 CM35.1 CM36.1 UM8.9 UM8.14 UM8.36 UM8.41 UM8.51
3/5V_B+: PC100.1 PC102.1 PC103.1 PC104.1 PC113.1 PC114.1 PL100.2 PQ100.5 PQ102.5 PU100.12
3V3_MAIN_EN: PR620.1 PR621.2 RV55.1 RV541.2 UV1.AW1 UV11.5
3V_EN: PR100.1 PU100.6
3V_F347_ON: RE83.1 UE5.128 UE9.4
3VALW_PCH: J6.2 U18.13 U18.14
3VS: J5.2 U17.8 U17.9
3VS_GATE: C258.1 R174.2 U17.5
5V_EN: PR112.1 PU100.20
5VS: J4.2 U17.13 U17.14
5VS_GATE: R182.2 U17.3
+0.675VS: C10.1 C11.1 C12.1 C13.1 CD3.1 CD4.1 CD5.1 CD6.1 CD41.1 CD43.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP202.2 R177.1
+0.675VSP: PC205.1 PC206.1 PJP202.1 PU200.2 PU200.20
+1.2VS: CA9.2 CA10.2 CA11.2 RA127.2 UA1.9 UA1.15 UA1.20 UA1.48 UA5.1
+1.05V_+1.5V_RUN: CH23.1 CH29.1 CH30.1 CH31.1 CH47.1 RH92.2 RH153.2 UH1.AF34 UH1.AK26 UH1.AK28 UH1.AN11 UH1.BB44 UH1.BE22
+1.05V_GPUP_B+: PC652.1 PC666.1 PJP902.1 PU602.8 PU602.9 PU602.10
+1.05V_PGOOD: PR301.2 PU300.1 UE5.122
+1.05VS: CH18.1 CH19.1 CH20.1 CH21.1 CH22.1 CH26.1 CH27.1 CH28.1 CH32.1 CH33.1 CH34.1 CH35.1 CH36.1 CH40.1 CH45.1 LH1.1 PJP300.2 PR527.1 RC50.2 RC51.2 RC54.2 RH142.1 RH143.1 RH146.2 RH147.1 UH1.AA18 UH1.AA24 UH1.AA26 UH1.AD20 UH1.AD22 UH1.AD24 UH1.AD26 UH1.AD28 UH1.AE18 UH1.AE20 UH1.AE22 UH1.AE24 UH1.AE26 UH1.AG18 UH1.AG20 UH1.AG22 UH1.AG24 UH1.AK18 UH1.AK20 UH1.AK22 UH1.AM18 UH1.AM20 UH1.AM22 UH1.AN34 UH1.AN35 UH1.AP22 UH1.AR22 UH1.AT22 UH1.L17 UH1.R18 UH1.U18 UH1.U20 UH1.U22 UH1.U24 UH1.U30 UH1.U35 UH1.U36 UH1.V18 UH1.V20 UH1.V22 UH1.V24 UH1.V28 UH1.V30 UH1.Y18 UH1.Y20 UH1.Y22 UH1.Y26 UH1.Y30 UV22.1 UV22.2 UV22.7
+1.5VS: CV422.1 CV423.1 CV424.1 CV425.1 CV426.1 PJP403.2 RH22.1 RH28.2 RH40.2 RH41.1 RH42.1 RH91.1 RH110.2 RH111.1 RH144.1 RH153.1 UH1.AW40 UV4.12 UV4.19 UV4.20 UV4.31 UV4.40
+1.05VS_VCC: LH1.2 RH150.1
+1.05VS_VGA: CV94.2 CV95.1 CV96.1 CV97.1 CV98.2 CV99.2 CV111.2 CV114.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV120.1 CV124.1 CV125.1 CV126.1 LV9.2 LV15.2 PJP901.2 UV1.AW26 UV1.AW33 UV1.AY24 UV1.AY26 UV1.AY27 UV1.AY29 UV1.AY30 UV1.AY32 UV1.AY33 UV1.AY35 UV1.BA24 UV1.BA26 UV1.BA27 UV1.BA29 UV1.BA30 UV1.BA32 UV1.BA33 UV1.BA35 UV1.BB24 UV1.BB27 UV1.BB30 UV1.BB33 UV22.6
+1.05VS_VGAP: PC655.1 PC656.1 PC657.1 PC658.1 PC661.1 PJP901.1 PL605.2 PR681.1
+1.5VSP: PC406.1 PJP403.1 PR405.1 PU401.1
+1.05VSP: PC306.1 PJP300.1 PL300.2 PR307.2
+1.05VSP_B+: PC301.1 PC302.1 PC303.1 PC304.1 PJP301.1 PQ300.5
+1.35V: C1.1 C2.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD40.1 CD42.1 CD44.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JP1.2 JP2.2 PJP200.2 RC12.2 RD1.2 RD5.2 RD11.2
+1.35V_CPU_VDDQ: C1.2 C2.2 C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC47.1 CC48.1 CC49.1 CC50.1 CC51.1 CPU1.AR29 CPU1.AR31 CPU1.AR33 CPU1.AT13 CPU1.AT19 CPU1.AT23 CPU1.AT27 CPU1.AT32 CPU1.AT36 CPU1.AV37 CPU1.AW22 CPU1.AW25 CPU1.AW29 CPU1.AW33 CPU1.AY18 CPU1.BB21 CPU1.BB22 CPU1.BB26 CPU1.BB27 CPU1.BB30 CPU1.BB31 CPU1.BB34 CPU1.BB36 CPU1.BD22 CPU1.BD26 CPU1.BD30 CPU1.BD33 CPU1.BE18 CPU1.BE22 CPU1.BE26 CPU1.BE30 CPU1.BE33 JP1.1 JP2.1 RC26.1
+1.35V_PWRGD: PR210.2 PU200.10 RC56.1
+1.35VP: PC208.1 PC209.1 PJP200.1 PL201.1 PR205.2 PU200.5 PU200.19
+1.35VS_VGA: CV81.2 CV82.1 CV83.1 CV84.1 CV85.1 CV86.1 CV87.1 CV88.1 CV89.2 CV90.2 CV91.1 CV92.1 CV93.2 CV100.1 CV101.1 CV102.1 CV103.1 CV104.1 CV105.1 CV106.1 CV107.1 CV110.1 CV112.1 CV113.1 CV135.1 CV136.1 CV137.1 CV138.1 CV139.2 CV140.2 CV141.1 CV142.1 CV143.1 CV144.1 CV145.1 CV146.1 CV153.1 CV154.1 CV155.1 CV156.1 CV160.1 CV161.1 CV162.1 CV163.1 CV164.1 CV165.1 CV166.1 CV167.1 CV168.1 CV169.1 CV170.1 CV171.1 CV172.1 CV173.1 CV174.1 CV175.1 CV180.1 CV181.1 CV182.1 CV184.1 CV185.1 CV186.1 CV187.1 CV188.1 CV189.1 CV190.1 CV191.1 CV192.1 CV193.1 CV194.1 CV198.1 CV199.1 CV200.1 CV201.1 CV202.1 CV203.1 CV204.1 CV205.1 CV206.1 CV207.1 CV208.1 CV209.1 CV210.1 CV211.1 CV213.1 CV214.1 CV215.1 CV216.1 CV217.1 CV218.1 CV219.1 CV220.1 CV221.1 CV222.1 CV223.1 CV224.1 CV225.1 CV226.1 CV227.1 CV228.1 CV229.1 CV230.1 CV231.1 CV232.1 CV233.1 CV234.1 CV235.1 CV236.1 CV237.1 CV238.1 CV239.1 CV240.1 CV241.1 CV242.1 CV243.1 CV244.1 CV245.1 CV246.1 CV247.1 CV248.1 CV249.1 CV250.1 CV252.1 CV253.1 CV254.1 CV255.1 CV256.1 CV257.1 CV258.1 CV259.1 CV260.1 CV261.1 CV262.1 CV263.1 CV264.1 CV265.1 CV266.1 CV267.1 CV268.1 CV269.1 CV270.1 CV271.1 CV272.1 CV273.1 CV274.1 CV275.1 CV276.1 CV277.1 CV278.1 CV279.1 CV280.1 CV281.1 CV282.1 CV283.1 CV284.1 CV285.1 CV286.1 CV287.1 CV288.1 CV289.1 CV290.1 CV291.1 CV292.1 CV293.1 CV294.1 CV295.1 CV296.1 CV297.1 CV298.1 CV313.1 CV314.1 CV315.1 CV338.1 CV339.1 PJP302.2 PJP304.2 PJP305.2 RV77.1 RV109.1 RV110.1 RV113.1 RV114.1 RV117.2 RV131.2 RV142.1 RV143.1 RV147.1 RV148.1 RV150.1 RV152.1 RV165.2 RV172.2 RV189.1 RV195.1 RV197.1 RV201.1 RV203.1 RV207.1 UV1.AA39 UV1.AC11 UV1.AD10 UV1.AD39 UV1.AF11 UV1.AF39 UV1.AG39 UV1.AK39 UV1.AM39 UV1.AM40 UV1.AN40 UV1.B47 UV1.C45 UV1.C46 UV1.C47 UV1.D44 UV1.D45 UV1.D46 UV1.E44 UV1.E45 UV1.F42 UV1.F44 UV1.F45 UV1.G41 UV1.G42 UV1.H41 UV1.H42 UV1.H43 UV1.J38 UV1.J39 UV1.J42 UV1.J43 UV1.K24 UV1.K26 UV1.K29 UV1.K30 UV1.K32 UV1.L14 UV1.L15 UV1.L17 UV1.L18 UV1.L20 UV1.L23 UV1.L24 UV1.L27 UV1.L29 UV1.L30 UV1.L32 UV1.L33 UV1.L35 UV1.L41 UV1.P11 UV1.P39 UV1.R11 UV1.R40 UV1.U11 UV1.U39 UV1.V11 UV1.V39 UV1.V40 UV1.Y11 UV1.Y40 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV7.B1 UV7.B3 UV7.B12 UV7.B14 UV7.C5 UV7.C10 UV7.D1 UV7.D3 UV7.D11 UV7.D12 UV7.D14 UV7.E5 UV7.E10 UV7.F1 UV7.F3 UV7.F12 UV7.F14 UV7.G1 UV7.G2 UV7.G4 UV7.G11 UV7.G13 UV7.G14 UV7.H3 UV7.H12 UV7.K3 UV7.K12 UV7.L1 UV7.L2 UV7.L4 UV7.L11 UV7.L13 UV7.L14 UV7.M1 UV7.M3 UV7.M12 UV7.M14 UV7.N5 UV7.N10 UV7.P1 UV7.P3 UV7.P11 UV7.P12 UV7.P14 UV7.R5 UV7.R10 UV7.T1 UV7.T3 UV7.T12 UV7.T14 UV8.B1 UV8.B3 UV8.B12 UV8.B14 UV8.C5 UV8.C10 UV8.D1 UV8.D3 UV8.D11 UV8.D12 UV8.D14 UV8.E5 UV8.E10 UV8.F1 UV8.F3 UV8.F12 UV8.F14 UV8.G1 UV8.G2 UV8.G4 UV8.G11 UV8.G13 UV8.G14 UV8.H3 UV8.H12 UV8.K3 UV8.K12 UV8.L1 UV8.L2 UV8.L4 UV8.L11 UV8.L13 UV8.L14 UV8.M1 UV8.M3 UV8.M12 UV8.M14 UV8.N5 UV8.N10 UV8.P1 UV8.P3 UV8.P11 UV8.P12 UV8.P14 UV8.R5 UV8.R10 UV8.T1 UV8.T3 UV8.T12 UV8.T14 UV9.B1 UV9.B3 UV9.B12 UV9.B14 UV9.C5 UV9.C10 UV9.D1 UV9.D3 UV9.D11 UV9.D12 UV9.D14 UV9.E5 UV9.E10 UV9.F1 UV9.F3 UV9.F12 UV9.F14 UV9.G1 UV9.G2 UV9.G4 UV9.G11 UV9.G13 UV9.G14 UV9.H3 UV9.H12 UV9.K3 UV9.K12 UV9.L1 UV9.L2 UV9.L4 UV9.L11 UV9.L13 UV9.L14 UV9.M1 UV9.M3 UV9.M12 UV9.M14 UV9.N5 UV9.N10 UV9.P1 UV9.P3 UV9.P11 UV9.P12 UV9.P14 UV9.R5 UV9.R10 UV9.T1 UV9.T3 UV9.T12 UV9.T14 UV12.B1 UV12.B3 UV12.B12 UV12.B14 UV12.C5 UV12.C10 UV12.D1 UV12.D3 UV12.D11 UV12.D12 UV12.D14 UV12.E5 UV12.E10 UV12.F1 UV12.F3 UV12.F12 UV12.F14 UV12.G1 UV12.G2 UV12.G4 UV12.G11 UV12.G13 UV12.G14 UV12.H3 UV12.H12 UV12.K3 UV12.K12 UV12.L1 UV12.L2 UV12.L4 UV12.L11 UV12.L13 UV12.L14 UV12.M1 UV12.M3 UV12.M12 UV12.M14 UV12.N5 UV12.N10 UV12.P1 UV12.P3 UV12.P11 UV12.P12 UV12.P14 UV12.R5 UV12.R10 UV12.T1 UV12.T3 UV12.T12 UV12.T14 UV13.B1 UV13.B3 UV13.B12 UV13.B14 UV13.C5 UV13.C10 UV13.D1 UV13.D3 UV13.D11 UV13.D12 UV13.D14 UV13.E5 UV13.E10 UV13.F1 UV13.F3 UV13.F12 UV13.F14 UV13.G1 UV13.G2 UV13.G4 UV13.G11 UV13.G13 UV13.G14 UV13.H3 UV13.H12 UV13.K3 UV13.K12 UV13.L1 UV13.L2 UV13.L4 UV13.L11 UV13.L13 UV13.L14 UV13.M1 UV13.M3 UV13.M12 UV13.M14 UV13.N5 UV13.N10 UV13.P1 UV13.P3 UV13.P11 UV13.P12 UV13.P14 UV13.R5 UV13.R10 UV13.T1 UV13.T3 UV13.T12 UV13.T14 UV15.B1 UV15.B3 UV15.B12 UV15.B14 UV15.C5 UV15.C10 UV15.D1 UV15.D3 UV15.D11 UV15.D12 UV15.D14 UV15.E5 UV15.E10 UV15.F1 UV15.F3 UV15.F12 UV15.F14 UV15.G1 UV15.G2 UV15.G4 UV15.G11 UV15.G13 UV15.G14 UV15.H3 UV15.H12 UV15.K3 UV15.K12 UV15.L1 UV15.L2 UV15.L4 UV15.L11 UV15.L13 UV15.L14 UV15.M1 UV15.M3 UV15.M12 UV15.M14 UV15.N5 UV15.N10 UV15.P1 UV15.P3 UV15.P11 UV15.P12 UV15.P14 UV15.R5 UV15.R10 UV15.T1 UV15.T3 UV15.T12 UV15.T14 UV16.B1 UV16.B3 UV16.B12 UV16.B14 UV16.C5 UV16.C10 UV16.D1 UV16.D3 UV16.D11 UV16.D12 UV16.D14 UV16.E5 UV16.E10 UV16.F1 UV16.F3 UV16.F12 UV16.F14 UV16.G1 UV16.G2 UV16.G4 UV16.G11 UV16.G13 UV16.G14 UV16.H3 UV16.H12 UV16.K3 UV16.K12 UV16.L1 UV16.L2 UV16.L4 UV16.L11 UV16.L13 UV16.L14 UV16.M1 UV16.M3 UV16.M12 UV16.M14 UV16.N5 UV16.N10 UV16.P1 UV16.P3 UV16.P11 UV16.P12 UV16.P14 UV16.R5 UV16.R10 UV16.T1 UV16.T3 UV16.T12 UV16.T14
+1.35VS_VGA_PGOOD: PR318.2 PU301.1 RV56.2
+1.35VS_VGAP: PC311.1 PC318.1 PJP302.1 PJP304.1 PJP305.1 PL301.2 PR319.1
+1.35VS_VGAP_B+: PC307.1 PC310.1 PC314.1 PC316.1 PJP303.1 PQ303.5
+1.35VS_VGAP_B++: PJP303.2 PJP600.1 PR603.1
+3.3V_ALW_PCH_JTAG: RH17.2 RH19.1 RH21.1 RH23.1
+3.3V_AVDD: CA6.1 CA7.2 CA8.2 RA41.2 RA43.2 RA44.2 RA92.2 RA114.1 RA115.1 UA1.29 UA1.34 UA1.38 UA3.13 UA3.16
+3.3V_DVDD: CA1.2 CA16.2 LA9.1 LA10.1 RA95.1 UA1.54 UA6.14
+3.3V_F347: CE1.1 CE2.1 CE3.1 CE4.2 CE10.1 CE19.1 CE24.1 CE59.1 J2.1 JELC1.1 RE1.1 RE2.1 RE6.1 RE7.1 RE8.1 RE12.1 RE13.1 RE14.1 RE15.1 RE16.1 RE17.1 RE21.1 RE23.1 RE25.1 RE40.1 RE43.1 UE1.6 UE1.7 UE2.8 UE3.27 UE9.1
+3.3V_F347_1: CE25.1 CE53.1 QE16.2 QE16.5 RE6.2 RE18.1 RE26.1 RE32.1 RE35.1 RE45.1 RE46.1 RE47.1 UE4.27 UE8.27
+3.3V_GFX_AON: CV121.1 CV122.1 CV123.1 CV132.1 CV133.1 CV134.1 RV35.2 RV39.1 RV50.2 RV53.2 RV55.2 RV61.1 RV62.2 RV63.2 RV64.2 RV191.2 RV192.2 RV214.2 RV217.2 RV218.2 RV219.2 RV229.2 RV230.2 RV231.2 RV233.2 RV526.2 RV527.2 RV530.1 RV541.1 RV547.1 RV548.1 UV1.AW17 UV1.AW30 UV1.AW32 UV1.AY17 UV11.6 UV11.7 UV11.13 UV11.14
+3V_PCH: C266.1 C267.1 CH10.1 CH25.1 CH39.1 CH41.1 CH46.1 CH48.1 CH54.1 J6.1 RH6.1 RH17.1 RH30.1 RH31.1 RH35.1 RH37.1 RH60.1 RH73.1 RH74.2 RH75.1 RH76.2 RH77.1 RH80.1 RH81.1 RH82.1 RH83.2 RH97.1 RH99.1 RH100.1 RH101.1 RH105.1 RH106.1 RH107.2 RH123.2 RH126.2 RH145.1 RPH4.5 RPH4.6 RPH4.7 RPH4.8 RPH6.5 RPH6.6 RPH6.7 RPH6.8 RPH7.5 RPH7.6 RPH7.7 RPH7.8 UH1.A26 UH1.AD12 UH1.AJ30 UH1.AJ32 UH1.K8 UH1.R20 UH1.R22 UH1.R24 UH1.R26 UH1.R28 UH1.U26 UH4.8
+3VALW: C262.1 C263.1 C269.1 C270.1 CC30.1 CE22.1 CE29.1 CE30.1 CE31.2 CE32.2 CE56.1 CH101.1 CL40.1 CL41.1 CM11.2 CM23.1 CM24.2 CM28.2 CM70.1 CT4.2 CT5.1 CT6.1 CT7.1 CV212.1 CZ6.1 J2.2 JPWR1.6 LE1.1 PJP102.2 PJP902.2 PR3.2 PR16.2 PR24.2 PR210.1 PR709.2 PR710.1 PR718.2 RC24.1 RE64.2 RE68.2 RE70.1 RE79.1 RE90.5 RE90.6 RE91.1 RE93.1 RE94.1 RE99.2 RE102.2 RH141.1 RM5.1 RM34.1 RM41.1 RT4.1 U17.6 U17.7 U18.1 U18.2 UC1.5 UE5.9 UE5.22 UE5.33 UE5.96 UE5.125 UE6.24 UE9.5 UH5.2 UL2.5 UM1.5 UM3.5 UM7.5 UT2.3 UT2.10 UT2.19 UT2.24 UV14.5
+3VALW_PCH_GATE: C268.1 RE62.1 U18.3
+3VALWP: PC107.1 PJP102.1 PL101.1 PR101.1
+3VLP: CU26.1 DU8.1 PC101.1 PD5.3 PR25.2 PU100.3 RE63.2 RU4.1 RU5.1 UE5.111 UU5.5
+3VS: C16.1 C260.1 C261.1 C2498.1 CD22.1 CD23.1 CD39.1 CE50.1 CF6.1 CH6.1 CH7.1 CH24.1 CH43.1 CH44.1 CH58.1 CM18.1 CM19.1 CM20.1 CM21.1 CM29.1 CM30.1 CM31.1 CM33.1 CN1.1 CN7.1 CN8.1 CN17.1 CN18.1 CN19.1 CN20.1 CN21.1 CN22.1 CN23.1 CN24.1 CN25.1 CN26.1 CN35.1 CN36.1 CN37.1 CN38.1 CN39.1 CN40.1 CN41.1 CN42.1 CV5.1 CV16.1 CV21.1 CV372.1 CV427.1 CV428.1 CV429.1 J5.1 JDIMM1.199 JDIMM2.199 JHDD1.8 JHDD1.9 JHDD1.10 JIO.28 JSSD1.2 JSSD1.4 JSSD1.62 JSSD1.64 JSSD1.66 JSSD2.2 JSSD2.4 JSSD2.62 JSSD2.64 JSSD2.66 JSSD3.2 JSSD3.4 JSSD3.62 JSSD3.64 JSSD3.66 JSSD4.2 JSSD4.4 JSSD4.62 JSSD4.64 JSSD4.66 LR1.1 PC405.1 PR301.1 PR318.1 PR407.2 PR519.2 PR600.1 PR614.1 PR639.1 PU401.8 QH3.2 QH3.5 QH4.2 QH4.5 QN2.2 QN3.2 R144.1 R145.1 R146.1 R147.1 R148.1 R149.1 R150.1 R151.1 R152.1 R153.1 R154.1 R155.1 R156.1 R157.1 R158.1 R159.1 R160.1 R161.1 R162.1 R163.1 R164.1 R165.1 R166.1 R167.1 R168.1 R169.1 R170.1 R171.1 R172.1 R173.1 R181.1 RA51.1 RA92.1 RA94.1 RA95.2 RA128.2 RC27.1 RD15.1 RE18.2 RE20.2 RE77.1 RE90.7 RE90.8 RF1.2 RF2.2 RF4.2 RF5.2 RH5.1 RH7.2 RH8.1 RH10.2 RH14.1 RH33.1 RH43.1 RH44.1 RH59.1 RH61.1 RH62.1 RH63.1 RH64.1 RH66.1 RH68.2 RH78.1 RH85.2 RH93.1 RH94.1 RH98.1 RH112.1 RH113.1 RH114.1 RH115.1 RH117.2 RH118.1 RH119.1 RH120.1 RH121.1 RH130.1 RH131.2 RH134.1 RH136.2 RH137.1 RH148.2 RH149.1 RH151.1 RH154.1 RH157.1 RL5.2 RM14.1 RM18.1 RM19.1 RM20.1 RM26.1 RM30.2 RM35.2 RM63.1 RM66.2 RM71.1 RM74.1 RM76.1 RM77.2 RM79.1 RM81.1 RM83.1 RM85.1 RM86.1 RN6.2 RN7.2 RN8.1 RN9.1 RN10.1 RN11.1 RN12.1 RN13.1 RN14.1 RN15.1 RN28.2 RN29.2 RN32.2 RN33.2 RPH3.6 RPH3.7 RT5.1 RV2.2 RV15.2 RV20.1 RV42.1 RV45.2 RV47.1 RV81.1 RV294.1 RV296.1 RV298.1 RV300.1 RV302.1 RV303.1 RV306.1 RV528.1 RV529.1 RV531.1 RV538.1 U2407.1 U2410.1 UA5.8 UE7.5 UH1.AE14 UH1.AF12 UH1.AG14 UH1.AK30 UH1.AK32 UH1.L24 UH1.R30 UH1.R32 UH2.5 UH3.5 UM4.5 UM4.9 UM4.12 UM4.16 UM8.24 UN2.1 UN2.7 UN2.8 UN2.14 UV2.5 UV4.11 UV4.37 UV11.1 UV11.2 UV17.5 UV18.1
+3VS_CAM: JEDP1.28 JEDP1.29 RV47.2
+3VS_CARD: CR1.1 CR2.1 CR6.1 CR7.1 LR1.2 RR4.1 RR4.2 UR1.11 UR1.27
+3VS_DP: CV34.1 CV35.1 CV377.1 JDP1.20 UV18.3
+3VS_TOUCH: CT3.1 JPWR1.3 RE100.1 RE101.1 RT6.2 UT1.1
+3VS_VGA: CV54.1 CV127.1 CV128.1 CV129.1 CV130.1 CV195.1 CV408.1 LV14.2 RV167.1 RV242.1 RV243.1 RV551.1 RV552.1 UV1.AJ10 UV1.AJ11 UV1.AK11 UV1.AM11 UV1.AN11 UV1.AR11 UV1.AW15 UV1.AW18 UV1.AY15 UV10.3 UV10.7 UV10.8 UV11.8 UV11.9 UV19.5 UV20.4
+3VS_WLAN_NGFF: CM10.2 CM12.1 CM13.1 CM14.1 CM15.1 CM25.2 CM26.1 CM27.1 JWLAN1.2 JWLAN1.4 JWLAN1.64 JWLAN1.66 QN4.2 QN5.2 RE92.2 RN5.1 RN25.1 RN26.1 UM1.1
+5VALW: C264.1 C265.1 CI1.1 CI2.1 CI26.1 CI27.1 JIO.24 JIO.25 JIO.26 PC308.1 PC313.1 PJP100.2 PR8.1 PR14.2 PR203.1 PR204.1 PU300.7 PU301.7 QE8.3 R175.1 RE4.1 RE28.1 RE38.1 RM91.1 RM92.1 RM93.1 RM94.1 RN27.1 U17.1 U17.2 U17.4 U18.4 UI2.5 UI3.5
+5VALW_LED: JPWR1.5 QE8.1
+5VALWP: PC108.1 PJP100.1 PL102.2 PR102.2 PU100.14
+5VS: C27.1 C29.1 C256.1 C257.1 CE23.1 CE26.1 CF4.1 CF5.1 CN2.1 CN3.1 CN4.1 CN6.1 CN51.1 CN52.1 CV23.1 CV376.1 J4.1 JFAN1.1 JFAN2.1 JHDD1.14 JHDD1.15 JHDD1.16 JKB3.5 JKB3.6 JKBBL1.15 JKBBL1.16 JLOGO1.1 JLOGO1.2 JPWR1.4 JTRONF.1 JTRONF.2 PC408.1 PR501.2 PR520.2 PR530.2 PR625.2 PR643.1 PU401.6 Q2409.1 Q2409.2 Q2409.5 Q2409.6 QH1.2 RE5.1 RE39.1 RF3.2 RF6.2 RN24.1 RT11.2 RV31.2 RV32.2 UA5.6 UV3.16 UV5.1 UV11.4 UV22.3
+5VS_TP_LED: C17.1 C2508.1 JPWR1.1 JPWR1.2 Q2409.4
+AV12_DV12_S: CR4.1 CR5.1 CR8.1 UR1.10 UR1.14
+AVDDH: CL5.1 CL6.1 CL7.1 UL1.9 UL1.22
+AVDDL: CL18.1 CL19.1 CL20.1 CL21.1 CL22.1 CL23.1 CL24.1 CL25.1 UL1.6 UL1.13 UL1.19 UL1.31 UL1.34
+DV33_18: CR3.2 UR1.18
+DVDDL: CL3.1 CL4.1 UL1.37
+PVDD: CA94.1 CA95.1 CA96.1 CA97.1 LA7.2 UA4.13 UA4.14 UA4.27 UA4.28
+V18R: CE48.1 UE5.124
+VCC_3IN1: CR12.1 CR13.1 JCR.4 JCR.11 UR1.12
+VCC_CORE: CPU1.A27 CPU1.A28 CPU1.A31 CPU1.A32 CPU1.A34 CPU1.A36 CPU1.A38 CPU1.A39 CPU1.A42 CPU1.A43 CPU1.A45 CPU1.A46 CPU1.A48 CPU1.AA8 CPU1.AA9 CPU1.AA46 CPU1.AA47 CPU1.AB8 CPU1.AB45 CPU1.AB46 CPU1.AC8 CPU1.AC9 CPU1.AC46 CPU1.AC47 CPU1.AD8 CPU1.AD46 CPU1.AE8 CPU1.AE46 CPU1.AE47 CPU1.AF8 CPU1.AG8 CPU1.AG46 CPU1.AH8 CPU1.AH46 CPU1.AH47 CPU1.AJ45 CPU1.AJ46 CPU1.AK8 CPU1.AK46 CPU1.AK47 CPU1.AL8 CPU1.AL9 CPU1.AL45 CPU1.AL46 CPU1.AM8 CPU1.AM9 CPU1.AM46 CPU1.AM47 CPU1.AN8 CPU1.AN9 CPU1.AN10 CPU1.AN12 CPU1.AN13 CPU1.AN14 CPU1.AN15 CPU1.AN16 CPU1.AN17 CPU1.AN19 CPU1.AN20 CPU1.AN21 CPU1.AN23 CPU1.AN24 CPU1.AN25 CPU1.AN26 CPU1.AN27 CPU1.AN29 CPU1.AN30 CPU1.AN32 CPU1.AN34 CPU1.AN36 CPU1.AN38 CPU1.AN39 CPU1.AN40 CPU1.AN41 CPU1.AN42 CPU1.AN43 CPU1.AN44 CPU1.AN45 CPU1.AN46 CPU1.AP8 CPU1.AP9 CPU1.AP10 CPU1.AP12 CPU1.AP13 CPU1.AP14 CPU1.AP15 CPU1.AP16 CPU1.AP17 CPU1.AP18 CPU1.AP19 CPU1.AP20 CPU1.AP21 CPU1.AP22 CPU1.AP23 CPU1.AP24 CPU1.AP25 CPU1.AP26 CPU1.AP27 CPU1.AP29 CPU1.AP30 CPU1.AP31 CPU1.AP32 CPU1.AP33 CPU1.AP34 CPU1.AP35 CPU1.AP36 CPU1.AP37 CPU1.AP38 CPU1.AP39 CPU1.AP40 CPU1.AP41 CPU1.AP42 CPU1.AP43 CPU1.AP44 CPU1.AP46 CPU1.AP47 CPU1.AR35 CPU1.AR37 CPU1.AR39 CPU1.AR41 CPU1.AR43 CPU1.AR45 CPU1.AR46 CPU1.B27 CPU1.B28 CPU1.B31 CPU1.B32 CPU1.B34 CPU1.B36 CPU1.B38 CPU1.B39 CPU1.B42 CPU1.B43 CPU1.B45 CPU1.B46 CPU1.B48 CPU1.C27 CPU1.C28 CPU1.C31 CPU1.C32 CPU1.C34 CPU1.C36 CPU1.C38 CPU1.C39 CPU1.C42 CPU1.C43 CPU1.C45 CPU1.C46 CPU1.C48 CPU1.D27 CPU1.D28 CPU1.D31 CPU1.D32 CPU1.D34 CPU1.D36 CPU1.D38 CPU1.D39 CPU1.D42 CPU1.D43 CPU1.D45 CPU1.D46 CPU1.D48 CPU1.E27 CPU1.E28 CPU1.E31 CPU1.E32 CPU1.E34 CPU1.E36 CPU1.E38 CPU1.E39 CPU1.E42 CPU1.E43 CPU1.E45 CPU1.E46 CPU1.E48 CPU1.F22 CPU1.F27 CPU1.F28 CPU1.F31 CPU1.F32 CPU1.F34 CPU1.F36 CPU1.F38 CPU1.F39 CPU1.F42 CPU1.F43 CPU1.F45 CPU1.F46 CPU1.F48 CPU1.G27 CPU1.G29 CPU1.G31 CPU1.G32 CPU1.G34 CPU1.G36 CPU1.G38 CPU1.G39 CPU1.G42 CPU1.G43 CPU1.G45 CPU1.G46 CPU1.G48 CPU1.H8 CPU1.H9 CPU1.H11 CPU1.H12 CPU1.H13 CPU1.H14 CPU1.H16 CPU1.H17 CPU1.H18 CPU1.H19 CPU1.H20 CPU1.H21 CPU1.H23 CPU1.H24 CPU1.H25 CPU1.H26 CPU1.H27 CPU1.H29 CPU1.H30 CPU1.H31 CPU1.H32 CPU1.H33 CPU1.H34 CPU1.H36 CPU1.H37 CPU1.H38 CPU1.H39 CPU1.H40 CPU1.H42 CPU1.H43 CPU1.H45 CPU1.H46 CPU1.H48 CPU1.J8 CPU1.J9 CPU1.J10 CPU1.J14 CPU1.J19 CPU1.J24 CPU1.J29 CPU1.J33 CPU1.J36 CPU1.J37 CPU1.J38 CPU1.J39 CPU1.J40 CPU1.J42 CPU1.J43 CPU1.J45 CPU1.J46 CPU1.J48 CPU1.K8 CPU1.K9 CPU1.K38 CPU1.K40 CPU1.K43 CPU1.K44 CPU1.K45 CPU1.K46 CPU1.K48 CPU1.L6 CPU1.L8 CPU1.L37 CPU1.L38 CPU1.L39 CPU1.L40 CPU1.L42 CPU1.L43 CPU1.L44 CPU1.L46 CPU1.L47 CPU1.M6 CPU1.M8 CPU1.M9 CPU1.M37 CPU1.M38 CPU1.M39 CPU1.M40 CPU1.M42 CPU1.M43 CPU1.M44 CPU1.M45 CPU1.M46 CPU1.N8 CPU1.N9 CPU1.N37 CPU1.N38 CPU1.N39 CPU1.N40 CPU1.N42 CPU1.N43 CPU1.N44 CPU1.N46 CPU1.N47 CPU1.P8 CPU1.P45 CPU1.P46 CPU1.R8 CPU1.R9 CPU1.R46 CPU1.R47 CPU1.T45 CPU1.T46 CPU1.U8 CPU1.U9 CPU1.U46 CPU1.U47 CPU1.V8 CPU1.V45 CPU1.V46 CPU1.W8 CPU1.W46 CPU1.W47 CPU1.Y8 CPU1.Y45 CPU1.Y46 PC900.1 PC901.1 PC902.1 PC903.1 PC905.1 PC906.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC935.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PC971.1 PC972.1 PC973.1 PC974.1 PC975.1 PC976.1 PC977.1 PC978.1 PC979.1 PC980.1 PC981.1 PC982.1 PC983.1 PC984.1 PC985.1 PC986.1 PC987.1 PC988.1 PC989.1 PC990.1 PC991.1 PC992.1 PC993.1 PC994.1 PC995.1 PC996.1 PC997.1 PC998.1 PL501.1 PL502.1 PL503.1 RC44.1
+VCCIO2PCH: CC45.1 CC46.1 CPU1.D5 CPU1.F17 RC54.1
+VCCIO_OUT: CC32.1 CPU1.D51 PR500.2 PR503.2 PR504.2 RC11.1 RC34.2 RC47.1 RC49.2 RC51.1
+VDD_TOUCH: CV19.1 JEDP1.17 RV81.2 UV2.1
+VDDCT_L: CL32.2 CL33.1 CL34.2 CL35.1 CL36.2 CL37.1 CL38.2 CL39.1 TL1.1 TL1.4 TL1.7 TL1.10
AGND: CA6.2 CA7.1 CA8.1 CA15.1 CA16.1 CA17.2 CA18.1 CA19.1 CA24.1 CA69.1 CA71.1 CA73.2 CA74.2 CA75.2 CA81.2 CA113.2 JIO.30 QA2.3 QA3.3 QA7.1 QA7.4 QA11.2 QA12.2 QA13.2 RA42.1 RA54.1 RA55.2 RA57.2 RA64.1 RA101.5 RA101.6 RA101.7 RA101.8 RA105.2 RA106.2 RA107.2 RA108.2 RA120.1 RA122.1 UA1.25 UA1.30 UA1.39 UA3.3 UA3.4 UA3.10 UA3.12 UA3.17 UA6.5 UA6.7 UA6.8
DVDD_HDAIO: CA14.2 RA51.2 UA1.6
