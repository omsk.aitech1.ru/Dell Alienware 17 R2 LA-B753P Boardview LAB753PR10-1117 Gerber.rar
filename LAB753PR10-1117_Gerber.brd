# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3RN3_R: length 3.7
  TOP w0.127: JIO.10 11.73,28.53 11.73,28.52 11.83,28.52 11.94,28.63 v4(12.74,28.63) 13.07,28.63 13.45,29.01 13.7,29.01 14.02,28.69 LI11.1 14.48,28.69 RI71.2
USB3RN5: length 155.9
  IN5 w0.099: v3(213.87,41.17) 213.87,40.85 213.74,40.72 213.64,40.72 213.64,40.72 211.51,40.72 210.84,40.05 206.17,40.05 204.27,41.95 204.27,47.08 208.42,51.23 208.42,53.23 214.33,59.14 229.24,59.14 232.39,62.28 232.39,65.23 232.96,65.8 232.96,71.37 233.72,72.14 233.72,96.33 222.26,107.79 222.26,117.55 216.93,122.89 209.38,122.89 207.08,125.2 201.06,125.2 199.23,127.03 199.23,128.3 196.04,131.49 192.22,131.49 190.71,132.99 190.71,134.71 v3(190.92,134.92)
  BOTTOM w0.089: UH1.AW29 214.28,40.9 214.01,41.17 v3(213.87,41.17)
  BOTTOM w0.127: v3(190.92,134.92) 190.77,134.77 190.77,134.32 190.53,134.08 189.95,134.08 CI38.1
USB3RN5_L: length 4.6
  BOTTOM w0.127: CI38.2 188.39,134.08 v4(187.49,134.08) 187.02,134.08 186.88,133.94 185.89,133.94 185.64,134.19 185.64,134.42 185.38,134.68 LI13.3 185.38,135.3 RI76.1
USB3RN5_R: length 7.4
  BOTTOM w0.127: RI76.2 185.38,136.25 LI13.4 185.38,136.95 185.62,137.2 185.62,137.34 185.2,137.77 185.2,138.28 184.79,138.68 v4(184.79,139.66) 184.79,142.14 184.7,142.23 184.7,142.24 JCDRA.36
USB3RN6: length 235.5
  TOP w0.127: RI65.1 15.69,22.4 LI8.2 16.16,22.4 16.49,22.72 16.87,22.72 v3(17.02,22.57)
  IN1 w0.099: v3(17.02,22.57) 16.85,22.74 16.67,22.74 16.62,22.79 16.44,22.79 16.35,22.69 16.35,22.39 16.64,22.1 17.88,22.1 19.19,20.79 22.04,20.79 24.47,18.35 24.47,17.29 26.68,15.08 26.68,14.34 27.1,13.92 27.87,13.92 29.38,12.41 29.91,12.41 32.4,9.92 52.83,9.92 53.37,10.45 53.37,11.01 53.98,11.63 56.93,11.63 58.07,12.76 61.16,12.76 62.21,11.71 66.99,11.71 68.26,10.44 71.89,10.44 72.67,9.65 144.9,9.65 146.38,11.13 149.42,11.13 151.42,13.13 162.4,13.13 164.73,15.47 167,15.47 168.46,14.01 169.56,14.01 169.91,13.66 176.6,13.66 176.98,14.03 190.12,14.03 192.95,16.85 199.5,16.85 200.87,18.22 202.16,18.22 204.02,20.09 204.02,21.32 206.92,24.22 206.92,27.64 208.12,28.84 208.12,35.27 209.29,36.43 209.29,36.88 209.72,37.31 211.78,37.31 212.49,38.02 212.49,40.28 212.49,40.28 212.49,40.34 212.61,40.46 212.61,40.46 212.88,40.73 216.09,40.73 216.16,40.81 216.16,40.93 216.11,40.98 216.11,41 215.98,41.13 v3(215.83,41.13)
  BOTTOM w0.089: v3(215.83,41.13) 215.95,41.13 216.16,40.92 216.16,40.73 UH1.AR29
USB3RN6_R: length 4.3
  TOP w0.127: RI65.2 14.48,22.4 LI8.1 14.02,22.4 13.69,22.72 13.4,22.72 13.13,22.99 13.13,23.14 v4(12.85,23.43) 12.04,24.23 11.94,24.23 11.73,24.02 11.72,24.03 JIO.19
USB3RP1: length 149.6
  IN5 w0.099: v3(216.41,40.16) 216.13,40.44 216.13,40.52 216.2,40.58 217.2,40.58 217.55,40.93 225.07,40.93 225.47,40.53 228.8,40.53 230.44,42.16 231.54,42.16 231.94,41.76 236.21,41.76 237.46,43.01 241.5,43.01 243.2,41.31 245.96,41.31 249.36,37.91 250.28,37.91 251.7,36.49 254.07,36.49 260.05,30.51 266.56,30.51 266.8,30.75 269.7,30.75 270.4,30.05 276.8,30.05 277.61,30.86 296.61,30.86 298.69,28.78 308.65,28.78 309,29.14 315.01,29.14 315.46,29.59 315.46,29.84 317.99,32.37 317.99,38.46 317.64,38.8 317.64,46.04 316.93,46.76 316.93,54.57 318.01,55.66 318.01,64.21 318.18,64.38 318.18,65.16 v3(318.38,65.35)
  BOTTOM w0.089: UH1.AP26 216.48,39.67 216.31,39.84 216.31,40.06 v3(216.41,40.16)
  BOTTOM w0.127: v3(318.38,65.35) 318.14,65.59 318.14,65.89 318.29,66.04 318.44,66.04 318.9,65.58 LI2.2 319.5,65.58 RI8.1
USB3RP1_R: length 13.5
  BOTTOM w0.127: RI8.2 320.58,65.58 LI2.1 321.33,65.58 321.53,65.78 321.7,65.78 321.88,65.6 322.1,65.6 322.21,65.49 DI3.8 DI3.2 323.78,65.49 323.96,65.67 324.41,65.67 324.93,66.19 324.93,69.94 325.47,70.48 326.88,70.48 327.76,71.35 328.13,71.35 328.22,71.25 JUSB1.6
USB3RP2: length 140
  IN5 w0.099: v3(317.97,52.31) 318.2,52.54 318.62,52.54 318.73,52.43 318.73,51.46 317.61,50.34 317.61,47.12 318.35,46.37 318.35,39.22 318.67,38.9 318.67,36.89 318.9,36.66 318.9,31.95 315.42,28.47 311.33,28.47 310.85,27.99 298.53,27.99 296.38,30.14 277.87,30.14 277.09,29.36 270.18,29.36 269.43,30.12 267.11,30.12 266.36,29.36 260.02,29.36 253.85,35.54 251.78,35.54 250.12,37.2 249.21,37.2 245.73,40.68 242.31,40.68 242.09,40.91 236.47,40.91 235.88,40.31 230.21,40.31 229.45,39.55 228.86,39.55 228.62,39.79 225.57,39.79 224.82,40.54 219.08,40.54 218.04,39.49 216.97,39.49 216.73,39.74 214.32,39.74 214.26,39.8 214.26,40.03 214.38,40.16 v3(214.52,40.16)
  BOTTOM w0.089: UH1.AV26 214.75,39.67 214.52,39.9 v3(214.52,40.16)
  BOTTOM w0.127: RI61.1 319.57,52.18 LI6.2 319.04,52.18 318.7,52.53 318.19,52.53 v3(317.97,52.31)
USB3RP2_R: length 9
  BOTTOM w0.127: RI61.2 320.65,52.18 LI6.1 321.26,52.18 321.58,52.5 321.99,52.5 322.34,52.15 DI5.8 DI5.2 323.84,52.15 323.98,52.29 327.03,52.29 327.67,52.93 328.05,52.93 328.22,52.76 JUSB2.6
USB3RP3: length 235.7
  TOP w0.127: v3(17.04,29.4) 17.01,29.4 16.77,29.16 16.46,29.16 16.09,29.54 LI11.3 15.69,29.54 RI72.1
  IN1 w0.099: v3(17.04,29.4) 17.04,29.37 17.24,29.17 17.37,29.17 17.73,28.81 17.73,25.68 17.43,25.38 17.43,24.03 19.62,21.84 22.51,21.84 25.28,19.07 25.28,17.63 29.71,13.2 30.69,13.2 31.82,12.07 35.36,12.07 36.65,10.78 49.39,10.78 49.92,11.32 52.54,11.32 53.78,12.55 56.75,12.55 57.78,13.59 64.1,13.59 65.17,12.52 67.58,12.52 68.87,11.23 72.21,11.23 72.95,10.49 95.52,10.49 95.9,10.87 111.15,10.87 111.38,11.1 142.07,11.1 143.64,12.67 149.82,12.67 151.06,13.92 161.94,13.92 164.56,16.54 169.78,16.54 170.69,15.62 172.32,15.62 173.01,16.32 176.37,16.32 176.85,15.83 179.47,15.83 179.73,16.1 189.36,16.1 191.72,18.46 198.84,18.46 204.89,24.5 204.89,33.59 209.11,37.81 211.14,37.81 211.76,38.43 211.76,41.55 212.43,42.21 213.34,42.21 213.8,41.76 213.94,41.76 214.04,41.85 v3(214.04,42.09)
  BOTTOM w0.089: UH1.AY31 213.88,41.63 214.04,41.79 v3(214.04,42.09)
USB3RP3_R: length 3.7
  TOP w0.127: RI72.2 14.48,29.54 LI11.4 14.02,29.54 13.73,29.25 13.35,29.25 12.98,28.88 11.98,28.88 11.83,29.03 JIO.9
USB3RP5: length 156.1
  IN5 w0.099: v3(190.34,134.92) 190.53,134.73 190.53,132.92 192.14,131.3 195.96,131.3 199.05,128.22 199.05,126.95 200.98,125.02 207,125.02 209.31,122.71 216.85,122.71 222.08,117.48 222.08,107.71 233.54,96.26 233.54,72.21 232.78,71.45 232.78,65.88 232.21,65.3 232.21,62.36 229.22,59.37 229.17,59.32 214.25,59.32 208.24,53.31 208.24,51.3 204.09,47.15 204.09,41.88 206.1,39.87 210.91,39.87 211.58,40.54 213.72,40.54 213.81,40.54 214.1,40.82 214.17,40.82 v3(214.52,41.17)
  BOTTOM w0.089: UH1.AV29 214.52,41 v3(214.52,41.17)
  BOTTOM w0.127: CI39.1 189.95,134.32 190.36,134.32 190.52,134.49 190.52,134.73 v3(190.34,134.92)
USB3RP5_L: length 4.3
  BOTTOM w0.127: RI75.1 186.23,135.3 LI13.2 186.23,134.75 185.88,134.41 185.88,134.29 185.99,134.18 186.78,134.18 186.92,134.32 187.23,134.32 187.25,134.34 187.73,134.34 187.76,134.32 188.38,134.32 CI39.2
USB3RP5_R: length 7.5
  BOTTOM w0.127: RI75.2 186.23,136.25 LI13.1 186.23,136.88 185.87,137.24 185.87,137.45 v4(185.65,137.67) 185.44,137.88 185.44,138.38 185.03,138.79 185.03,139.4 185.04,139.41 185.04,139.92 185.03,139.93 185.03,142.15 185.1,142.22 JCDRA.37
USB3RP6: length 235.6
  TOP w0.127: RI66.1 15.69,23.25 LI8.3 16.26,23.25 16.55,22.97 16.66,22.97 v3(16.84,23.14)
  IN1 w0.099: v3(216.48,41.13) 216.34,41 216.34,40.73 216.16,40.55 212.95,40.55 212.86,40.46 212.86,40.46 212.67,40.27 212.67,40.21 212.67,40.2 212.67,37.94 211.86,37.13 209.8,37.13 209.47,36.8 209.47,36.36 208.3,35.19 208.3,28.76 207.1,27.56 207.1,24.14 204.21,21.25 204.21,20.01 202.23,18.04 200.94,18.04 199.57,16.67 193.02,16.67 190.2,13.85 177.05,13.85 176.68,13.48 169.84,13.48 169.48,13.83 168.38,13.83 166.92,15.29 164.81,15.29 162.47,12.95 151.49,12.95 149.49,10.95 146.45,10.95 144.98,9.47 72.6,9.47 71.81,10.26 68.19,10.26 66.92,11.53 62.13,11.53 61.08,12.58 58.15,12.58 57.01,11.44 54.05,11.44 53.55,10.94 53.55,10.38 52.91,9.74 32.32,9.74 29.83,12.23 29.31,12.23 27.8,13.74 27.03,13.74 26.5,14.27 26.5,15 24.29,17.21 24.29,18.28 21.96,20.61 19.12,20.61 17.81,21.92 16.56,21.92 16.17,22.31 16.17,22.77 16.37,22.97 16.66,22.97 v3(16.84,23.14)
  BOTTOM w0.089: UH1.AP29 216.48,40.84 v3(216.48,41.13)
USB3RP6_R: length 4.2
  TOP w0.127: JIO.18 11.74,24.53 11.79,24.47 12.14,24.47 12.8,23.82 12.82,23.82 13.24,23.4 13.24,23.38 13.38,23.24 13.38,23.09 13.5,22.97 13.74,22.97 14.02,23.25 LI8.4 14.48,23.25 RI66.2
USB3TN1: length 157.7
  IN5 w0.099: v3(209.79,38.84) 210.01,38.84 210.51,39.34 213.1,39.34 213.69,38.75 217.5,38.75 218.38,37.87 220.73,37.87 221.96,39.1 222.31,39.1 222.84,39.63 223.48,39.63 223.71,39.4 224.73,39.4 225.42,38.71 228.46,38.71 228.74,38.99 230.37,38.99 230.58,39.21 232.66,39.21 232.9,39.45 236.4,39.45 236.64,39.69 245.61,39.69 250.63,34.67 253.07,34.67 259.31,28.44 267.27,28.44 267.68,28.84 269.5,28.84 270.41,27.93 296.59,27.93 297.39,27.13 315.9,27.13 316.68,27.9 316.68,28.29 317.96,29.57 318.77,29.57 319.06,29.85 319.06,30.67 320.04,31.65 320.04,36.86 319.53,37.37 319.53,46.41 318.47,47.47 318.47,49.98 319.65,51.16 319.65,55.21 318.75,56.11 318.75,58.93 320.11,60.29 320.11,61.04 319.98,61.16 v3(319.49,61.16)
  BOTTOM w0.102: v3(209.79,38.84) 210.03,39.08 211.29,39.08 211.58,38.79 UH1.BE24
  BOTTOM w0.127: CI30.1 317.68,61.62 317.68,61.38 317.88,61.18 318.96,61.18 319.1,61.32 319.34,61.32 v3(319.49,61.16)
USB3TN1_L: length 3.3
  BOTTOM w0.127: RI11.1 319.5,64.52 LI3.3 318.92,64.52 318.73,64.34 318.24,64.34 318.11,64.21 318.09,64.21 317.65,63.77 317.65,63.76 317.6,63.71 317.6,63.07 CI30.2
USB3TN1_R: length 9.8
  BOTTOM w0.127: JUSB1.8 328.22,65.61 328.15,65.55 327.76,65.55 327.13,66.18 325.97,66.18 324.18,64.39 323.88,64.39 323.78,64.49 DI3.4 DI3.7 322.15,64.49 321.89,64.23 321.66,64.23 321.37,64.52 LI3.4 320.58,64.52 RI11.2
USB3TN2: length 150.3
  IN5 w0.099: v3(208.52,38.58) 208.65,38.46 208.65,37.91 209.1,37.46 213.13,37.46 213.64,37.98 217.11,37.98 217.92,37.16 224.51,37.16 225.38,38.03 228.66,38.03 228.87,37.81 230.27,37.81 230.56,38.1 236.64,38.1 236.94,38.4 242.66,38.4 243.88,37.19 246.74,37.19 250.28,33.64 252.48,33.64 259.17,26.95 296.07,26.95 297.16,25.86 316.97,25.86 317.73,26.62 317.73,27.87 318.39,28.52 319.64,28.52 321.12,30.01 321.12,34.95 322.25,36.08 322.25,37 320.87,38.38 320.87,46.55 319.9,47.51 319.9,47.7 320.02,47.82 320.5,47.82 v3(320.55,47.76)
  BOTTOM w0.089: UH1.BD25 212.09,39.3 211.63,39.3 211.42,39.5 209.49,39.5 209.2,39.21 209.15,39.21
  BOTTOM w0.127: v3(320.55,47.76) 320.45,47.86 319.69,47.86 319.68,47.85 319.18,47.85 319.17,47.86 317.74,47.86 317.45,48.15 317.45,48.39 CI32.1 ; v3(208.52,38.58) 208.71,38.77 208.71,39 208.92,39.21 209.15,39.21
USB3TN2_L: length 3.5
  BOTTOM w0.127: RI60.1 319.57,51.13 LI5.3 318.1,51.13 317.48,50.51 317.48,49.87 CI32.2
USB3TN2_R: length 11.3
  BOTTOM w0.127: RI60.2 320.65,51.13 LI5.4 321.26,51.13 321.48,50.9 322.02,50.9 322.27,51.15 DI5.7 DI5.4 323.83,51.15 323.97,51.02 324.97,51.02 325.52,50.47 325.52,48.84 326.25,48.11 326.8,48.11 327.7,47.21 328.12,47.21 328.22,47.31 JUSB2.8
USB3TN3: length 232.7
  TOP w0.127: CI36.1 18.08,31.1 18.14,31.16 18.46,31.16 v3(18.7,30.91)
  IN1 w0.099: v3(18.7,30.91) 18.37,31.24 18.12,31.24 17.88,31 17.88,30.53 18.99,29.43 18.99,28.03 19.56,27.46 19.56,24.76 20.24,24.08 22.49,24.08 26.95,19.63 26.95,19.17 32.48,13.64 36.21,13.64 37.37,12.49 48.22,12.49 51.15,15.42 53.47,15.42 53.97,15.92 58.1,15.92 58.79,15.23 67.13,15.23 68.35,14.01 73.83,14.01 74.96,12.88 94.55,12.88 95.11,13.44 119.87,13.44 120.31,12.99 127.78,12.99 128.21,13.43 141.04,13.43 141.93,14.33 149.22,14.33 150.44,15.54 151.04,15.54 153.54,18.03 162.93,18.03 163.34,18.45 167.34,18.45 167.85,18.95 172.36,18.95 173.2,18.11 179.47,18.11 179.89,17.69 183.1,17.69 183.78,18.37 189.35,18.37 191.06,20.08 198.24,20.08 203.26,25.1 203.26,39.42 205.01,41.18 206.89,41.18 207.02,41.04 208.28,41.04 209.23,41.99 v3(209.23,42.25)
  BOTTOM w0.089: UH1.BE32 211.82,41.98 211.89,41.98 212.01,42.1 212.01,42.12 212.03,42.13 212.03,42.2 211.89,42.34 211.52,42.34 211.46,42.28 211.46,42.14 211.38,42.07 211.23,42.07 210.98,42.32 210.92,42.32 210.9,42.34 210.89,42.34
  BOTTOM w0.127: v3(209.23,42.25) 209.3,42.19 209.58,42.19 209.73,42.34 210.89,42.34
USB3TN3_L: length 1.9
  TOP w0.127: CI36.2 16.84,31.09 16.24,31.09 LI12.2 15.69,30.78 RI73.1
USB3TN3_R: length 3.9
  TOP w0.127: RI73.2 14.48,30.78 LI12.1 14.02,30.78 13.72,31.08 13.62,31.08 13.21,30.67 13.19,30.67 12.66,30.14 v4(12.4,30.14) 11.94,30.14 11.83,30.03 JIO.7
USB3TN5: length 155.8
  IN5 w0.099: v3(207.52,41.44) 207.53,41.44 207.87,41.79 207.87,41.89 207.81,41.95 205.58,41.95 204.88,42.65 204.88,46.41 213.54,55.08 213.87,55.08 217.31,58.52 229.5,58.52 233.16,62.18 233.16,64.89 233.68,65.41 233.68,71.07 234.33,71.72 234.33,96.6 222.93,108 222.93,117.78 217.1,123.61 209.76,123.61 207.56,125.81 201.46,125.81 199.84,127.43 199.84,128.88 196.54,132.18 193.21,132.18 192.53,132.86 192.53,134.56 v3(192.13,134.96)
  BOTTOM w0.089: UH1.BE26 211.59,39.61 211.5,39.7 209.56,39.7 209.49,39.77
  BOTTOM w0.127: RI78.1 187.85,138.62 LI14.3 187.85,137.99 188.18,137.67 188.18,136.51 188.86,135.83 192.03,135.83 192.37,135.49 192.37,135.2 v3(192.13,134.96) ; 209.49,39.77 209.31,39.77 208.97,40.11 208.5,40.11 207.75,40.86 207.75,41.22 v3(207.52,41.44)
USB3TN5_R: length 4.2
  BOTTOM w0.127: JCDRA.42 187.1,142.23 187.18,142.14 187.18,141.8 v4(187.92,141.07) 188.18,140.81 188.18,140.51 187.85,140.19 LI14.4 187.85,139.57 RI78.2
USB3TN6: length 228.3
  TOP w0.127: CI34.1 18.46,24.86 18.55,24.86 v3(18.7,24.71)
  IN1 w0.099: v3(209.49,41.11) 209.71,40.89 209.71,40.79 208.96,40.04 205.21,40.04 204.15,38.98 204.15,37.24 205.05,36.35 205.05,35.33 204.08,34.36 204.08,24.8 198.57,19.29 191.42,19.29 189.02,16.9 178.48,16.9 178.27,17.11 173.09,17.11 172.03,18.17 168.55,18.17 167.92,17.54 164.43,17.54 161.6,14.71 150.74,14.71 149.52,13.49 143.23,13.49 141.63,11.89 110.96,11.89 110.77,11.7 72.86,11.7 72.54,12.02 69.23,12.02 67.87,13.37 65.49,13.37 64.44,14.42 58.48,14.42 57.77,15.13 56.16,15.13 55.96,14.92 54.27,14.92 53.43,14.09 50.93,14.09 48.42,11.57 36.97,11.57 35.69,12.85 32.15,12.85 31.02,13.99 30.04,13.99 26.1,17.92 26.1,19.36 22.63,22.83 19.74,22.83 19.33,23.24 19.33,23.5 18.23,24.6 18.23,24.83 18.33,24.93 18.48,24.93 v3(18.7,24.71)
  BOTTOM w0.089: 209.97,40.35 210.2,40.12 212.12,40.12 UH1.BD27
  BOTTOM w0.127: 209.97,40.35 209.64,40.68 209.64,40.96 v3(209.49,41.11)
USB3TN6_L: length 1.9
  TOP w0.127: CI34.2 16.85,24.79 16.23,24.79 LI9.2 15.69,24.49 RI67.1
USB3TN6_R: length 3.6
  TOP w0.127: JIO.16 11.63,25.53 11.82,25.72 11.93,25.72 12.02,25.63 12.02,25.63 12.03,25.62 12.6,25.62 12.81,25.4 12.81,25.17 v4(13.17,24.82) 13.32,24.67 13.63,24.67 13.8,24.49 LI9.1
USB3TP1: length 157.8
  IN5 w0.099: v3(210.35,38.64) 210.35,38.92 210.59,39.16 213.03,39.16 213.62,38.57 217.43,38.57 218.3,37.69 220.81,37.69 222.04,38.92 222.38,38.92 222.91,39.45 223.41,39.45 223.64,39.22 224.65,39.22 225.34,38.53 228.53,38.53 228.82,38.81 230.45,38.81 230.66,39.03 232.73,39.03 232.97,39.27 236.48,39.27 236.72,39.51 245.53,39.51 250.55,34.49 253,34.49 259.24,28.26 267.35,28.26 267.76,28.66 269.42,28.66 270.34,27.75 296.51,27.75 297.31,26.95 315.97,26.95 316.86,27.83 316.86,28.21 318.03,29.38 318.85,29.38 319.24,29.78 319.24,30.6 320.22,31.58 320.22,36.93 319.71,37.44 319.71,46.48 318.65,47.55 318.65,49.91 319.83,51.08 319.83,55.29 318.93,56.19 318.93,58.86 320.29,60.21 320.29,61.11 320.05,61.34 319.89,61.34 v3(319.49,61.75)
  BOTTOM w0.102: v3(210.35,38.64) 210.35,38.77 210.44,38.86 211.21,38.86 211.69,38.39 UH1.BD23
  BOTTOM w0.127: CI31.1 317.92,61.59 317.92,61.48 317.98,61.42 318.86,61.42 319,61.56 319.3,61.56 v3(319.49,61.75)
USB3TP1_L: length 3.2
  BOTTOM w0.127: CI31.2 317.85,63.26 317.85,63.61 v4(318.09,63.84) 318.34,64.1 318.6,64.1 318.71,63.98 318.71,63.79 318.83,63.67 LI3.2 319.5,63.67 RI13.1
USB3TP1_R: length 9.8
  BOTTOM w0.127: RI13.2 320.58,63.67 LI3.1 321.37,63.67 321.68,63.99 DI3.6 DI3.5 323.78,63.99 323.94,64.14 324.28,64.14 326.07,65.94 327.03,65.94 327.66,65.3 328.12,65.3 328.22,65.2 JUSB1.9
USB3TP2: length 150.2
  IN5 w0.099: v3(209.08,38.57) 208.83,38.32 208.83,37.99 209.17,37.64 213.06,37.64 213.57,38.16 217.18,38.16 217.99,37.34 224.44,37.34 225.3,38.21 228.73,38.21 228.95,37.99 230.19,37.99 230.49,38.28 236.57,38.28 236.87,38.58 242.74,38.58 243.96,37.37 246.81,37.37 250.36,33.82 252.55,33.82 259.25,27.13 296.14,27.13 297.23,26.04 316.9,26.04 317.55,26.69 317.55,27.94 318.31,28.7 319.56,28.7 320.94,30.09 320.94,35.03 322.07,36.16 322.07,36.92 320.69,38.31 320.69,46.47 319.72,47.44 319.72,47.78 319.94,48 320.2,48 v3(320.55,48.35)
  BOTTOM w0.089: UH1.BC24 212.17,38.79 211.87,39.1 211.55,39.1 211.36,39.29 209.57,39.29 209.24,38.96
  BOTTOM w0.127: 209.24,38.96 209.02,38.96 208.95,38.9 208.95,38.7 v3(209.08,38.57) ; v3(320.55,48.35) 320.31,48.11 v4(319.43,48.11) 317.84,48.11 317.69,48.25 317.69,48.54 317.81,48.66 CI33.1
USB3TP2_L: length 3.6
  BOTTOM w0.127: CI33.2 317.73,49.92 317.73,50.39 v4(317.97,50.64) 318.22,50.88 318.46,50.88 318.58,50.76 318.58,50.36 318.66,50.28 LI5.2 319.57,50.28 RI59.1
USB3TP2_R: length 11.3
  BOTTOM w0.127: JUSB2.9 328.22,46.9 328.15,46.96 327.6,46.96 326.69,47.87 326.15,47.87 325.28,48.74 325.28,50.37 324.87,50.77 323.96,50.77 323.84,50.65 DI5.5 DI5.6 321.62,50.65 321.24,50.28 LI5.1 320.65,50.28 RI59.2
USB3TP3: length 232.9
  TOP w0.127: v3(18.7,31.5) 18.7,31.49 18.61,31.4 18.56,31.4 18.56,31.4 18.33,31.4 CI37.1
  IN1 w0.099: v3(18.7,31.5) 18.63,31.42 18.05,31.42 17.7,31.08 17.7,30.46 18.81,29.35 18.81,27.96 19.38,27.38 19.38,24.68 20.16,23.9 22.42,23.9 26.77,19.55 26.77,19.09 32.4,13.46 36.14,13.46 37.29,12.31 48.29,12.31 51.23,15.24 53.54,15.24 54.04,15.74 58.03,15.74 58.71,15.05 67.06,15.05 68.28,13.83 73.76,13.83 74.89,12.7 94.63,12.7 95.19,13.26 119.79,13.26 120.24,12.81 127.85,12.81 128.29,13.25 141.12,13.25 142.01,14.14 149.3,14.14 150.51,15.36 151.12,15.36 153.62,17.85 163,17.85 163.41,18.26 167.41,18.26 167.92,18.77 172.28,18.77 173.13,17.93 179.39,17.93 179.81,17.51 183.17,17.51 183.85,18.19 189.42,18.19 191.14,19.9 198.32,19.9 203.44,25.02 203.44,39.35 205.09,41 206.81,41 206.95,40.86 208.36,40.86 209.31,41.81 v3(209.76,41.81)
  BOTTOM w0.089: 210.89,42.1 210.91,42.1 211.14,41.86 211.53,41.86 211.65,41.75 211.93,41.75 212.03,41.84 212.21,42.02 212.21,42.03 212.22,42.04 212.22,42.04 212.23,42.04 UH1.BC32
  BOTTOM w0.127: 210.89,42.1 209.83,42.1 209.76,42.03 v3(209.76,41.81)
USB3TP3_L: length 1.9
  TOP w0.127: CI37.2 16.85,31.33 16.23,31.33 LI12.3 15.69,31.63 RI74.1
USB3TP3_R: length 3.9
  TOP w0.127: RI74.2 14.48,31.63 LI12.4 13.97,31.63 13.66,31.32 13.5,31.32 v4(13.26,31.08) 12.57,30.39 11.91,30.39 11.78,30.53 JIO.6
USB3TP5: length 155.9
  IN5 w0.099: v3(192.71,134.96) 192.71,132.94 193.29,132.36 196.61,132.36 200.02,128.96 200.02,127.51 201.54,125.99 207.63,125.99 209.83,123.79 217.17,123.79 223.11,117.86 223.11,108.08 234.51,96.67 234.51,71.64 233.86,70.99 233.86,65.33 233.62,65.1 233.34,64.81 233.34,62.11 229.58,58.34 217.39,58.34 213.94,54.9 213.62,54.9 205.06,46.34 205.06,42.73 205.66,42.13 207.89,42.13 208.11,41.91 v3(208.11,41.44)
  BOTTOM w0.089: 209.49,40.01 209.5,40.01 209.52,39.99 209.58,39.99 209.67,39.9 211.9,39.9 212.11,39.69 212.58,39.69 UH1.BC26
  BOTTOM w0.127: v3(208.11,41.44) 207.99,41.33 207.99,41.32 207.99,40.96 208.6,40.35 209.07,40.35 209.41,40.01 209.49,40.01 ; v3(192.71,134.96) 192.61,135.06 192.61,135.59 192.13,136.07 188.97,136.07 188.43,136.6 v4(188.43,137.02) 188.43,137.72 188.7,137.99 LI14.2 188.7,138.62 RI77.1
USB3TP5_R: length 4.2
  BOTTOM w0.127: JCDRA.43 187.5,142.22 187.43,142.15 187.43,141.9 187.88,141.45 187.89,141.45 188.42,140.92 188.42,140.48 188.7,140.19 LI14.1 188.7,139.57 RI77.2
USB3TP6: length 228.1
  TOP w0.127: CI35.1 18.33,25.11 18.52,25.11 v3(18.7,25.29)
  IN1 w0.099: v3(210.1,41.11) 209.89,40.9 209.89,40.72 209.04,39.86 205.29,39.86 204.33,38.91 204.33,37.31 205.23,36.42 205.23,35.26 204.26,34.29 204.26,24.73 198.64,19.11 191.49,19.11 189.1,16.72 178.41,16.72 178.2,16.93 173.01,16.93 171.96,17.99 168.62,17.99 168,17.36 164.51,17.36 161.67,14.53 150.82,14.53 149.59,13.31 143.31,13.31 141.71,11.71 111.04,11.71 110.85,11.52 72.78,11.52 72.46,11.84 69.15,11.84 67.8,13.19 65.42,13.19 64.37,14.24 58.41,14.24 57.7,14.95 56.24,14.95 56.03,14.74 54.34,14.74 53.5,13.91 51.01,13.91 48.49,11.39 36.9,11.39 35.61,12.67 32.08,12.67 30.94,13.81 29.96,13.81 25.92,17.85 25.92,19.29 22.55,22.65 19.67,22.65 19.15,23.17 19.15,23.42 18.05,24.53 18.05,24.9 18.25,25.11 18.52,25.11 v3(18.7,25.29)
  BOTTOM w0.089: 210.89,40.41 211.74,40.41 UH1.BE28
  BOTTOM w0.127: v3(210.1,41.11) 210,41.01 210,40.67 210.26,40.41 210.89,40.41
USB3TP6_L: length 1.9
  TOP w0.127: RI68.1 15.69,25.34 LI9.3 16.24,25.04 16.84,25.04 CI35.2
USB3TP6_R: length 3.7
  TOP w0.127: LI9.4 14.02,25.34 13.58,24.91 13.44,24.91 13.06,25.29 13.06,25.5 12.69,25.87 v4(12.4,25.87) 12.12,25.87 12.03,25.96 11.79,25.96 11.72,26.03 JIO.15
USB20_CAM_N6_R: length 3.5
  TOP w0.127: RV7.2 97.35,125.39 LV2.2 96.81,125.92 96.81,126.32 96.42,126.71 96.16,126.71 95.67,127.19 95.49,127.19 JEDP1.24
USB20_CAM_P6_R: length 3.5
  TOP w0.127: JEDP1.23 95.87,127.52 95.87,127.34 96.26,126.95 96.52,126.95 97.01,126.47 97.4,126.47 LV2.3 97.92,125.95 98.07,125.95
USB20_N0: length 130.2
  IN5 w0.099: v3(316.36,59.74) 316.11,60 315.94,60 315.22,59.27 315.22,56.42 316.12,55.51 316.12,46.38 316.8,45.69 316.8,32.33 314.81,30.34 313.22,30.34 312.9,30.02 311.03,30.02 310.81,30.24 308.55,30.24 307.89,29.58 300.13,29.58 297.73,31.98 276.5,31.98 276.06,31.55 264.76,31.55 262.31,34 259.88,34 255.88,38 252.9,38 251.51,39.38 249.94,39.38 245.92,43.4 243.29,43.4 241.56,45.13 241.56,45.87 240.65,46.79 235.41,46.79 234.57,45.95 234.57,45.29 v3(234.74,45.12)
  BOTTOM w0.089: 231.83,44.32 231.82,44.33 231.82,44.38 231.55,44.65 231.24,44.65 230.58,43.99 230.25,43.99 230.04,43.78 229.81,43.78 229.75,43.84 229.75,44.05 229.79,44.1 UH1.B37
  BOTTOM w0.127: 231.83,44.32 231.93,44.22 234.03,44.22 234.5,44.68 234.5,44.88 v3(234.74,45.12) ; RI1.1 317.91,59.61 LI1.4 317.13,59.61 316.82,59.92 316.54,59.92 v3(316.36,59.74)
USB20_N0_CONN: length 17.3
  IN6 w0.099: JUSB1.2 326.72,68.21 326.45,68.48 325.95,68.48 325.44,67.97 325.44,63.27 325.2,63.03 324.94,63.03 v3(324.74,62.83)
  BOTTOM w0.127: v3(324.74,62.83) 324.59,62.98 322.26,62.98 322.19,62.92 322.19,62.75 DI2.3 322.61,61.9 322.32,61.61 322.32,61.36 320.74,59.78 320.07,59.78 319.9,59.61 LI1.3 318.99,59.61 RI1.2
USB20_N1: length 257.3
  TOP w0.127: v3(17.04,20.4) 16.94,20.5 16.47,20.5 16.28,20.3 LI7.4 15.69,20.3 RI63.1
  IN6 w0.099: v3(17.04,20.4) 17.43,20.79 18.24,20.79 20.09,22.64 22.71,22.64 25.96,19.39 27.47,19.39 32.56,14.3 36.09,14.3 37.9,12.49 45.03,12.49 47.54,15 49.96,15 50.54,15.58 52.83,15.58 54.04,16.79 58.64,16.79 58.98,16.45 62.16,16.45 63.32,17.61 70.6,17.61 74.44,13.77 87.68,13.77 89.09,12.36 94.43,12.36 96.38,14.31 120.9,14.31 121.36,14.77 140.93,14.77 142.79,16.63 147.5,16.63 148.24,15.89 150.61,15.89 152.39,14.11 153.56,14.11 153.89,13.78 157.46,13.78 158.24,13 167.82,13 168.4,13.59 173.58,13.59 173.86,13.87 182.31,13.87 183.02,13.16 190.74,13.16 193.33,15.75 193.8,15.75 195.02,16.97 205.73,16.97 206.2,17.44 211.01,17.44 212,18.43 214.03,18.43 216.26,20.66 216.76,20.66 219.9,23.8 225.71,23.8 226.93,25.02 226.93,26.74 229.07,28.88 229.61,28.88 230.42,29.69 230.42,32.92 230.17,33.17 230.17,43.41 231.32,44.56 232.43,44.56 232.67,44.79 232.78,44.91 232.78,45.12 v3(233.02,45.35)
  BOTTOM w0.089: UH1.A38 230.48,44.48 230.65,44.65 231.17,45.18 231.46,45.18
  BOTTOM w0.127: 231.46,45.18 232.03,45.18 232.22,44.99 232.65,44.99 v3(233.02,45.35)
USB20_N1_CONN: length 4.8
  TOP w0.127: RI63.2 14.48,20.3 LI7.3 14.05,20.3 13.77,20.59 13.53,20.59 13.22,20.89 13.22,21.63 v4(12.99,21.86) 12.44,22.42 12.28,22.42 12.05,22.64 11.87,22.64 11.76,22.53 JIO.22
USB20_N2: length 130.8
  IN1 w0.099: v3(186.9,137.81) 186.49,138.21 186.49,138.7 187.15,139.36 195.03,139.36 199.96,134.43 200.21,134.43 210.01,124.63 210.01,114.68 212.49,112.21 216.73,112.21 222.9,106.03 224.48,106.03 231.63,98.88 231.94,98.88 234.04,96.79 234.04,70.63 233.35,69.94 233.35,66.24 232.57,65.47 232.57,60.38 232.15,59.95 232.15,51.41 231.63,50.9 231.63,44.96 231.91,44.68 231.91,43.79 231.74,43.62 231.67,43.62 231.46,43.82 v3(231.46,44.03)
  BOTTOM w0.089: UH1.A36 230.38,43.59 230.44,43.53 230.67,43.53 230.73,43.47 230.83,43.47 230.95,43.59 230.95,43.65 230.78,43.82 230.78,43.92 231.28,44.41 231.4,44.41 231.52,44.29 231.52,44.1 v3(231.46,44.03)
  BOTTOM w0.127: v3(186.9,137.81) 186.68,138.03 186.68,138.26 186.97,138.54 LM1.1
USB20_N2_CONN: length 3.1
  BOTTOM w0.127: JCDRA.40 186.3,142.27 186.2,142.17 186.2,141.71 186.65,141.26 186.65,141.01 186.97,140.69 LM1.2
USB20_N3: length 42
  IN5 w0.099: v3(260.12,31.53) 260.29,31.7 260.29,32.22 260.02,32.49 259.34,32.49 254.51,37.31 252.52,37.31 251.13,38.7 249.69,38.7 245.79,42.6 243.03,42.6 241.82,43.8 235.08,43.8 234.95,43.68 234.95,43.59 235.23,43.31 v3(235.33,43.31)
  BOTTOM w0.089: UH1.A34 230.45,42.79 231.02,42.79
  BOTTOM w0.102: 231.02,42.79 231.64,42.79 232.01,43.16
  BOTTOM w0.127: v3(260.12,31.53) 260.29,31.7 260.29,32.03 260.54,32.29 261.09,32.29 262.1,31.28 262.1,31.08 262.16,31.02 262.41,31.02 262.59,31.19 262.69,31.19 UE1.5 ; v3(235.33,43.31) 235.25,43.31 234.61,42.67 233.57,42.67 232.96,43.28 232.13,43.28 232.01,43.16
USB20_N4: length 118.7
  IN6 w0.099: v3(169.45,11.06) 169.53,10.97 169.79,10.97 169.92,11.1 169.92,11.7 170.55,12.33 174.2,12.33 174.6,12.73 180.61,12.73 181.94,11.4 191.06,11.4 195.48,15.82 203.71,15.82 204.15,15.38 213.85,15.38 219.97,21.5 227.23,21.5 229.17,23.44 229.17,26.06 231.99,28.88 231.99,32.95 232.88,33.83 232.88,36.35 232.68,36.55 232.68,42.27 v3(232.27,42.67)
  BOTTOM w0.089: UH1.B33 229.89,42.43 229.77,42.43 229.68,42.52 229.68,42.66 229.81,42.79 230.04,42.79 230.27,42.56 231.21,42.56 231.46,42.3 232.01,42.3
  BOTTOM w0.127: JWLAN1.5 167.11,35.03 167.24,35.15 167.39,35.15 169.29,33.25 169.29,24.48 168.81,23.99 168.81,17.72 169.22,17.31 169.22,16.28 169.69,15.81 169.69,13.83 169.9,13.61 169.9,11.03 169.78,10.9 169.6,10.9 v3(169.45,11.06) ; v3(232.27,42.67) 232.33,42.61 232.33,42.46 232.17,42.3 232.01,42.3
USB20_N5: length 244.1
  TOP w0.127: 91.59,124.02 92.08,123.54 92.08,123.47 91.95,123.34 91.95,123.25 92.33,122.87 92.33,121.99 92.65,121.67 93.26,121.67 93.37,121.56 93.48,121.56 93.62,121.7 93.62,121.88 93.55,121.95 DV2.3 94.17,122.01 94.34,122.01 94.86,122.53 95.36,122.53 96.16,121.73 98.23,121.73 v3(98.43,121.93)
  IN1 w0.099: v3(228.26,42.11) 228.19,42.18 228.19,42.38 228.34,42.53 229.36,42.53 229.66,42.83 229.66,44.8 230.36,45.5 230.36,46.98 229.44,47.89 229.44,49.53 228.83,50.14 228.83,55.35 229.44,55.96 229.44,57.95 232.09,60.61 232.09,65.7 232.83,66.44 232.83,70.1 233.42,70.69 233.42,96.64 231.74,98.32 231.52,98.32 224.28,105.55 222.68,105.55 216.52,111.72 212.24,111.72 209.53,114.43 209.53,124.43 200.1,133.86 199.37,133.86 198.83,134.4 197.93,134.4 196.75,135.57 196.13,135.57 194.33,137.38 188.57,137.38 188.04,136.85 185.51,136.85 184.65,137.71 182.68,137.71 182.3,138.09 182.3,138.94 181.36,139.88 176.31,139.88 175.38,138.94 168.47,138.94 166.61,137.09 165.14,137.09 164.54,136.49 161.25,136.49 160.4,137.34 160.4,137.98 159.86,138.52 157.46,138.52 155.56,140.41 151.54,140.41 150.75,139.63 150.75,138.48 149.14,136.87 142.93,136.87 141.33,135.28 139.84,135.28 139.4,134.84 137.32,134.84 136.88,135.28 131.85,135.28 131.48,135.64 116.58,135.64 115.22,134.28 107.86,134.28 98.98,125.41 98.98,121.92 98.8,121.73 98.63,121.73 v3(98.43,121.93)
  BOTTOM w0.089: v3(228.26,42.11) 228.45,41.93 UH1.F31
USB20_N6: length 233
  TOP w0.127: RV7.1 98.2,124.39 LV2.1 98.73,124 99.12,124 100.08,123.05 100.08,122.59 v3(99.92,122.43)
  IN1 w0.099: v3(227.09,42.11) 226.98,42.22 226.98,46.51 228.26,47.79 228.26,49.68 228.16,49.78 228.16,55.69 228.77,56.29 228.77,58.22 231.43,60.88 231.43,66.07 232.08,66.72 232.08,70.29 232.6,70.81 232.6,95.81 223.77,104.64 222.63,104.64 216.23,111.04 211.95,111.04 208.87,114.12 208.87,124.03 199.79,133.1 199.14,133.1 198.5,133.73 196.86,133.73 195.82,134.78 193.73,134.78 192.35,136.15 183.02,136.15 181.64,137.53 181.64,138.64 181.08,139.19 176.76,139.19 175.83,138.27 171.51,138.27 169.67,136.43 167.47,136.43 166.17,135.13 160.83,135.13 160.74,135.04 158.7,135.04 158.04,135.7 156.21,135.7 155.92,135.99 155.92,137.38 155.52,137.77 154.36,137.77 154.08,138.05 154.08,139.34 153.66,139.75 151.84,139.75 151.45,139.36 151.45,138.21 149.39,136.16 143.2,136.16 141.65,134.62 140.11,134.62 139.61,134.12 137.08,134.12 136.59,134.62 132.51,134.62 131.97,134.08 129.22,134.08 128.32,134.98 119.57,134.98 118.13,133.53 108.64,133.53 100.48,125.37 100.48,123.6 100.15,123.27 100.15,122.67 v3(99.92,122.43)
  BOTTOM w0.089: v3(227.09,42.11) 226.65,41.68 UH1.K31
USB20_N7: length 118.7
  IN5 w0.099: v3(228.26,41.14) 228.22,41.17 228.22,41.43 228.29,41.49 228.67,41.49 229.73,42.56 229.73,44.17 230.98,45.41 231,45.41 231.52,45.94 233.61,45.94 235.19,47.52 240.95,47.52 243.23,45.24 245.5,45.24 250.25,40.49 251.35,40.49 253.14,38.7 256.15,38.7 260.15,34.7 262.55,34.7 264.53,32.71 300.21,32.71 302.67,30.25 307.58,30.25 308.47,31.14 314.58,31.14 316.04,32.61 316.04,42.96 315.15,43.85 315.15,46.38 314.9,46.64 314.56,46.64 v3(314.39,46.8)
  BOTTOM w0.089: v3(228.26,41.14) 227.85,40.73 UH1.G29
  BOTTOM w0.127: LI4.1 317.04,46.93 316.75,46.65 314.54,46.65 v3(314.39,46.8)
USB20_N7_CONN: length 15.6
  IN6 w0.099: JUSB2.2 326.72,49.23 325.83,50.12 325.18,50.12 325.03,49.97 324.69,49.63 324.69,47.74 324.82,47.6 325.01,47.6 v3(325.19,47.78)
  BOTTOM w0.127: LI4.2 319.68,46.93 319.85,46.76 319.85,46.51 319.92,46.45 320.11,46.45 320.38,46.17 320.38,45.66 320.55,45.49 321.64,45.49 321.93,45.79 321.93,46.04 321.87,46.1 321.49,46.1 DI4.3 321.87,46.48 322.02,46.64 322.02,47.25 322.54,47.77 323.85,47.77 324.04,47.58 324.99,47.58 v3(325.19,47.78)
USB20_N8: length 262
  TOP w0.127: v3(17.04,26.72) 16.87,26.89 16.64,26.89 16.34,26.59 LI10.4 15.69,26.59 RI69.1
  IN6 w0.099: v3(17.04,26.72) 17.05,26.72 17.28,26.96 17.39,26.96 17.53,26.83 17.53,26 16,24.48 16,20.37 17.04,19.34 18.29,19.34 18.98,20.03 18.98,20.41 20.28,21.72 22.7,21.72 25.72,18.7 27.23,18.7 32.28,13.64 35.81,13.64 37.63,11.83 45.31,11.83 47.73,14.25 51.9,14.25 52.53,14.88 53.25,14.88 54.44,16.08 58.3,16.08 58.59,15.79 62.43,15.79 63.49,16.84 70.44,16.84 74.31,12.97 87.41,12.97 88.68,11.7 95.53,11.7 97.49,13.65 120.6,13.65 120.99,13.26 139.28,13.26 140.08,14.06 141.18,14.06 142.3,15.18 150.38,15.18 152.11,13.45 153.29,13.45 153.61,13.12 157.09,13.12 158.19,12.02 169.53,12.02 170.36,12.85 174.01,12.85 174.37,13.21 182.03,13.21 182.74,12.5 191.48,12.5 195.29,16.3 204,16.3 204.42,15.88 210.38,15.88 212.21,17.71 215.45,17.71 219.85,22.11 225.6,22.11 227.77,24.28 227.77,26.17 228.57,26.97 229.28,26.97 231.46,29.15 231.46,33.19 231.9,33.63 231.9,34.75 231.47,35.18 231.47,36.4 232.02,36.95 232.02,40.99 231.7,41.3 231.33,41.3 231.24,41.39 231.24,41.54 v3(231.31,41.61)
  BOTTOM w0.089: 231.02,41.9 230.87,42.04 UH1.A32
  BOTTOM w0.127: 231.02,41.9 v3(231.31,41.61)
USB20_N8_CONN: length 3.6
  TOP w0.127: JIO.13 11.76,27.03 11.77,27.02 11.82,27.02 11.93,27.13 v4(12.7,27.13) 13.12,27.13 13.37,26.88 13.63,26.88 13.91,26.59 LI10.3 14.48,26.59 RI69.2
USB20_P0: length 130.4
  IN5 w0.099: v3(234.15,45.12) 234.39,45.36 234.39,46.02 235.34,46.97 240.72,46.97 241.75,45.95 241.75,45.2 243.37,43.58 246,43.58 250.01,39.56 251.59,39.56 252.97,38.18 255.96,38.18 259.96,34.18 262.39,34.18 264.84,31.73 275.99,31.73 276.42,32.16 297.8,32.16 300.2,29.76 307.81,29.76 308.47,30.42 310.88,30.42 311.1,30.2 312.82,30.2 313.14,30.52 314.74,30.52 316.62,32.41 316.62,45.62 315.94,46.3 315.94,55.44 315.04,56.34 315.04,59.35 315.87,60.18 316.21,60.18 v3(316.36,60.33)
  BOTTOM w0.089: 232.01,44.49 231.64,44.86 231.16,44.86 230.5,44.2 230.25,44.2 230.06,44.39 229.8,44.39 229.49,44.08 UH1.D37
  BOTTOM w0.127: v3(316.36,60.33) 316.53,60.16 316.83,60.16 317.13,60.46 LI1.1 317.91,60.46 RI4.1 ; 232.01,44.49 232.03,44.46 233.93,44.46 234.25,44.78 234.25,45.02 v3(234.15,45.12)
USB20_P0_CONN: length 17.3
  IN6 w0.099: v3(324.74,63.42) 324.95,63.21 325.12,63.21 325.26,63.35 325.26,68.05 325.87,68.66 326.38,68.66 326.72,69 JUSB1.3
  BOTTOM w0.127: RI4.2 318.99,60.46 LI1.2 319.9,60.46 320.33,60.02 320.64,60.02 322.07,61.46 322.07,61.7 321.87,61.9 DI2.2 321.95,62.74 321.95,63.02 322.16,63.23 324.55,63.23 v3(324.74,63.42)
USB20_P1: length 257.2
  TOP w0.127: RI64.1 15.69,21.15 LI7.1 16.16,21.15 16.58,20.74 16.79,20.74 v3(17.04,20.98)
  IN6 w0.099: v3(17.04,20.98) 18.17,20.98 20.02,22.82 22.78,22.82 26.04,19.57 27.54,19.57 32.63,14.48 36.16,14.48 37.98,12.67 44.96,12.67 47.47,15.18 49.89,15.18 50.47,15.76 52.76,15.76 53.97,16.97 58.71,16.97 59.06,16.63 62.08,16.63 63.25,17.79 70.68,17.79 74.52,13.95 87.75,13.95 89.17,12.54 94.35,12.54 96.31,14.5 120.83,14.5 121.28,14.95 140.86,14.95 142.71,16.81 147.57,16.81 148.31,16.07 150.68,16.07 152.46,14.29 153.64,14.29 153.96,13.96 157.54,13.96 158.32,13.18 167.75,13.18 168.33,13.77 173.51,13.77 173.79,14.05 182.39,14.05 183.1,13.34 190.67,13.34 193.25,15.93 193.72,15.93 194.94,17.15 205.66,17.15 206.12,17.62 210.93,17.62 211.93,18.61 213.95,18.61 216.19,20.84 216.69,20.84 219.83,23.98 225.63,23.98 226.75,25.1 226.75,26.81 228.99,29.06 229.53,29.06 230.24,29.77 230.24,32.84 229.99,33.1 229.99,43.48 231.25,44.74 232.36,44.74 232.6,44.99 232.6,45.24 v3(232.44,45.4)
  BOTTOM w0.089: UH1.C38 229.58,44.59 230.04,44.59 230.31,44.86 230.56,44.86 231.12,45.42 231.14,45.42
  BOTTOM w0.102: 231.14,45.42 231.16,45.42
  BOTTOM w0.127: v3(232.44,45.4) 232.42,45.42 231.16,45.42
USB20_P1_CONN: length 4.8
  TOP w0.127: RI64.2 14.48,21.15 LI7.2 14.04,21.15 13.72,20.83 13.63,20.83 13.47,21 13.47,21.74 12.99,22.22 12.97,22.22 12.54,22.66 12.38,22.66 12.16,22.89 11.9,22.89 11.76,23.03 JIO.21
USB20_P2: length 131
  IN1 w0.099: v3(231.32,43.44) 231.82,43.44 232.09,43.72 232.09,44.75 231.82,45.03 231.82,50.83 232.33,51.34 232.33,59.87 232.75,60.3 232.75,65.39 233.53,66.17 233.53,69.87 234.22,70.56 234.22,96.86 232.02,99.06 231.71,99.06 224.56,106.21 222.97,106.21 216.8,112.39 212.56,112.39 210.19,114.76 210.19,124.7 200.28,134.61 200.04,134.61 195.11,139.54 187.07,139.54 186.31,138.78 v3(186.31,137.81)
  BOTTOM w0.089: 231.02,43.27 230.65,43.27 230.59,43.33 230.24,43.33 230.02,43.55 229.59,43.55 UH1.C36
  BOTTOM w0.102: v3(231.32,43.44) 231.15,43.27 231.02,43.27
  BOTTOM w0.127: LM1.4 186.16,138.55 186.44,138.28 186.44,137.93 v3(186.31,137.81)
USB20_P2_CONN: length 3
  BOTTOM w0.127: LM1.3 186.16,140.75 186.4,140.99 186.4,141.16 185.96,141.6 185.96,142.2 185.9,142.26 JCDRA.39
USB20_P3: length 42
  IN5 w0.099: v3(260.7,31.53) 260.47,31.77 260.47,32.3 260.1,32.67 259.41,32.67 254.59,37.49 252.59,37.49 251.21,38.88 249.76,38.88 245.87,42.78 243.11,42.78 241.9,43.98 235,43.98 234.77,43.75 234.77,43.46 v3(234.62,43.31)
  BOTTOM w0.089: UH1.C34 229.6,42.98 230.07,42.98 230.24,43.14 230.51,43.14 230.65,43 231.02,43
  BOTTOM w0.102: 231.02,43 231.51,43 231.94,43.44
  BOTTOM w0.127: 231.94,43.44 232.03,43.52 233.06,43.52 233.67,42.92 234.51,42.92 234.67,43.08 234.67,43.27 v3(234.62,43.31) ; UE1.4 262.1,30.65 262.1,30.72 261.85,30.97 261.85,31.18 260.99,32.04 260.64,32.04 260.53,31.93 260.53,31.71 v3(260.7,31.53)
USB20_P4: length 118.7
  IN6 w0.099: v3(232.86,42.67) 232.86,36.63 233.06,36.43 233.06,33.76 232.17,32.87 232.17,28.81 229.35,25.99 229.35,23.37 227.31,21.32 220.04,21.32 213.92,15.2 204.08,15.2 203.64,15.64 195.56,15.64 191.13,11.22 181.86,11.22 180.53,12.55 174.67,12.55 174.28,12.15 170.63,12.15 170.1,11.62 170.1,11.3 v3(170.33,11.07)
  BOTTOM w0.089: UH1.D33 229.47,42.45 229.77,42.15 230.05,42.15 230.25,42.35 231.12,42.35 231.38,42.09 231.89,42.09 231.91,42.07 231.98,42.07 231.99,42.05 232.01,42.05
  BOTTOM w0.127: v3(232.86,42.67) 232.86,42.64 232.27,42.05 232.01,42.05 ; v3(170.33,11.07) 170.15,11.25 170.15,13.72 169.93,13.93 169.93,15.91 169.46,16.38 169.46,17.41 169.05,17.82 169.05,23.89 169.54,24.38 169.54,33.35 167.49,35.4 167.24,35.4 167.1,35.53 JWLAN1.3
USB20_P5: length 244.2
  TOP w0.127: JEDP1.35 91.71,123.2 91.71,123.15 92.09,122.77 92.09,121.89 92.55,121.42 93.17,121.42 93.92,120.68 94.33,120.68 DV2.2 94.55,121.63 94.55,121.88 94.96,122.29 95.26,122.29 96.06,121.49 98.28,121.49 v3(98.43,121.35)
  IN1 w0.099: v3(227.67,42.11) 228.27,42.71 229.28,42.71 229.48,42.91 229.48,44.88 230.18,45.58 230.18,46.9 229.26,47.82 229.26,49.45 228.65,50.07 228.65,55.42 229.26,56.03 229.26,58.03 231.91,60.68 231.91,65.77 232.65,66.51 232.65,70.18 233.23,70.76 233.23,96.56 231.66,98.13 231.45,98.13 224.21,105.37 222.61,105.37 216.44,111.54 212.16,111.54 209.35,114.35 209.35,124.35 200.02,133.68 199.29,133.68 198.76,134.22 197.85,134.22 196.68,135.39 196.05,135.39 194.25,137.2 188.65,137.2 188.12,136.67 185.43,136.67 184.57,137.53 182.6,137.53 182.12,138.01 182.12,138.87 181.28,139.7 176.39,139.7 175.45,138.76 168.54,138.76 166.69,136.91 165.22,136.91 164.62,136.31 161.18,136.31 160.22,137.26 160.22,137.9 159.78,138.34 157.38,138.34 155.49,140.23 151.61,140.23 150.93,139.55 150.93,138.41 149.22,136.69 143,136.69 141.41,135.1 139.91,135.1 139.48,134.66 137.24,134.66 136.8,135.1 131.77,135.1 131.41,135.46 116.65,135.46 115.29,134.1 107.93,134.1 99.16,125.33 99.16,121.85 98.87,121.55 98.63,121.55 v3(98.43,121.35)
  BOTTOM w0.089: v3(227.67,42.11) 227.85,41.94 UH1.G31
USB20_P6: length 232.8
  TOP w0.127: v3(100.55,122.45) 100.32,122.68 100.32,123.15 99.24,124.23 99.24,124.63 LV2.4 98.92,125.1 RV6.1
  IN1 w0.099: v3(100.55,122.45) 100.33,122.66 100.33,123.19 100.66,123.52 100.66,125.3 108.72,133.35 118.2,133.35 119.65,134.8 128.25,134.8 129.15,133.9 132.04,133.9 132.58,134.44 136.51,134.44 137.01,133.94 139.69,133.94 140.19,134.44 141.73,134.44 143.27,135.98 149.47,135.98 151.63,138.14 151.63,139.28 151.92,139.57 153.59,139.57 153.9,139.26 153.9,137.98 154.28,137.59 155.45,137.59 155.74,137.3 155.74,135.92 156.13,135.52 157.96,135.52 158.63,134.86 160.82,134.86 160.91,134.95 166.25,134.95 167.54,136.25 169.75,136.25 171.59,138.09 175.91,138.09 176.84,139.01 181,139.01 181.46,138.56 181.46,137.46 182.94,135.97 192.28,135.97 193.65,134.6 195.75,134.6 196.79,133.55 198.43,133.55 199.06,132.92 199.72,132.92 208.69,123.95 208.69,114.05 211.88,110.86 216.16,110.86 222.56,104.46 223.7,104.46 232.42,95.73 232.42,70.89 231.9,70.37 231.9,66.79 231.25,66.14 231.25,60.96 228.59,58.29 228.59,56.37 227.98,55.76 227.98,49.7 228.08,49.6 228.08,47.86 226.8,46.58 226.8,42.35 226.57,42.11 v3(226.5,42.11)
  BOTTOM w0.089: UH1.L31 226.25,41.63 226.5,41.87 v3(226.5,42.11)
USB20_P7: length 118.7
  IN5 w0.099: v3(314.39,46.22) 314.63,46.46 314.82,46.46 314.97,46.31 314.97,43.78 315.86,42.89 315.86,32.68 314.5,31.32 308.4,31.32 307.51,30.43 302.74,30.43 300.28,32.9 264.61,32.9 262.62,34.88 260.22,34.88 256.22,38.88 253.21,38.88 251.42,40.67 250.32,40.67 245.57,45.42 243.31,45.42 241.03,47.7 235.12,47.7 233.53,46.12 231.45,46.12 230.92,45.59 230.9,45.59 229.55,44.25 229.55,42.64 228.59,41.67 228.21,41.67 227.67,41.14 v3(227.61,41.14)
  BOTTOM w0.089: v3(227.61,41.14) 227.25,40.78 UH1.H29
  BOTTOM w0.127: LI4.4 317.04,46.08 316.72,46.41 314.58,46.41 v3(314.39,46.22)
USB20_P7_CONN: length 15.6
  IN6 w0.099: v3(325.19,47.19) 324.96,47.42 324.75,47.42 324.51,47.66 324.51,49.71 325.1,50.3 325.92,50.3 JUSB2.3
  BOTTOM w0.127: v3(325.19,47.19) 325.04,47.33 323.94,47.33 323.75,47.53 322.65,47.53 322.26,47.14 322.26,46.64 322.42,46.48 DI4.2 322.66,46.1 322.28,46.1 322.18,46 322.18,45.68 321.74,45.25 320.45,45.25 320.14,45.56 320.14,46.07 320.01,46.19 319.76,46.19 319.65,46.08 LI4.3
USB20_P8: length 262.2
  TOP w0.127: v3(17.04,27.31) 16.86,27.13 16.64,27.13 16.33,27.44 LI10.1 15.69,27.44 RI70.1
  IN6 w0.099: v3(230.71,41.62) 230.72,41.62 231.22,41.12 231.63,41.12 231.84,40.91 231.84,37.02 231.29,36.47 231.29,35.11 231.72,34.67 231.72,33.71 231.28,33.26 231.28,29.23 230.89,28.84 230.89,28.84 229.55,27.5 229.55,27.5 229.2,27.15 228.5,27.15 227.59,26.24 227.59,24.35 225.52,22.29 219.78,22.29 215.37,17.89 212.14,17.89 210.31,16.06 204.5,16.06 204.07,16.48 195.21,16.48 191.41,12.68 182.82,12.68 182.11,13.39 174.29,13.39 173.94,13.03 170.29,13.03 169.46,12.2 158.27,12.2 157.17,13.3 153.69,13.3 153.36,13.63 152.19,13.63 150.46,15.36 142.23,15.36 141.11,14.24 140.01,14.24 139.21,13.44 121.07,13.44 120.67,13.83 97.41,13.83 95.46,11.88 88.76,11.88 87.49,13.15 74.38,13.15 70.51,17.02 63.41,17.02 62.36,15.97 58.66,15.97 58.37,16.26 54.37,16.26 53.18,15.06 52.45,15.06 51.82,14.43 47.65,14.43 45.23,12.01 37.7,12.01 35.89,13.82 32.36,13.82 27.3,18.88 25.8,18.88 22.78,21.9 20.21,21.9 18.8,20.49 18.8,20.11 18.21,19.52 17.11,19.52 16.18,20.45 16.18,24.4 17.71,25.92 17.71,26.9 17.46,27.14 17.2,27.14 v3(17.04,27.31)
  BOTTOM w0.089: v3(230.71,41.62) 230.6,41.73 230.25,41.73 230.02,41.96 229.56,41.96 UH1.C32
USB20_P8_CONN: length 3.7
  TOP w0.127: RI70.2 14.48,27.44 LI10.2 13.94,27.44 13.62,27.12 13.47,27.12 13.21,27.39 11.96,27.39 11.82,27.53 JIO.12
USB_OC0#: length 139.2
  TOP w0.127: RPH7.4 220.04,25.43 221.53,26.91 221.53,28.37 222.37,29.21 223.01,29.21 224.18,28.04 v3(224.18,28.02)
  IN1 w0.099: v3(318.99,55.07) 317.18,53.27 317.18,50.7 312.36,45.87 312.36,33.45 306.53,27.62 301.91,27.62 301.64,27.36 290.01,27.36 286.56,23.92 281.97,23.92 281.28,23.23 280.34,23.23 279.75,22.63 274.14,22.63 272.93,23.84 264.42,23.84 255.94,32.32 244.26,32.32 239.34,27.4 238.6,27.4 v3(238.13,27.87)
  IN4 w0.091: v3(224.18,28.02) 225.05,28.88 229.92,28.88 230.41,28.4 234.61,28.4 235.21,27.8 235.96,27.8 236.43,28.27 237.72,28.27 v3(238.13,27.87)
  BOTTOM w0.089: UH1.P3 224.63,29.88 224.63,29.41 224.44,29.22 224.44,28.96 224.58,28.82 224.58,28.41 v3(224.18,28.02)
  BOTTOM w0.127: v1(322.47,53.81) 321.15,53.81 320.75,54.21 CI5.1 320.75,54.88 320.61,55.03 UI2.3 319.51,55.59 v3(318.99,55.07)
USB_OC1#: length 120.8
  TOP w0.127: RPH7.3 220.54,25.35 221.87,26.68 221.87,27.24 222.37,27.74 222.37,28.32 v1(222.47,28.42) 222.65,28.6 v3(223.06,28.6)
  IN1 w0.099: v3(238.1,28.78) 238.59,28.28 239.91,28.28 244.16,32.54 256.04,32.54 264.52,24.07 273.12,24.07 274.32,22.86 279.64,22.86 280.24,23.46 281.09,23.46 281.79,24.16 286.49,24.16 289.93,27.6 301.55,27.6 301.82,27.87 306.44,27.87 311.91,33.34 v3(311.91,36.35)
  IN4 w0.091: v3(223.06,28.6) 223.6,29.14 227.75,29.14 227.79,29.1 230.06,29.1 230.28,28.88 234.85,28.88 235.26,29.29 237.59,29.29 v3(238.1,28.78)
  BOTTOM w0.089: v3(223.06,28.6) 223.11,28.65 223.11,29.07 UH1.V1
  BOTTOM w0.127: UI3.3 319.84,42.13 319.99,41.99 CI29.1 319.7,41.07 319.7,38.99 318.9,38.19 313.76,38.19 v3(311.91,36.35)
USB_OC2#: length 258
  TOP w0.127: JIO.5 12.27,31.03 v3(12.6,31.36) ; RPH7.2 221.04,25.49 222.16,26.61 222.16,26.81 v1(222.42,27.07) 222.81,27.46 v3(223.09,27.46)
  IN4 w0.091: v3(228.77,23.75) 228.77,24.35 228.54,24.58 226.8,24.58 226.58,24.36 220.31,24.36 219.18,25.49 216.93,25.49 v3(216.47,25.03)
  IN6 w0.099: v3(223.09,27.46) 222.84,27.46 221.32,25.95 217.39,25.95 v3(216.47,25.03) 215.25,23.81 215.25,22.23 213.31,20.28 212.6,20.28 211.36,19.04 206.51,19.04 205.65,18.19 200.37,18.19 200.04,17.86 194.65,17.86 193.46,16.67 192.99,16.67 190.42,14.09 183.4,14.09 182.74,14.75 179.81,14.75 179.69,14.88 169.72,14.88 169.35,14.51 167.83,14.51 167.24,13.91 158.66,13.91 157.86,14.71 154.75,14.71 152.64,16.82 148.64,16.82 147.92,17.54 142.44,17.54 140.55,15.66 120.73,15.66 120.38,15.3 95.45,15.3 95.43,15.28 88.79,15.28 88.15,14.64 74.51,14.64 70.57,18.58 69.45,18.58 69.08,18.95 57.24,18.95 55.74,17.45 53.77,17.45 52.56,16.24 50.27,16.24 49.69,15.66 47.27,15.66 44.76,13.15 38.17,13.15 35.96,15.37 32.42,15.37 27.74,20.05 26.24,20.05 22.38,23.9 18.48,23.9 18.23,24.16 18.23,27.14 17.21,28.16 15.8,28.16 v3(12.6,31.36)
  BOTTOM w0.089: UH1.U2 223.62,29.44 223.62,27.78 223.3,27.46
  BOTTOM w0.127: v3(223.09,27.46) 223.3,27.46 ; v3(228.77,23.75) 228.82,23.7 228.82,23.05 228.35,22.58 228.35,21.44 RH72.2
USB_OC3#: length 5.9
  BOTTOM w0.089: UH1.P1 224.77,29.03 224.77,28.01
  BOTTOM w0.127: 224.77,28.01 224.26,27.49 224.26,27.28 v1(224.26,27.28) 224.58,26.96 225.27,26.96 225.9,26.34 225.9,25.66 226.52,25.03 RPH6.1
USB_OC4#: length 12
  TOP w0.127: v3(228.34,24.16) 228.34,22.44 v1(228.13,22.24)
  BOTTOM w0.089: 228.35,24.14 228.35,24.17 v3(228.34,24.16) ; UH1.M3 225.54,29.5 225.85,29.18 225.85,28.95 225.64,28.74 225.64,27.88 225.76,27.76
  BOTTOM w0.127: v3(228.34,24.16) 228.02,24.47 RPH6.4 228.02,25.16 227.75,25.43 227.75,26.27 226.72,27.29 226.22,27.29 225.76,27.76 ; 228.35,24.14 228.35,22.94 228.09,22.68 228.09,22.1 RH72.1
USB_OC5#: length 5.7
  TOP w0.127: RPH7.1 221.54,25.48 221.66,25.59 222.63,25.59 v1(222.88,25.84) 223.09,26.05 v3(223.09,26.88)
  BOTTOM w0.089: 223.81,27.65 223.81,28.97 UH1.T1
  BOTTOM w0.127: v3(223.09,26.88) 223.47,26.88 223.81,27.21 223.81,27.65
USB_OC6#: length 5.9
  BOTTOM w0.089: 225.22,27.65 225.22,29.46 UH1.N2
  BOTTOM w0.127: RPH6.2 v1(227.02,26.07) 226.51,26.58 225.97,26.58 225.22,27.34 225.22,27.65
USB_OC7#: length 5.6
  BOTTOM w0.089: UH1.M1 225.45,28.99 225.45,27.69 225.49,27.65
  BOTTOM w0.127: 225.49,27.65 225.49,27.5 v1(225.95,27.04) 226.61,27.04 227.52,26.13 RPH6.3
USB_PWR_EN#: length 381.2
  TOP w0.127: v3(13.34,32.54) 13.06,32.82 12.58,32.82 11.78,32.03 JIO.3 ; v3(288.77,21.73) 289.05,21.45 UE5.117 ; v3(317.4,54.32) v1(317.4,55.04)
  IN1 w0.099: v3(319.06,39.91) 323.16,35.81 323.16,34.55 323.7,34.01 v3(323.7,26.82)
  IN2 w0.099: v3(288.77,21.73) 281.25,21.73 280.85,21.33 276.34,21.33 274.48,19.47 268.68,19.47 267.13,17.92 261.85,17.92 257.94,14 252.95,14 252.6,13.66 242.4,13.66 241.57,14.48 237.99,14.48 236.82,13.32 232.7,13.32 230.22,10.84 222.09,10.84 221.1,9.84 210.13,9.84 206.46,13.52 194.42,13.52 191.92,11.02 173.09,11.02 172.27,10.2 158.35,10.2 155.22,13.33 150.44,13.33 149.1,14.66 147.56,14.66 145.38,16.85 128.73,16.85 127.5,15.61 120.9,15.61 120.29,15 89.32,15 88.56,14.24 80.7,14.24 78.88,16.06 71.4,16.06 70.94,15.61 57.53,15.61 56.8,14.88 53.06,14.88 52.6,14.42 50.76,14.42 49.01,12.67 37.48,12.67 36.29,13.86 32.46,13.86 29.51,16.8 27.69,16.8 25.73,18.76 25.73,19.26 24.79,20.2 22.2,20.2 21.63,20.77 19.78,20.77 18.41,22.13 16.49,22.13 16.24,22.38 16.24,22.93 13.74,25.43 13.74,32.14 v3(13.34,32.54)
  IN4 w0.091: v3(288.77,21.73) 291.74,24.69 322.7,24.69 323.7,25.69 v3(323.7,26.82)
  IN6 w0.099: v3(317.4,54.32) 317.17,54.09 317.17,41.8 v3(319.06,39.91)
  BOTTOM w0.127: v3(319.06,39.91) 318.15,39.91 317.3,40.76 CI28.1 317.3,41.81 317.44,41.96 UI3.4 ; UI2.4 318.21,55.23 318.06,55.08 CI4.1 v3(317.4,54.32)
USBCHG_DET#: length 10.3
  TOP w0.127: v1(11.88,38.52) 12.47,38.52 CU27.2 14,36.39 13.93,36.31 CU28.1 13.93,35.26 14.39,34.8 DU9.2 14.39,33.26 RU4.2 13.74,33.11 12.33,33.11 11.75,32.53 JIO.2
USBCHG_DET_D: length 14.5
  TOP w0.127: PD100.3 23.93,40.85 20.06,40.85 18.46,39.25 v1(18.46,38.05) 18.46,37.35 18.09,36.98 RU6.1 16.75,37.68 16.33,37.68 16.22,37.8 16.22,38.1 16.36,38.24 UU5.4
USBCHG_DET_EC#: length 309.8
  TOP w0.127: UE5.75 280,10.84 279.73,10.58 v3(279.32,10.58) ; v3(15.58,35.09) 16.36,34.32 DU9.1 16.79,35.67 CU29.1 16.53,35.93 RU6.2
  IN2 w0.099: v3(279.32,10.58) 278.4,11.5 271.11,11.5 269.73,12.87 261.02,12.87 260.32,12.17 253.87,12.17 251.69,10 240.55,10 237.19,6.63 210.82,6.63 206.66,10.8 203.62,10.8 202.72,11.69 197.54,11.69 192.63,6.78 158.77,6.78 157.02,8.53 155.62,8.53 154.79,9.36 151.29,9.36 149.51,11.15 147.9,11.15 147.49,11.56 147.49,12.49 145.85,14.13 145.11,14.13 144.2,15.05 128.56,15.05 127.28,13.77 94.9,13.77 93.7,12.58 70.46,12.58 68.47,14.57 58.58,14.57 56.26,12.25 54.35,12.25 53.04,13.56 50.87,13.56 49.01,11.7 37.07,11.7 35.66,13.11 32.24,13.11 29.24,16.12 27.28,16.12 24.62,18.78 23.86,18.78 23.73,18.91 17.48,18.91 15.54,20.85 15.54,22.67 11.71,26.5 11.71,34.46 12.8,35.55 15.12,35.55 v3(15.58,35.09)
  BOTTOM w0.127: v1(15.34,34.44) 15.34,34.85 v3(15.58,35.09)
USBRBIAS: length 3.4
  TOP w0.089: RH109.1 227.04,38.11 v1(227.55,37.59)
  TOP w0.254: RH109.1 226.85,38.53 226.37,39.01 v3(226.37,39.18)
  BOTTOM w0.254: UH1.K24 226.37,38.98 v3(226.37,39.18) 226.37,39.39 UH1.K26
VCIN0_PH: length 281.3
  TOP w0.254: UE5.109 288.14,18.25 v3(288.08,18.19) ; v3(129.81,90.83) v1(129.81,91.48) 128.37,92.92 124.7,92.92 PH1.1 ; PR24.1 PR25.1 v3(298.48,22.13)
  IN1 w0.254: v3(298.48,22.13) 296.23,19.88 292.25,19.88 290.56,18.19 v3(288.08,18.19) ; v3(177.19,24.74) 177.19,24.81 176.75,25.25 174.96,25.25 172.28,27.93 172.28,28.63 169.53,31.38 167.43,31.38 164.62,34.19 164.62,37.52 165.28,38.18 165.28,40.13 164.56,40.85 162.68,40.85 162.44,41.09 162.44,41.34 159.67,44.11 159.67,44.76 155.81,48.62 154.19,48.62 147.82,54.99 146.24,54.99 141.25,59.98 141.25,64.36 137.25,68.36 137.25,84.24 131.6,89.89 130.75,89.89 v3(129.81,90.83)
  IN6 w0.254: v3(238.45,49.2) 238.45,48.85 239.41,47.89 241.29,47.89 243.62,45.57 245.34,45.57 248.19,42.72 248.19,39.59 256.17,31.6 256.17,30.95 259.29,27.83 259.85,27.83 265.73,21.95 269.22,21.95 275.08,16.09 275.08,13.17 275.9,12.36 279.03,12.36 282.09,15.42 288.32,15.42 288.6,15.7 288.6,17.67 v3(288.08,18.19)
  BOTTOM w0.254: v3(238.45,49.2) 238.45,49.58 238.11,49.93 236.37,49.93 235.79,50.51 235.79,51.62 232.15,55.26 225.63,55.26 223.47,57.42 210.94,57.42 206.67,53.15 206.67,50.85 202.06,46.24 202.06,35.02 199.47,32.43 197.5,32.43 193.11,28.03 193.11,27.44 187.14,21.47 178.13,21.47 176.68,22.91 176.68,24.23 v3(177.19,24.74)
VCIN1_PH: length 5.7
  TOP w0.127: PR26.2 PC13.2 PR23.1 292.48,14.68 292.15,14.68 v1(291.59,15.24) 291.39,15.45 UE5.102
VCORE_VDDP: length 1.1
  BOTTOM w0.127: v1(131.82,122.91) 132.46,123.55 PR523.1
VCOUT0_PH#: length 329.1
  TOP w0.127: UE5.104 288.42,16.25 v3(288.08,15.9) ; v1(27.31,40.73) 27.31,40.16 v3(27.12,39.97)
  TOP w0.254: v3(27.12,39.97) 26.98,39.83 26.98,37.61 26.48,37.11 26.48,36.12 PR114.1
  IN2 w0.099: v3(27.12,39.97) 26.71,40.37 21.58,40.37 17.79,36.58 17.79,36 15.99,34.2 13.79,34.2 12.87,33.28 12.87,31.79 13.27,31.39 13.27,25.27 15.79,22.75 15.79,20.92 17.57,19.14 23.83,19.14 23.96,19.01 24.84,19.01 27.51,16.35 29.33,16.35 32.34,13.34 35.75,13.34 37.16,11.93 48.92,11.93 50.77,13.79 53.13,13.79 54.45,12.47 56.16,12.47 58.48,14.79 70.77,14.79 71.59,15.61 77.57,15.61 79.74,13.45 89.13,13.45 89.93,14.25 120.6,14.25 121.21,14.87 127.67,14.87 128.36,15.55 144.4,15.55 145.32,14.63 146.29,14.63 147.28,13.64 148.96,13.64 152.36,10.24 156.83,10.24 157.87,9.2 172.68,9.2 173.48,9.99 193.25,9.99 196.03,12.77 206.21,12.77 209.95,9.04 221.28,9.04 222.38,10.14 233.7,10.14 236.06,12.5 252.79,12.5 253.39,13.1 259.65,13.1 262.7,16.15 268.31,16.15 268.68,16.52 275.92,16.52 276.32,16.12 280.18,16.12 281.15,15.15 287.33,15.15 v3(288.08,15.9)
