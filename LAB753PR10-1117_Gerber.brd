# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_HTX_GRX_P1: length 48.5
  IN4 w0.112: v3(152.23,82.01) 152.06,82.17 152.06,82.71 153.12,83.77 154.12,83.77 154.49,84.13 154.49,90.4 152.16,92.72 144.24,92.72 140.93,96.03 137.2,96.03 136.11,97.12 133.87,97.12 132.7,98.29 132.7,99.42 130.47,101.65 125.41,101.65 125.08,101.31 125.08,101.13 124.97,101.02 v3(124.72,101.02)
  BOTTOM w0.089: CPU1.B5 124.81,101.02 v3(124.72,101.02)
  BOTTOM w0.14: CC14.1 152.65,83.01 152.65,83.27 152.53,83.39 152.16,83.39 152.02,83.25 152.02,82.21 v3(152.23,82.01)
PEG_HTX_GRX_P2: length 44.2
  IN4 w0.089: 124.19,98.7 124.2,98.71 124.2,99.08 124.08,99.2 124.08,99.39 v3(123.87,99.6)
  IN4 w0.112: v3(151.41,84.41) 151.28,84.29 151.28,83.91 151.04,83.67 150.55,83.67 148.43,85.79 145.9,85.79 145.53,86.16 139.82,86.16 136.97,89 135.08,89 131.07,93.02 124.31,93.02 123.57,93.75 123.57,98.08 124.19,98.7
  BOTTOM w0.089: CPU1.D6 123.92,99.6 v3(123.87,99.6)
  BOTTOM w0.14: CC15.1 155.04,84.38 155.04,84.6 154.91,84.72 154.45,84.72 154.06,85.11 152.64,85.11 152.4,84.88 151.93,84.88 151.91,84.85 151.37,84.85 151.27,84.75 151.27,84.55 v3(151.41,84.41)
PEG_HTX_GRX_P3: length 44.3
  IN4 w0.089: 126.12,100.72 126.1,100.71 125.53,100.71 125.08,100.26 125.08,100.17 125.05,100.14 125.05,99.19 125.36,98.88 125.43,98.88 v3(125.62,98.69)
  IN4 w0.112: v3(151.58,85.61) 151.58,85.94 151.69,86.05 152.39,86.05 153.77,87.44 153.77,90.12 151.87,92.02 143.92,92.02 141.7,94.24 135.59,94.24 128.9,100.94 126.33,100.94 126.12,100.72
  BOTTOM w0.089: CPU1.E4 125.96,99.02 v3(125.62,98.69)
  BOTTOM w0.14: CC16.1 152.97,85.94 152.97,86.25 152.9,86.32 152.5,86.32 152.24,86.07 151.61,86.07 151.41,85.87 151.41,85.78 v3(151.58,85.61)
PEG_HTX_GRX_P4: length 42.3
  IN4 w0.089: 126.06,99.79 126.06,98.9 125.99,98.83 125.99,98.54 125.84,98.39 125.84,98.05 v3(125.66,97.87)
  IN4 w0.112: 126.06,99.79 126.43,100.16 127.45,100.16 127.84,99.78 129.04,99.78 135.42,93.4 138.61,93.4 139.54,92.47 142.34,92.47 143.49,91.32 151.58,91.32 153.05,89.85 153.05,88.54 152.15,87.63 151.99,87.63 151.8,87.44 151.8,86.96 v3(151.93,86.83)
  BOTTOM w0.089: v3(125.66,97.87) 125.66,97.53 125.53,97.4 CPU1.G5
  BOTTOM w0.14: v3(151.93,86.83) 151.72,87.04 151.72,87.29 152.12,87.7 153.04,87.7 153.2,87.53 154.88,87.53 155,87.41 155,87.15 CC17.1
PEG_HTX_GRX_P5: length 32.4
  IN4 w0.112: v3(127.26,99.49) 127.52,99.23 127.95,99.23 131.47,95.71 131.82,95.71 135.91,91.61 138.09,91.61 138.87,90.82 143,90.82 143.33,90.49 148.44,90.49 149.93,89 150.37,89 150.48,89.12 151.01,89.12 151.07,89.05 151.58,89.05 151.79,88.85 151.79,88.57 v3(151.94,88.42)
  BOTTOM w0.089: v3(127.26,99.49) 127.26,99.28 CPU1.E2
  BOTTOM w0.14: CC18.1 153.16,88.55 153.16,88.85 153.08,88.94 151.93,88.94 151.74,88.75 151.74,88.61 v3(151.94,88.42)
PEG_HTX_GRX_P6: length 38.4
  IN4 w0.112: v3(124.38,96.13) 124.52,96 124.52,95.79 125.05,95.26 125.82,95.26 126.27,95.71 126.79,95.71 127.18,95.32 127.18,95 127.52,94.66 129.72,94.66 130.47,93.91 131.22,93.91 135.36,89.76 137.33,89.76 140.19,86.9 149.17,86.9 v3(149.32,86.76)
  BOTTOM w0.089: CPU1.J6 124.72,96.47 v3(124.38,96.13)
  BOTTOM w0.14: v3(149.32,86.76) 149.51,86.95 149.93,86.95 150.34,87.37 150.34,88.68 150.8,89.13 150.8,89.69 151.14,90.03 152.26,90.03 152.44,90.21 154.59,90.21 CC19.1
PEG_HTX_GRX_P7: length 33.6
  IN4 w0.112: v3(149.45,87.99) 149.16,88.28 149.16,88.7 148.26,89.6 143.23,89.6 142.74,90.1 138.58,90.1 137.87,90.81 135.64,90.81 131.59,94.86 130.83,94.86 128.03,97.66 127.23,97.66 v3(127.1,97.79)
  BOTTOM w0.089: CPU1.G2 127.5,97.4 v3(127.1,97.79)
  BOTTOM w0.14: v3(149.45,87.99) 149.32,88.13 149.32,88.74 149.68,89.11 149.68,90.18 151.08,91.58 152.54,91.58 152.65,91.47 152.65,91.2 CC20.1
PEG_HTX_GRX_P8: length 82.5
  IN6 w0.119: v3(167.78,137.33) 168.03,137.09 168.03,137 167.81,136.78 165.77,136.78 164.44,135.45 162.89,135.45 162.59,135.15 161.66,135.15 161.06,134.56 154.61,134.56 153.28,133.23 153.1,133.23 147.05,127.18 147.05,117.96 151.39,113.62 151.39,105.08 150.35,104.04 146.91,104.04 141.72,98.85 137.22,98.85 136.62,98.25 135.1,98.25 134.99,98.36 134.99,98.83 135.07,98.91 135.25,98.91 135.4,98.75 v3(135.4,98.69)
  BOTTOM w0.089: CPU1.J4 126.24,96.47 126.24,96.33 126.47,96.1 128.71,96.1 128.85,95.95 129.76,95.95 129.77,95.94 129.8,95.94
  BOTTOM w0.14: v3(167.78,137.33) 167.92,137.47 167.92,137.73 CC21.1 ; v3(135.4,98.69) 135.06,98.35 135.06,97.18 133.33,95.45 v4(132.77,95.45) 131.24,95.45 130.75,95.94 129.8,95.94
PEG_HTX_GRX_P9: length 83.3
  IN6 w0.119: v3(132.06,99.17) 132.06,98.88 132.16,98.78 133.15,98.78 134.4,97.54 137.06,97.54 137.64,98.12 142,98.12 147.21,103.33 150.64,103.33 152.1,104.79 152.1,113.91 147.87,118.14 147.87,126.63 153.14,131.9 153.41,131.9 154.59,133.07 160.71,133.07 161.69,134.06 165.59,134.06 166.77,135.24 168.11,135.24 168.32,135.45 168.32,136.09 168.65,136.42 169.24,136.42 169.43,136.6 169.43,137.1 v3(169.18,137.34)
  BOTTOM w0.14: CPU1.J1 128.4,96.81 131.56,96.81 132.87,98.12 132.87,98.59 132.62,98.85 132.38,98.85 v3(132.06,99.17) ; CC22.1 169.85,138.72 169.85,138.52 169.34,138.01 169.34,137.51 v3(169.18,137.34)
PEG_HTX_GRX_P10: length 89.9
  IN6 w0.119: v3(125.1,91.28) 124.93,91.44 124.7,91.44 124.4,91.74 124.4,92.48 125.61,93.69 125.61,95.32 126.37,96.09 130.71,96.09 131.07,95.72 132.43,95.72 133.54,96.83 137.4,96.83 137.99,97.41 142.29,97.41 147.5,102.62 150.94,102.62 152.81,104.49 152.81,114.21 148.61,118.41 148.61,124.7 149.92,126.01 149.92,126.59 151.76,128.44 151.76,129.01 153.11,130.36 153.46,130.36 155.01,131.91 160.58,131.91 161.85,133.18 165.81,133.18 167.07,134.44 168.39,134.44 168.68,134.74 171.08,134.74 171.81,135.47 171.81,136.61 v3(171.62,136.81)
  BOTTOM w0.089: CPU1.T5 125.42,91.6 v3(125.1,91.28)
  BOTTOM w0.14: CC23.1 171.81,137.59 171.81,137 v3(171.62,136.81)
PEG_HTX_GRX_P11: length 90.1
  IN6 w0.119: v3(135.61,95.66) 135.43,95.84 135.28,95.84 135.19,95.75 135.19,95.24 135.32,95.11 138.71,95.11 139.6,96 141.89,96 147.8,101.91 151.23,101.91 153.59,104.26 153.59,114.44 149.36,118.67 149.36,124.41 155.31,130.36 160.86,130.36 161.87,131.37 165.28,131.37 165.51,131.6 166.56,131.6 168.47,133.52 171.15,133.52 173.86,136.22 173.86,137.26 173.59,137.53 v3(173.59,137.57)
  BOTTOM w0.089: CPU1.R5 125.3,92.52 125.22,92.6 125.22,92.73 125.32,92.83 129.25,92.83 129.33,92.75 129.38,92.75 129.4,92.73 129.42,92.73 ; 129.8,92.73 129.78,92.73
  BOTTOM w0.14: v3(173.59,137.57) 173.76,137.75 173.76,138.93 CC24.1 ; 129.78,92.73 129.42,92.73 ; v3(135.61,95.66) 135.31,95.35 135.31,95.1 134.87,94.66 134.64,94.66 133.59,93.61 133.59,93.58 133.21,93.2 133.18,93.2 132.71,92.73 129.8,92.73
PEX_TERMP: length 6.2
  TOP w0.127: RV57.2 157.13,100.14 157.23,100.24 v1(158,100.24) 158.09,100.15 v3(158.09,99.67)
  BOTTOM w0.127: UV1.BJ38 160.8,97.42 158.55,99.67 v3(158.09,99.67)
PEX_TSTCLK_OUT: length 8.3
  TOP w0.102: RV54.2 167.41,97.86 166.78,97.86 166.44,98.2 v4(163.84,98.2) 163.18,98.2 162.83,98.55 161.74,98.55 161.46,98.27 161.46,97.84 v3(161.2,97.58)
  BOTTOM w0.089: UV1.BH38 v3(161.2,97.58)
PEX_TSTCLK_OUT#: length 7.9
  TOP w0.102: RV54.1 167.57,97.63 166.68,97.63 166.34,97.97 163.09,97.97 162.73,98.33 161.83,98.33 161.69,98.18 161.69,97.89 v3(162,97.58)
  BOTTOM w0.089: UV1.BG38 v3(162,97.58)
PHASE1: length 8.3
  TOP w0.127: v3(134.69,123.66) 134.69,123.41 v2(134.06,122.79)
  IN2 w1.016: 127.45,120.61 131.57,120.61 133.73,122.77
  vias: v3(124.59,122.58) v3(124.59,121.95) v3(124.59,121.31) v3(124.69,126.85) v3(124.69,126.21) v3(124.69,124.09) v3(124.69,123.4) v3(125.22,122.58) v3(125.22,121.95) v3(125.22,121.31) v3(125.86,122.58) v3(125.86,121.95) v3(125.86,121.31) v3(126.49,122.58) v3(126.49,121.95) v3(126.49,121.31) v3(126.82,126.85) v3(126.82,126.21) v3(126.82,124.11) v3(126.82,123.41) v3(135.13,124.11)
PHASE2: length 19.1
  TOP w0.127: v3(132.78,127.41) v2(132.23,127.95)
  IN2 w1.016: 116.51,127.68 116.51,128.35 118.62,130.46 127.35,130.46 128.56,129.25 131.13,129.25 132.27,128.11
  vias: v3(115.57,122.52) v3(115.57,121.88) v3(115.57,121.25) v3(116.18,126.85) v3(116.18,126.21) v3(116.18,124.03) v3(116.18,123.4) v3(116.21,122.52) v3(116.21,121.88) v3(116.21,121.25) v3(116.84,122.52) v3(116.84,121.88) v3(116.84,121.25) v3(117.48,122.52) v3(117.48,121.88) v3(117.48,121.25) v3(118.3,126.84) v3(118.3,126.2) v3(118.32,124.03) v3(118.32,123.4) v3(133.23,126.96)
PHASE3: length 6.5
  TOP w0.127: PC508.1 107.76,119.51 v1(107.11,118.86)
  IN2 w1.016: 103.19,118.84 106.11,121.76 106.49,121.76
  vias: v3(102.36,118.33) v3(102.36,117.74) v3(107.38,122.71) v3(107.38,122.07) v3(107.38,121.44) v3(107.8,126.85) v3(107.8,126.21) v3(107.81,124.04) v3(107.81,123.41) v3(108.02,122.71) v3(108.02,122.07) v3(108.02,121.44) v3(108.65,122.71) v3(108.65,122.07) v3(108.65,121.44) v3(109.29,122.71) v3(109.29,122.07) v3(109.29,121.44) v3(109.93,126.85) v3(109.93,126.21) v3(109.93,124.03) v3(109.93,123.4) v3(109.92,122.71)
PLIMIT: length 6.7
  BOTTOM w0.127: RA112.1 6.02,34.55 v1(6.39,34.91)
  BOTTOM w0.254: RA112.1 6.28,33.67 6.28,33.03 6.01,32.77 6.01,32.21 6.96,31.26 CA99.1 6.96,30.76 6.66,30.46 6.66,29.48 UA4.1
PLT_RST#: length 258.5
  TOP w0.127: v3(175.96,17.52) 175.96,17.8 175.6,18.15 175.6,19.31 173.85,21.06 173.85,21.76 RM33.2 ; v3(317.07,25.41) 317.07,23.28 v1(317.5,22.85) 317.5,19.99 322.44,15.05 v3(323.73,15.05) 324.33,15.05 325.88,16.6 UR1.1 ; UE5.13 283.6,28.74 v3(283.6,28.75) 283.6,29.23 CE34.1 ; v3(313.49,26.52) 314,26.52 315.25,27.78 315.25,28.35 315.66,28.76 315.66,29.73 316.45,30.52 316.83,30.52 317.05,30.75 UL1.2 ; UH3.4 221.2,20.52 221.02,20.35 v3(221.02,19.93) 220.17,19.08 219.06,19.08 218.55,18.56 216.02,18.56 215.66,18.56 215.65,18.57 211.64,18.57 209.38,20.83 208.29,20.83 207.67,21.45 v3(207.09,21.45)
  IN1 w0.099: v3(313.49,26.52) 315.97,26.52 v3(317.07,25.41)
  IN6 w0.099: v3(207.09,21.45) 202.4,21.45 201.84,20.89 200.1,20.89 199.14,19.93 193.34,19.93 192.09,18.69 191.53,18.69 190.42,17.57 189.38,17.57 188.84,17.03 180.51,17.03 180.44,17.1 178.33,17.1 178.17,17.26 177.01,17.26 176.86,17.11 176.37,17.11 v3(175.96,17.52) ; v3(313.49,26.52) 309.41,26.52 304.57,31.36 300.52,31.36 298.82,29.66 284.51,29.66 v3(283.6,28.75) ; v3(323.73,15.05) 312.18,15.05 310.34,13.21 307.7,13.21 305.63,11.14 276.79,11.14 275.86,10.21 274.55,10.21 272.23,12.54 272.23,14.06 271.46,14.82 270.68,14.82 270.27,15.23 264.69,15.23 262.64,13.17 242.42,13.17 242.1,12.85 238.04,12.85 237.39,13.5 237.39,15.03 v3(237.2,15.22) 237.2,17.34 238.1,18.24 238.1,19.67 238.87,20.44 238.87,23.47 241.88,26.48 241.88,28.66 243.9,30.68 v3(243.9,33.81)
  BOTTOM w0.127: v3(221.02,19.93) 221.27,19.93 222.02,19.18 222.02,18.44 222.46,18.01 223.97,18.01 224.25,18.29 225.97,18.29 226.19,18.07 RH43.2 ; RH43.2 226.47,17.77 226.47,17.06 226.94,16.59 227.41,16.59 227.84,16.16 227.84,15.71 228.27,15.28 234.01,15.28 234.71,15.98 236.44,15.98 v3(237.2,15.22) ; RH43.2 227.1,18.96 RH51.1 ; UT2.16 243.66,32.9 243.9,33.15 v3(243.9,33.81)
PLT_RST#_R: length 3.4
  TOP w0.127: v3(171.81,23.46) 171.87,23.52 RM33.1
  BOTTOM w0.127: JWLAN1.44 171.98,23.28 v3(171.81,23.46)
PM_APWROK_R: length 14.1
  TOP w0.127: v3(221.86,31.85) 221.86,30.03 220.12,28.28 220.12,27.5 218.35,25.73 v2(218.35,25.21) 217.87,24.73 217.87,22.27 217.45,21.85 RH50.2
  BOTTOM w0.089: v3(221.86,31.85) 221.62,31.61 UH1.AB7
PM_CLKRUN#: length 10.8
  TOP w0.089: v3(216.3,31.3) 216.14,31.46 215,31.46 214.79,31.67 213.5,31.67 213.41,31.59 211.03,31.59 RH33.2
  TOP w0.127: RH67.2 207.85,33.35 v1(208.28,32.92) 208.64,32.56 210.05,32.56 RH33.2
  BOTTOM w0.089: v3(216.3,31.3) 216.61,31.61 UH1.AN7
PM_DRAM_PWRGD: length 232.3
  TOP w0.127: v3(77.62,63.31) 76.82,64.11 76.82,65.67 v1(77.65,66.5) 78.18,67.03 90.76,67.03 91.01,66.78 91.01,64.81 89.78,63.58 RC31.1
  IN4 w0.091: v3(231.29,22.15) 230.62,22.82 228.39,22.82 227.84,23.37 208.57,23.37 v3(208.04,22.84)
  IN6 w0.099: v3(77.62,63.31) 77.12,62.8 77.12,51.31 76.09,50.28 76.09,47.87 73.74,45.52 73.74,37.83 72.29,36.38 72.29,29.97 74.23,28.03 74.97,28.03 77.06,25.94 79.4,25.94 81.02,24.32 81.02,19.07 82.45,17.65 140.75,17.65 141.98,18.88 152.58,18.88 153.29,18.16 154.66,18.16 155.75,17.07 159.55,17.07 160.52,16.09 165.28,16.09 166.11,16.92 168.91,16.92 170.96,18.97 175.09,18.97 175.45,18.61 182.85,18.61 183.5,19.25 190.85,19.25 191.16,19.57 191.73,19.57 193.05,20.89 198.85,20.89 199.73,21.77 201.48,21.77 202.06,22.35 207.56,22.35 v3(208.04,22.84)
  BOTTOM w0.127: v3(231.29,22.15) 231.6,22.46 RH52.1
PM_DRAM_PWRGD_R: length 7.8
  BOTTOM w0.127: UH1.H3 227.16,29.57 227.47,29.26 227.47,29.01 227.98,28.5 227.98,27.86 228.68,27.17 229.66,27.17 v1(231.23,25.59) 231.6,25.22 RH52.2
PM_SLP_S3#: length 105
  TOP w0.127: v3(287.01,22.15) 286.5,22.66 286.5,23.94 286.86,24.3 286.86,24.89 286.26,25.49 286.26,26.34 286.4,26.48 UE5.6 286.4,28.42 286.58,28.6 287.02,28.6 287.21,28.79 287.21,29.54 CE41.1
  IN1 w0.099: v3(287.01,22.15) 286.54,21.68 281.37,21.68 280.77,21.08 264.9,21.08 260.91,25.07 v3(259.82,25.07) 259.54,25.35 259.54,26.45 255.25,30.73 245.16,30.73 237.34,22.91 237.34,20.95 236.14,19.76 231.91,19.76 231.69,19.98 231.69,23.1 231.21,23.59 229.96,23.59 227.53,26.02 v3(227.53,28.22)
  BOTTOM w0.089: 227.34,28.41 227.16,28.59 UH1.H1
  BOTTOM w0.127: T76.1 231,25.21 229.35,26.86 228.54,26.86 227.53,27.87 v3(227.53,28.22) 227.34,28.41 ; QE1.2 261.16,17.24 260.57,17.24 258.38,19.42 258.38,23.64 v3(259.82,25.07)
PM_SLP_S4#: length 82.4
  TOP w0.127: UE5.84 283.6,10.49 v3(283.61,10.48)
  IN1 w0.099: v3(283.97,22.15) 283.78,21.96 281.33,21.96 280.87,21.5 273.67,21.5 273.27,21.9 264.73,21.9 255.44,31.19 244.97,31.19 237.05,23.27 v3(235.96,23.27)
  BOTTOM w0.089: 231.02,29.63 230.94,29.71 230.94,30.8 230.52,31.22 230.26,31.22 230.04,31.44 UH1.C6
  BOTTOM w0.127: v3(235.96,23.27) T75.1 233.85,23.98 233.54,23.98 232.62,24.91 232.62,25.78 231.76,26.63 231.76,28.88 231.02,29.63 ; v3(283.97,22.15) 284.2,21.92 284.2,17.53 283.44,16.77 283.44,15.79 282.41,14.76 282.41,11.67 v3(283.61,10.48)
PM_SLP_S5#: length 83.7
  TOP w0.089: T74.1 222.62,31.87 v3(222.74,31.87)
  TOP w0.127: CE45.1 282.96,28.82 283.2,28.58 UE5.14 283.2,23.39 v3(283.1,23.29)
  IN4 w0.089: 231.59,32.51 229.76,32.51
  IN4 w0.091: 229.76,32.51 228.82,32.51 228.44,32.13 227.94,32.13 227.7,31.89 226.49,31.89 226.07,32.31 224.55,32.31 224.46,32.22 223.09,32.22 v3(222.74,31.87) ; 231.59,32.51 231.76,32.51 232.55,33.3 235.46,33.3 235.76,33 237.58,33 238.57,33.99 241.57,33.99 241.78,33.77 241.78,33.49 245.15,30.12 253.65,30.12 258.13,25.64 260.55,25.64 263.65,22.53 263.96,22.53 264.63,21.86 271.32,21.86 271.52,22.06 273.56,22.06 273.98,21.64 281.71,21.64 283.1,23.03 v3(283.1,23.29)
  BOTTOM w0.089: UH1.Y7 222.47,31.61 v3(222.74,31.87)
  BOTTOM w0.127: v3(283.1,23.29) 282.68,23.71 281.7,23.71 281.37,23.38 281.37,21.07 279.26,18.96 QE3.2
PM_SLP_SUS#: length 65.6
  TOP w0.127: UE5.38 273.45,23.85 272.87,23.27 272.25,23.27 271.81,22.82 271.81,21.81 272.13,21.49 v3(272.47,21.49) ; v3(228.67,27.71) 228.67,27.7 T77.1
  IN1 w0.099: v3(272.47,21.49) 264.81,21.49 255.35,30.96 245.06,30.96 237.11,23.01 237.11,21.05 236.06,19.99 234.43,19.99 233.87,20.55 233.87,23.83 233.74,23.97 232.53,23.97 228.78,27.71 v3(228.67,27.71)
  BOTTOM w0.089: UH1.F1 228.56,28.41
  BOTTOM w0.127: 228.56,28.41 228.67,28.3 v3(228.67,27.71)
PM_SYS_PWRGD_BUF: length 54.1
  TOP w0.089: 90.81,80.2 91.83,80.2 92.15,79.87 95.99,79.87 v3(96.31,80.2)
  TOP w0.127: v3(77.62,67.46) 91.02,67.46 91.51,66.98 91.51,63.86 RC30.1 RC26.2 89.42,62.66 RC31.2 87.94,63.39 UC1.4 ; v3(78.83,79.38) 79.65,80.2 v2(89.17,80.2) 90.81,80.2
  IN1 w0.099: v3(78.83,79.38) 76.65,77.2 76.65,68.43 v3(77.62,67.46)
  BOTTOM w0.089: v3(96.31,80.2) 96.61,79.9 CPU1.AP48
POK: length 68.6
  TOP w0.203: PU100.7 23.04,27.05 22.79,26.8 22.79,24.04 23.43,23.4 25.72,23.4 27.55,21.57 27.55,19.68 28.96,18.27 28.96,16.38 28.51,15.93 28.51,13.38 30.86,11.03 30.86,9.95 31.14,9.67 32.54,9.67 33.33,8.88 36.83,8.88 37.94,9.98 47.08,9.98 48.4,8.66 58.28,8.66 v3(58.41,8.79)
  TOP w0.254: v3(70.8,13.07) v1(70.17,13.07) 69.95,13.29 PR14.1 69.48,14.06 69.45,14.08 PR17.1
  IN4 w0.254: v3(70.8,13.07) 68.93,13.07 68.14,12.28 64.91,12.28 61.42,8.79 v3(58.41,8.79)
POWER_LED: length 11.2
  BOTTOM w0.127: QE9.1 286.25,6.57 282.5,6.57 282.07,7 QE8.2 280.79,6.57 280.09,6.57 RE28.2 v1(278.09,7.32)
PS_ID: length 24.4
  TOP w0.127: v1(289.03,36.76) 288.69,36.42 PR4.2
  TOP w0.203: v3(282.31,24.63) 282.31,26.41 282.4,26.49 UE5.16
  TOP w0.254: v3(281.22,35.73) 282.13,36.64 284.61,36.64 285.4,35.85 286.74,35.85 287.11,35.49 PR3.1 PR4.2
  BOTTOM w0.254: v3(282.31,24.63) 282.61,24.93 282.61,29.98 282.31,30.28 282.31,34.63 v3(281.22,35.73)
PSID: length 250.7
  TOP w0.127: v3(60.76,30.08) v2(61.44,30.08)
  TOP w0.254: v3(279.36,35.74) 279.53,35.91 PL2.2
  IN3 w0.254: v3(279.36,35.74) 278.03,35.74 275.35,33.06 245.69,33.06 240.46,27.84 240.46,26.41 238.77,24.72 238.77,24.06 237.73,23.01 237.73,20.53 235.82,18.62 233.99,18.62 232.07,16.7 230.82,16.7 229.33,15.2 215.27,15.2 214.01,16.46 206.14,16.46 205.51,17.08 204.7,17.08 204.08,16.46 193.08,16.46 190.98,14.37 175.25,14.37 173.17,12.28 162.64,12.28 160.86,14.06 158.42,14.06 156.57,15.91 154.09,15.91 151.12,18.89 146.85,18.89 146.61,18.65 131,18.65 130.53,19.12 130.53,23.54 129.3,24.77 78.53,24.77 v3(76.77,23.01)
  IN6 w0.254: v3(60.76,30.08) 63.93,30.08 71,23.01 v3(76.77,23.01)
  BOTTOM w0.254: v3(60.76,30.08) PJPDC1.10
PSID-1: length 3.4
  TOP w0.127: PQ2.2 283.13,34.14 v1(282.97,34.29)
  TOP w0.254: PQ2.2 282.55,33.2 PR9.2 282.01,34.61 PR6.1
PSID-2: length 4.6
  TOP w0.127: PR8.2 287.07,33.24 v1(287.23,33.39)
  TOP w0.254: PQ2.1 285.33,32.55 PR8.2 286.01,33.94 285.89,34.06 PQ7.2
PSID-3: length 3.6
  TOP w0.127: v1(288.48,38.61) 288.48,38.16 PR4.1
  TOP w0.254: PR4.1 287.16,36.83 PQ7.3
PWM3: length 41.7
  TOP w0.127: v3(133.54,124.87) 134.22,124.87 v2(134.74,125.39)
  TOP w0.254: PU501.3 103.88,114.77 102.94,113.82 v3(102.87,113.82)
  IN4 w0.254: v3(102.87,113.82) 106.81,117.76 130.56,117.76 133.29,120.49 133.29,124.61 v3(133.54,124.87)
PWR_B_7313#: length 66.1
  TOP w0.127: UE3.17 216.18,114.85 216.09,114.94 215.85,114.94 215.31,114.39 213.88,114.39 213.4,114.87 v3(213.4,115.61) 212.99,115.61 212.49,115.1 v2(212.49,114.38) ; JPWR1.19 182.15,147.26 182.06,147.17 182.06,146.41 182.41,146.05 183.52,146.05 184.8,144.77 184.8,144.05 185.36,143.49 185.36,134.27 v3(183.3,132.21)
  IN6 w0.099: v3(213.4,115.61) 211.39,117.62 202.88,117.62 200.04,120.46 200.04,124.71 198.87,125.87 198.87,128.83 196.08,131.62 183.89,131.62 v3(183.3,132.21)
PWR_G_7313#: length 60.7
  TOP w0.127: v3(182.7,132.2) 182.35,132.55 182.35,134.53 182.23,134.64 182.23,143 181.8,143.43 181.8,147.14 181.65,147.3 JPWR1.18 ; UE3.16 214.94,115.24 214.54,114.85 v2(214.24,114.85) 214.21,114.85 213.88,115.18 v3(213.88,115.28)
  IN6 w0.099: v3(213.88,115.28) 213.72,115.11 213.32,115.11 211.05,117.39 202.78,117.39 199.81,120.36 199.81,124.61 198.65,125.78 198.65,128.74 195.99,131.4 183.44,131.4 182.7,132.14 v3(182.7,132.2)
PWR_LED#: length 6.1
  TOP w0.127: UE5.92 286.8,9.73 285.94,8.88 v3(285.94,8.08) 286.17,8.08 v1(286.73,7.52)
  BOTTOM w0.127: v3(285.94,8.08) 285.5,7.64 QE9.2
PWR_R_7313#: length 63.3
  TOP w0.127: v2(212.88,116.09) 213.87,116.09 214.34,115.62 v3(214.48,115.62) 214.6,115.74 UE3.15 ; JPWR1.17 181.15,147.35 181.55,146.95 181.55,143.33 181.98,142.89 181.98,134.48 182.07,134.39 v3(182.07,132.21)
  IN6 w0.099: v3(214.48,115.62) 214.48,115.19 214.1,114.81 213.31,114.81 210.95,117.17 202.69,117.17 199.59,120.27 199.59,124.52 198.42,125.68 198.42,128.64 195.89,131.17 183.11,131.17 v3(182.07,132.21)
PWR_SRC_ON: length 0.6
  TOP w0.127: 83.87,114.11 v1(83.87,113.53)
PWRSHARE_EN_EC#: length 306.5
  TOP w0.127: v3(13.31,31.96) 12.85,32.43 v1(12.78,32.43) 12.6,32.43 11.7,31.53 JIO.4 ; v3(287.67,20.87) 287.67,21.22 288.7,22.25 UE5.119
  IN2 w0.099: v3(287.67,20.87) 281.79,20.87 281.12,20.2 276.33,20.2 273.61,17.48 268.19,17.48 267.91,17.2 263.43,17.2 259.55,13.32 253.29,13.32 252.69,12.72 235.58,12.72 233.22,10.36 222.29,10.36 221.27,9.35 209.96,9.35 206.29,13.02 194.56,13.02 192.07,10.52 173.3,10.52 172.48,9.7 158.1,9.7 155.27,12.52 150.4,12.52 149.04,13.88 147.36,13.88 146.37,14.87 145.4,14.87 143.67,16.6 128.83,16.6 127.59,15.36 121,15.36 120.39,14.75 89.39,14.75 88.65,14.01 80.58,14.01 78.75,15.84 71.49,15.84 71.04,15.38 57.62,15.38 56.9,14.66 53.19,14.66 52.73,14.19 50.86,14.19 48.82,12.16 37.26,12.16 35.85,13.57 32.43,13.57 29.43,16.57 27.6,16.57 25.51,18.67 25.51,19.16 24.71,19.95 22.06,19.95 21.52,20.5 19.73,20.5 18.32,21.91 16.39,21.91 16.02,22.28 16.02,22.84 13.49,25.36 13.49,31.78 v3(13.31,31.96)
RATE: length 22
  TOP w0.127: v3(150.38,134.39) 154.93,134.39 RM71.2 RM69.2 v1(155.68,137.48)
  IN4 w0.091: v3(150.38,134.39) 146.75,130.76 v3(145.96,130.76)
  BOTTOM w0.127: UM8.21 151.14,131.37 150.51,130.74 150.51,129.44 149.94,128.87 147.86,128.87 v3(145.96,130.76)
REGN_CHG: length 15
  TOP w0.203: PU700.24 43.27,39.93 43.4,40.06 43.4,40.76 43.56,40.92 45.02,40.92 v3(45.09,40.98) 45.09,41.37 PC710.1
  TOP w0.254: v3(36.85,38.21) PR714.1
  IN6 w0.254: v3(36.85,38.21) 37.09,38.44 41.28,38.44 43.69,40.86 44.96,40.86 v3(45.09,40.98)
  BOTTOM w0.127: v3(45.09,40.98) 45.1,40.98 v1(45.61,41.49)
REMOTE1+: length 147.2
  TOP w0.127: v2(128.37,116.25) 128.65,115.97 128.96,115.97 v3(128.97,115.98)
  TOP w0.254: Q2407.1 132.11,116.64 131.46,117.29 Q2407.2 130.57,117.07 C2500.1 129.64,117.07 128.97,116.4 v3(128.97,115.98)
  IN1 w0.254: v3(158.55,46.81) 156.23,49.14 154.39,49.14 148.03,55.49 146.45,55.49 143.14,58.8 143.14,67.21 144.69,68.75 144.69,78.98 146.86,81.14 154.19,81.14 155.33,82.29 155.33,91.54 152.68,94.19 147.1,94.19 143.76,97.54 138.45,97.54 129.31,106.68 129.31,115.05 128.97,115.39 v3(128.97,115.98)
  BOTTOM w0.254: v3(158.55,46.81) 157.72,45.99 157.72,36.89 154.65,33.82 154.65,28.43 151.89,25.68 151.89,22.96 149.62,20.68 149.62,15.98 149.77,15.83 C2502.1 149.24,14.76 149.24,14.59 148.82,14.17 U2407.2
REMOTE1-: length 144.8
  TOP w0.127: v3(129.67,115.48) v2(129.67,114.71)
  TOP w0.254: v3(129.67,115.48) C2500.2 130.62,116.15 Q2407.3
  IN1 w0.254: v3(129.67,115.48) 129.82,115.33 129.82,106.89 138.66,98.05 143.97,98.05 147.31,94.7 152.89,94.7 155.84,91.75 155.84,82.08 154.4,80.63 147.07,80.63 145.2,78.77 145.2,68.54 143.65,66.99 143.65,59.01 146.66,56 148.24,56 154.6,49.65 156.52,49.65 159.07,47.09 159.07,46.47 v3(158.89,46.29)
  BOTTOM w0.254: U2407.3 148.92,13.67 149.62,14.38 C2502.2 150.32,14.92 150.32,16 150.13,16.2 150.13,20.47 152.4,22.75 152.4,25.47 155.16,28.22 155.16,33.61 158.23,36.68 158.23,45.63 v3(158.89,46.29)
REMOTE2+: length 97.1
  TOP w0.254: v3(199.05,35.41) 199.05,33.84 194.31,29.1 194.31,25.46 192.89,24.04 192.89,17.98 194.44,16.43 v2(194.44,15.69) 194.44,11.1 192.76,9.43 191.71,9.43 v3(191.2,8.92)
  IN1 w0.254: v3(152.34,11.76) 166.58,11.76 167.13,11.2 167.13,10.48 167.75,9.87 172.71,9.87 173.28,10.44 189.67,10.44 v3(191.2,8.92)
  BOTTOM w0.254: U2407.4 149.04,13.17 149.42,13.55 C2504.1 149.9,13.55 150.98,12.47 151.7,12.47 152.34,11.83 v3(152.34,11.76) ; v3(199.05,35.41) 199.15,35.51 199.84,35.51 200.73,36.4 200.73,45.16 200.17,45.72 200.17,49.49 C2505.1 200.75,49.87 Q2408.2 201.47,51.5 Q2408.1
REMOTE2-: length 96.3
  TOP w0.254: v3(191.96,8.92) 192.97,8.92 194.95,10.89 194.95,16.68 v2(193.85,17.78) 193.4,18.23 193.4,23.82 194.82,25.25 194.82,28.86 199.56,33.6 199.56,35.59 v3(199.02,36.12)
  IN1 w0.254: v3(191.96,8.92) 189.93,10.95 173.07,10.95 172.51,10.39 167.95,10.39 167.64,10.7 167.64,11.41 166.79,12.27 152.03,12.27 151.68,11.92 v3(151.68,11.77)
  BOTTOM w0.254: v3(199.02,36.12) 199.13,36.02 199.63,36.02 200.22,36.61 200.22,44.95 199.66,45.51 199.66,49.71 199.89,49.94 C2505.2 199.89,50.85 Q2408.3 ; U2407.5 149.73,12.67 C2504.2 150.43,11.97 151.49,11.97 v3(151.68,11.77)
RF_+1.05VSP: length 3.5
  BOTTOM w0.127: PR306.1 242.88,30.06 v1(243.4,30.58)
  BOTTOM w0.254: PU300.5 242.03,28.51 241.87,28.67 241.87,29.05 242.39,29.57 PR306.1
RF_+1.35VS_VGAP: length 3.1
  BOTTOM w0.127: v1(132.72,112.49) PR311.1
  BOTTOM w0.254: PU301.5 131.66,110.87 131.45,111.08 131.45,111.6 131.76,111.91 PR311.1
RING2: length 9.1
  IN6 w0.254: v3(3.05,6.96) 2.85,7.16 2.85,10.14 3.29,10.58 3.29,11.91 v3(3.54,12.16)
  BOTTOM w0.127: v1(2.03,6.72) 2.81,6.72 v3(3.05,6.96)
  BOTTOM w0.254: v3(3.05,6.96) 3.05,7.1 3.44,7.49 UA3.7 ; v3(3.54,12.16) 3.54,11 UA3.14
RJ45_CT: length 12.5
  BOTTOM w1.016: CL30.2 321.69,84.04 323.34,85.69 324.68,85.69
  vias: v1(327.87,85.5) v3(325.63,85.94) v3(325.63,85.36)
RJ45_CT0: length 2.6
  TOP w0.127: RL12.1 326.46,87.62 v3(326.45,87.62) v1(326.45,88.33)
  BOTTOM w0.127: TL1.15 v3(326.45,87.62)
RJ45_CT1: length 2.9
  TOP w0.127: v1(328.91,88.31) 329.45,87.76 v3(329.45,87.6) 329.44,87.59 RL11.1
  BOTTOM w0.127: TL1.18 v3(329.45,87.6)
RJ45_CT2: length 2.8
  TOP w0.127: RL10.1 332.49,87.63 v3(332.45,87.67) 332.26,87.86 v1(332.26,88.5)
  BOTTOM w0.127: TL1.21 v3(332.45,87.67)
RJ45_CT3: length 2.7
  TOP w0.127: RL9.1 335.47,87.66 v3(335.45,87.68) v1(335.96,88.19)
  BOTTOM w0.127: TL1.24 v3(335.45,87.68)
RJ45_MDI0+: length 23
  BOTTOM w0.381: JLAN.1 324.35,104.65 321.36,101.66 v2(321.36,97.84) 321.36,93.05 324.45,89.96 TL1.13
RJ45_MDI0-: length 22.8
  BOTTOM w0.381: JLAN.2 327.39,104.11 326.63,104.11 326.43,103.91 326.43,103.34 326.23,103.14 325.58,103.14 325.38,103.34 325.38,103.91 325.17,104.11 324.57,104.11 321.9,101.44 v2(321.9,95.66) 321.9,93.27 324.98,90.19 324.98,89.93 325.45,89.46 TL1.14
RJ45_MDI1+: length 21.5
  BOTTOM w0.381: TL1.16 327.45,90.32 327,90.77 325.66,90.77 322.82,93.61 v2(322.82,99.82) 322.82,100.65 324.42,102.25 326.61,102.25 326.97,102.61 JLAN.3
RJ45_MDI1-: length 21.4
  BOTTOM w0.381: TL1.17 328.45,89.39 327.98,89.85 327.98,90.54 327.22,91.3 325.88,91.3 323.36,93.83 v2(323.36,94.3) 323.36,100.43 324.64,101.72 326.57,101.72 326.8,101.49 326.8,99.81 327.06,99.55 JLAN.6
RJ45_MDI2+: length 25.5
  IN4 w0.381: v3(330.66,87.29) 330.67,87.3 330.67,87.68 330.1,88.25 325.7,88.25 322.29,91.67 322.29,98.14 325.28,101.13 327.42,101.13 JLAN.4
  BOTTOM w0.381: TL1.19 330.45,88.17 330.66,87.97 v3(330.66,87.29)
RJ45_MDI2-: length 25.5
  IN4 w0.381: JLAN.5 325.51,100.57 322.85,97.91 322.85,91.9 325.93,88.81 330.33,88.81 331.23,87.91 331.23,87.3 v3(331.24,87.29)
  BOTTOM w0.381: v3(331.24,87.29) 331.24,87.97 331.45,88.18 TL1.20
RJ45_MDI3+: length 25.6
  IN1 w0.381: v3(333.45,87.71) 333.45,87.94 333.18,88.22 325.33,88.22 323.52,90.03 323.52,97.56 324.48,98.53 JLAN.7
  BOTTOM w0.381: v3(333.45,87.71) 333.45,87.71 TL1.22
RJ45_MDI3-: length 25.4
  IN1 w0.381: v3(333.73,87.07) 334,87.33 334,88.17 333.4,88.76 325.55,88.76 324.06,90.25 324.06,97.32 324.71,97.97 327.42,97.97 JLAN.8
  BOTTOM w0.381: v3(333.73,87.07) 334.45,87.78 TL1.23
ROM_CS: length 23.6
  TOP w0.127: v3(150.37,72.66) 149.98,73.05 v1(149.98,73.19)
  IN6 w0.099: v3(150.37,72.66) 151.51,72.66 153.48,70.69 155.12,70.69 155.35,70.92 161.52,70.92 162.88,69.56 v3(167.59,69.56)
  BOTTOM w0.089: UV1.BA3 v3(167.59,69.56)
  BOTTOM w0.127: v3(150.37,72.66) 150.19,72.84 RV167.2 150.88,73.37 151.58,74.07 UV10.1
ROM_SCLK: length 26.9
  TOP w0.127: RV233.1 154.29,67.12 v3(154.29,67.74) 154.56,68.01 RV226.2 155.46,68.49 160.1,68.49 v2(160.7,69.09) 160.94,69.33 166.78,69.33 167.33,68.78 v3(167.59,68.78)
  IN1 w0.099: v3(154.29,67.74) 155.26,68.71 155.26,76.62 v3(154.56,77.32)
  BOTTOM w0.1: v3(167.59,68.78) 167.2,68.39 UV1.BA2
  BOTTOM w0.127: v3(154.56,77.32) 154.13,77.32 RV169.2
ROM_SCLK_R: length 6.5
  BOTTOM w0.127: RV169.1 150.27,77.01 149.35,77.94 v3(149.35,78.27) 149.04,78.58 UV10.6
ROM_SI: length 21.8
  TOP w0.127: RV229.1 153.68,70.22 v3(154.28,70.22) 154.47,70.41 RV215.2 155.46,69.94 156.89,69.94 157.2,70.26 160.42,70.26 160.95,70.79 162.21,70.79 v2(162.51,70.49) 163.02,70.49 163.31,70.78 166.17,70.78 166.57,70.38 v3(166.8,70.38)
  IN1 w0.099: v3(154.47,75.87) 154.85,75.49 154.85,70.79 v3(154.28,70.22)
  BOTTOM w0.089: UV1.BA5 v3(166.8,70.38)
  BOTTOM w0.127: v3(154.47,75.87) 154.07,75.87 RV170.2
ROM_SI_R: length 8.1
  BOTTOM w0.127: RV170.1 152.29,76.73 150.1,76.73 149.2,77.62 148.5,77.62 v3(147.95,78.18) 147.77,78.36 UV10.5
ROM_SO: length 20.7
  TOP w0.127: RV231.1 153.93,69.53 v3(154.29,69.53) 154.68,69.53 RV223.2 155.46,69.69 v2(157.3,69.69) 157.6,69.98 167.2,69.98 v3(167.58,70.36)
  IN1 w0.099: v3(154.29,69.53) 153.86,69.97 153.86,71.92 v3(154.28,72.34)
  BOTTOM w0.089: UV1.BA4 167.2,69.98 v3(167.58,70.36)
  BOTTOM w0.127: v3(154.28,72.34) 153.55,72.34 152.85,73.03 RV168.1
ROM_SO_R: length 7
  BOTTOM w0.127: UV10.2 150.31,76.25 150.54,76.47 151.92,76.47 152.34,76.05 152.34,74.93 RV168.2 151.78,73.35 v1(151.78,73)
RREF: length 5.2
  TOP w0.127: v1(331.08,13.5) RR2.2
  TOP w0.203: UR1.9 329.63,17.61 329.66,17.59 329.66,17.52
  TOP w0.305: 329.66,17.52 329.66,15.59 330.68,14.57 RR2.2
RST#: length 6
  TOP w0.127: UE6.3 239.7,43.04 240.63,42.12 241,42.12 241.43,41.68 CE55.2 241.06,41.01 240.36,41.01 RE91.2 239.55,41.38 v1(239.05,40.88)
RTRON_LED_B_DRV#: length 212.3
  TOP w0.127: JTRONF.5 186.21,11.38 189.95,7.63 193.74,7.63 198.19,12.09 198.19,19.81 200.39,22.01 201.57,22.01 203.77,24.22 203.77,24.37 204.46,25.06 204.46,30.66 v2(204.04,31.08) 201.84,33.28 201.84,47.88 203.26,49.29 v3(203.26,50.03)
  IN2 w0.099: v3(203.26,50.03) 202.85,49.63 202.1,49.63 193.21,58.51 167.64,58.51 163.13,63.02 161.22,63.02 159.08,65.16 159.08,66.38 158.89,66.57 158.89,79.02 157.13,80.78 157.13,91.63 155.45,93.31 155.45,99.05 156.99,100.59 156.99,101.11 155.52,102.57 155.52,115.95 151.1,120.37 151.1,123.33 153.02,125.26 153.02,126.71 153.55,127.23 153.55,133.75 155.2,135.4 160.13,135.4 161.58,136.85 166.93,136.85 167.32,136.46 170.39,136.46 170.84,136.01 175.4,136.01 176.13,136.73 v3(176.13,136.79)
  BOTTOM w0.127: UE8.14 176.47,138 176.13,137.66 v3(176.13,136.79)
RTRON_LED_G_DRV#: length 203.6
  TOP w0.127: JTRONF.4 185.41,11.82 189.85,7.38 193.84,7.38 198.44,11.98 198.44,19.71 200.49,21.76 201.67,21.76 204.03,24.11 204.03,24.27 204.71,24.95 204.71,30.97 v2(202.89,32.79) 202.1,33.58 202.1,47.64 203.7,49.25 203.7,51.06 v3(202.86,51.89)
  IN2 w0.099: v3(173.1,134.14) 172.65,134.58 166.19,134.58 165.69,134.08 161.38,134.08 160.53,133.22 158.66,133.22 157.71,132.28 157.71,127.18 158.1,126.79 158.1,124.27 158.47,123.9 158.47,114.19 156.65,112.36 156.65,103.04 158.95,100.74 158.95,90.23 158.26,89.54 158.26,81.33 160.02,79.57 160.02,67.05 160.23,66.84 160.23,65.75 161.48,64.5 175,64.5 175.6,63.91 177.9,63.91 182.17,59.64 193.71,59.64 201.46,51.89 v3(202.86,51.89)
  BOTTOM w0.127: UE8.11 176.55,136.5 174.69,134.65 173.61,134.65 v3(173.1,134.14)
RTRON_LED_R_DRV#: length 211.3
  TOP w0.127: v3(203.45,51.91) 203.95,51.4 203.95,49.03 202.49,47.56 v2(202.49,34.8) 202.49,33.78 204.97,31.31 204.97,24.85 204.28,24.16 204.28,24.01 201.78,21.51 200.6,21.51 198.69,19.6 198.69,11.87 193.95,7.13 189.74,7.13 184.61,12.26 JTRONF.3
  IN2 w0.099: v3(203.45,51.91) 203.88,51.48 201.56,51.48 193.62,59.42 168.09,59.42 163.49,64.02 161.65,64.02 160,65.66 160,66.73 159.82,66.92 159.82,79.46 158.04,81.24 158.04,89.64 158.73,90.33 158.73,100.65 156.42,102.95 156.42,112.49 158.24,114.31 158.24,123.36 154.45,127.15 154.45,131.27 155.23,132.05 155.23,133.21 156.51,134.49 161.87,134.49 162.4,135.02 166.09,135.02 166.3,134.81 173.02,134.81 v3(173.7,134.14)
  BOTTOM w0.127: v3(173.7,134.14) 173.93,134.37 174.84,134.37 176.48,136 UE8.10
RXDET: length 24.9
  TOP w0.127: v3(154.04,135.93) 153.71,135.6 152.81,135.6 RM77.1 RM73.1 v1(153.77,138.08)
  IN4 w0.091: v3(154.04,135.93) 153.39,135.93 149.84,132.37 148.72,132.37 146.69,130.34 145.76,130.34 145.53,130.57 v3(145.53,131.19)
  BOTTOM w0.127: v3(145.53,131.19) 146.14,131.19 148.21,129.12 149.84,129.12 150.26,129.54 150.26,130.99 151.13,131.87 UM8.22
SATA_COMP: length 5.8
  TOP w0.127: v1(214.82,29.68) 214.64,29.68 v3(213.88,30.44) 211.63,30.44 RH28.1
  BOTTOM w0.254: v3(213.88,30.44) 213.88,30.57 214.15,30.84 214.28,30.84 214.3,30.82 UH1.AY5
SATA_IREF: length 2.9
  TOP w0.127: RH22.2 211.28,30.99 v1(211.71,30.99) v3(212.54,30.99)
  BOTTOM w0.089: v3(212.54,30.99) 212.39,30.84 UH1.BD4
SATA_LED_ACT: length 20.7
  TOP w0.127: QE14.1 157.04,130.4 157.04,134 157.19,134.15 157.19,134.8 158.66,136.27 158.66,136.63 159.43,137.39 159.92,137.39 160.11,137.58 v1(161.23,137.58) 161.42,137.39 162.07,137.39 v3(162.47,137.8)
  BOTTOM w0.127: 164.38,136.96 164.38,137.8 164.72,138.14 QE13.5 ; 164.38,136.96 164.37,136.97 162.66,136.97 162.47,137.16 v3(162.47,137.8) 162.47,138.05 162.22,138.31 RE39.2 162.37,138.74 162.97,138.14 QE13.2 ; 164.38,136.96 164.38,136.5 ; QE12.5 164.8,135.74 164.38,136.16 164.38,136.5 ; 164.38,136.5 164.61,136.5 164.72,136.39 QE12.6
SATA_PRX_DTX_N0: length 59.9
  TOP w0.127: CN12.1 166.73,17.45 167.14,17.45 168.35,16.25 168.35,15.56 v3(168.18,15.39)
  IN1 w0.099: v3(168.18,15.39) 168.39,15.17 168.39,15 168.76,14.64 172.7,14.64 172.87,14.81 179.56,14.81 179.72,14.65 189.45,14.65 192.27,17.46 199.25,17.46 200.67,18.89 201.96,18.89 203.13,20.05 203.13,21.28 205.88,24.04 205.88,29.68 206.49,30.29 207.46,30.29 v3(207.51,30.24)
  BOTTOM w0.089: UH1.BC8 212.56,32.19 212.1,32.19 211.87,31.96 211.43,31.96 210.9,31.42
  BOTTOM w0.102: 210.85,31.15 210.86,31.15 210.86,31.17 210.91,31.22 210.91,31.3 210.91,31.41 210.9,31.42
  BOTTOM w0.127: v3(207.51,30.24) 207.66,30.39 210.1,30.39 210.85,31.15
SATA_PRX_DTX_N0_C: length 2.4
  TOP w0.127: CN12.2 165.29,17.54 164.59,17.54 164.44,17.4 164.16,17.4 163.99,17.23 UN1.4
SATA_PRX_DTX_N0_R: length 16.7
  TOP w0.127: v3(160.44,29.62) 159.79,29.62 156.55,26.38 156.55,24.23 156.54,24.22 156.54,23.57 156.55,23.56 156.55,19.8 156.01,19.26 156.01,17.69 156.29,17.41 156.48,17.41 CN16.2
  BOTTOM w0.127: v3(160.44,29.62) 160.61,29.44 161.13,29.44 161.21,29.53 JHDD1.5
SATA_PRX_DTX_N0_RC: length 2.3
  TOP w0.127: UN1.12 159.03,17.23 158.9,17.35 158.47,17.35 158.3,17.53 157.96,17.53 CN16.1
SATA_PRX_DTX_N1: length 67
  TOP w0.127: v3(235.77,11.44) 236,11.68 236,11.99 CN29.1
  BOTTOM w0.089: UH1.BC10 212.21,33.1 211.9,32.79 211.08,32.79 210.7,32.41 210.19,32.41
  BOTTOM w0.127: v3(235.77,11.44) 236.01,11.2 236.01,11.02 235.8,10.81 202.7,10.81 200.28,13.24 200.28,19.49 v4(200.89,20.1) 205.13,24.35 205.13,25.02 205.3,25.19 205.3,31.72 206,32.41 207.85,32.41 207.86,32.4 208.43,32.4 208.44,32.41 210.19,32.41
SATA_PRX_DTX_N1_C: length 2.5
  TOP w0.127: v3(235.83,14.21) 236.04,14 236.04,13.65 CN29.2
  BOTTOM w0.127: v3(235.83,14.21) 235.65,14.03 JSSD1.35
SATA_PRX_DTX_N3: length 67.2
  TOP w0.127: v3(163.83,8.12) 163.23,8.12 162.98,8.37 162.98,9.15 CN45.1
  BOTTOM w0.089: 210.19,33.51 210.33,33.51 210.45,33.39 211.68,33.39 211.96,33.67 211.96,33.68 212.19,33.92 UH1.BC12
  BOTTOM w0.127: 210.19,33.51 208.78,33.51 208.56,33.29 205.26,33.29 204.42,32.45 204.42,25.58 204.23,25.39 204.23,24.69 202.03,22.49 201.59,22.49 192.84,13.74 192.84,11.93 191.22,10.31 172.84,10.31 172.15,9.62 166.05,9.62 164.58,8.14 163.85,8.14 v3(163.83,8.12)
SATA_PRX_DTX_N3_C: length 3.1
  TOP w0.127: v3(162.9,10.9) 163.07,10.73 163.07,10.61 CN45.2
  BOTTOM w0.127: v3(162.9,10.9) 162.99,10.99 162.99,11.33 162.77,11.56 162.77,12.04 162.65,12.16 JSSD4.35
SATA_PRX_DTX_N4: length 40.5
  TOP w0.127: v3(186.36,17.78) 186.6,17.54 186.6,17.24 186.62,17.23 186.62,16.92 186.53,16.83 CN46.1
  BOTTOM w0.089: 210.19,34.44 210.36,34.44 210.86,33.95 211.38,33.95 211.64,34.2 211.96,34.2 212.06,34.3 UH1.BD13
  BOTTOM w0.127: v3(186.36,17.78) 186.6,17.54 186.6,17.01 187.25,16.36 190.7,16.36 192.6,18.25 192.6,24.86 194.43,26.69 194.43,27.48 198.05,31.11 200.85,31.11 201.57,31.83 201.6,31.83 202.01,32.23 202.01,32.26 202.67,32.92 203.51,32.92 205.1,34.51 v4(205.84,34.51) 208.66,34.51 208.76,34.61 209.58,34.61 209.74,34.44 210.19,34.44
SATA_PRX_DTX_N4_C: length 3.4
  TOP w0.127: CN46.2 186.23,15.92 186.57,15.58 186.57,15.5 v3(186.35,15.28)
  BOTTOM w0.127: JSSD3.35 186.15,13.77 186.27,13.9 186.27,14.26 186.5,14.48 186.5,15.13 v3(186.35,15.28)
SATA_PRX_DTX_N5: length 29.8
  TOP w0.127: v3(212.33,14.15) 212.45,14.03 212.45,14.03 212.45,13.66 CN30.1
  IN1 w0.099: v3(212.33,14.15) 212.47,14 212.47,13.81 212.33,13.67 212.03,13.67 211.76,13.93 211.76,14.56 214.2,16.99 214.2,24.19 215,24.99 215,27.61 215.82,28.43 215.82,30.68 215.92,30.78 215.92,32.57 215.21,33.28 212.99,33.28 211.88,34.4 211.88,34.56 211.56,34.88 211.42,34.88 211.27,35.03 v3(211.27,35.08)
  BOTTOM w0.089: UH1.BC14 212.48,34.73 212.39,34.83 212.06,34.83 211.87,35.02 211.78,35.02 211.71,35.08 v3(211.27,35.08)
SATA_PRX_DTX_N5_C: length 3
  TOP w0.127: v3(212.38,11.51) 212.62,11.75 212.62,12.12 CN30.2
  BOTTOM w0.127: v3(212.38,11.51) 212.53,11.66 212.53,11.78 212.15,12.16 JSSD2.35
SATA_PRX_DTX_P0: length 59.9
  TOP w0.127: v3(168.76,15.39) 168.59,15.55 168.59,16.35 167.24,17.7 166.86,17.7 166.51,18.05 CN11.1
  IN1 w0.099: v3(207.51,30.82) 207.16,30.47 206.41,30.47 205.7,29.76 205.7,24.11 202.95,21.36 202.95,20.12 201.89,19.07 200.6,19.07 199.18,17.64 192.19,17.64 189.37,14.83 179.79,14.83 179.63,14.99 172.79,14.99 172.62,14.82 168.83,14.82 168.57,15.08 168.57,15.21 168.75,15.39 v3(168.76,15.39)
  BOTTOM w0.089: 210.68,31.41 210.68,31.49 211.39,32.21 211.39,32.39 211.6,32.6 211.78,32.6 211.86,32.52 211.86,32.39 UH1.BE8
  BOTTOM w0.102: 210.68,31.41 210.68,31.32
  BOTTOM w0.127: 210.68,31.32 209.99,30.63 207.7,30.63 v3(207.51,30.82)
SATA_PRX_DTX_P0_C: length 2.4
  TOP w0.127: UN1.5 164.01,17.73 164.1,17.64 164.34,17.64 164.49,17.78 165.26,17.78 CN11.2
SATA_PRX_DTX_P0_R: length 16.7
  TOP w0.127: v3(160.44,28.99) 160.06,29.37 159.89,29.37 156.8,26.28 v4(156.8,23.89) 156.8,19.7 156.25,19.15 156.25,17.79 156.39,17.66 156.78,17.66 156.9,17.77 156.9,17.96 CN15.2
  BOTTOM w0.127: v3(160.44,28.99) 160.64,29.2 161.11,29.2 161.28,29.03 JHDD1.6
SATA_PRX_DTX_P0_RC: length 2.3
  TOP w0.127: CN15.1 158,17.77 158.4,17.77 158.57,17.6 158.9,17.6 159.04,17.73 UN1.11
SATA_PRX_DTX_P1: length 67.1
  TOP w0.127: v3(236.35,11.44) 236.25,11.55 236.25,12.05 CN27.1
  BOTTOM w0.089: UH1.BE10 211.65,33 210.99,33 210.61,32.62 210.3,32.62 210.28,32.64 210.22,32.64 210.2,32.66 210.19,32.66
  BOTTOM w0.127: 210.19,32.66 v4(208.18,32.66) 205.89,32.66 205.06,31.82 205.06,25.29 204.89,25.12 204.89,24.45 200.9,20.46 200.88,20.46 200.38,19.95 200.38,19.93 200.04,19.6 200.04,13.13 202.6,10.57 235.9,10.57 236.26,10.92 236.26,11.35 v3(236.35,11.44)
SATA_PRX_DTX_P1_C: length 2.5
  TOP w0.127: v3(236.41,14.21) 236.27,14.07 236.27,13.53 CN27.2
  BOTTOM w0.127: JSSD1.33 236.15,13.89 236.41,14.15 v3(236.41,14.21)
SATA_PRX_DTX_P3: length 66.8
  TOP w0.127: CN43.1 163.49,9.58 163.31,9.58 163.22,9.49 163.22,8.48 163.33,8.37 163.48,8.37 v3(163.84,8.72)
  BOTTOM w0.089: 210.19,33.75 210.2,33.75 210.22,33.73 210.4,33.73 210.53,33.6 211.5,33.6 211.55,33.64 211.55,33.84 211.62,33.92 UH1.BE12
  BOTTOM w0.127: 210.19,33.75 208.67,33.75 208.46,33.54 205.14,33.54 v4(204.54,32.94) 204.18,32.58 204.18,25.68 203.99,25.49 203.99,24.79 201.93,22.74 201.49,22.74 192.6,13.84 192.6,12.03 191.12,10.55 172.74,10.55 172.05,9.86 165.95,9.86 164.48,8.39 164.17,8.39 v3(163.84,8.72)
SATA_PRX_DTX_P3_C: length 3.2
  TOP w0.127: v3(163.49,10.9) 163.3,10.71 163.3,10.66 CN43.2
  BOTTOM w0.127: v3(163.49,10.9) 163.25,11.14 163.25,11.43 163.02,11.66 163.02,12.03 163.15,12.16 JSSD4.33
SATA_PRX_DTX_P4: length 40.8
  TOP w0.127: CN44.1 186.86,17.07 186.86,17.7 v3(186.95,17.78)
  BOTTOM w0.089: UH1.BB13 212.62,34.32 212.31,34.63 212.12,34.63 211.88,34.4 211.55,34.4 211.3,34.15 210.94,34.15 210.44,34.65 210.3,34.65 210.28,34.67 210.22,34.67 210.2,34.69 210.19,34.69
  BOTTOM w0.127: v3(186.95,17.78) 186.84,17.68 186.84,17.11 187.35,16.6 190.6,16.6 192.35,18.35 192.35,24.96 194.19,26.79 194.19,27.58 197.95,31.35 200.75,31.35 v4(201.65,32.25) 202.57,33.17 203.41,33.17 205,34.75 205.52,34.75 205.54,34.77 206.16,34.77 206.18,34.75 208.56,34.75 208.66,34.85 209.68,34.85 209.84,34.69 210.19,34.69
SATA_PRX_DTX_P4_C: length 3.4
  TOP w0.127: v3(186.94,15.28) 186.79,15.42 186.79,15.64 CN44.2
  BOTTOM w0.127: v3(186.94,15.28) 186.76,15.1 186.76,14.38 186.53,14.15 186.53,13.85 186.65,13.72 JSSD3.33
SATA_PRX_DTX_P5: length 29.8
  TOP w0.127: CN28.1 212.84,13.44 212.69,13.59 212.69,13.92 v3(212.91,14.15)
  IN1 w0.099: v3(211.14,34.51) 211.33,34.7 211.48,34.7 211.7,34.48 211.7,34.32 212.91,33.1 215.13,33.1 215.74,32.5 215.74,30.85 215.64,30.76 215.64,28.51 214.82,27.69 214.82,25.07 214.02,24.27 214.02,17.07 211.58,14.63 211.58,13.86 211.95,13.49 212.41,13.49 212.65,13.73 212.65,13.89 v3(212.91,14.15)
  BOTTOM w0.089: v3(211.14,34.51) 211.36,34.73 UH1.BE14
SATA_PRX_DTX_P5_C: length 2.8
  TOP w0.127: CN28.2 212.86,12.22 212.86,11.61 v3(212.96,11.51)
  BOTTOM w0.127: JSSD2.33 212.65,12.01 212.78,11.88 212.78,11.69 v3(212.96,11.51)
SATA_PTX_DRX_N0: length 67.8
  TOP w0.127: CN10.1 166.13,15.97 166.66,15.97 v4(166.82,15.81) 166.97,15.66 166.97,14.46 v3(167.09,14.34)
  IN1 w0.099: v3(214.41,31.31) 214.22,31.5 214.22,31.67 213.99,31.89 213.41,31.89 213.31,31.79 211.51,31.79 210.83,31.12 210.83,26.01 210.32,25.5 210.32,23.84 209.59,23.1 209.59,20.07 209.1,19.58 208.52,19.58 207.29,18.34 207.29,17.61 204.01,14.33 194.49,14.33 192.58,12.42 177.88,12.42 177.47,12.02 171.92,12.02 171.65,11.75 168.52,11.75 166.95,13.33 166.95,14.2 v3(167.09,14.34)
  BOTTOM w0.089: v3(214.41,31.31) 214.13,31.59 214.13,32.06 UH1.AW8
SATA_PTX_DRX_N0_C: length 1.7
  TOP w0.127: CN10.2 164.72,15.98 164.33,15.98 164.08,16.23 UN1.2
SATA_PTX_DRX_N0_R: length 21.7
  TOP w0.127: CN14.2 156.9,16.03 156.9,15.86 156.76,15.72 155.97,15.72 155.77,15.92 155.77,15.94 155.32,16.39 155.3,16.39 155.16,16.54 v4(155.16,17.9) 155.16,18.35 v3(155.36,18.56)
  BOTTOM w0.127: v3(155.36,18.56) 155.17,18.75 155.17,18.99 154.41,19.75 154.41,24.04 159.55,29.19 159.55,30.27 160.06,30.78 161.16,30.78 161.2,30.74 161.2,30.57 161.25,30.53 JHDD1.3
SATA_PTX_DRX_N0_RC: length 2.4
  TOP w0.127: UN1.14 159.05,16.23 158.92,16.09 158.37,16.09 158.1,15.83 158.02,15.83 CN14.1
SATA_PTX_DRX_N1: length 55.4
  TOP w0.127: CN31.1 234.47,12.12 234.47,11.42 233.87,10.82 233.18,10.82 231.85,12.16 223.21,12.16 221.16,10.1 220.58,10.1 220.33,9.85 219.99,9.52 215.72,9.52 215.17,10.06 210.28,10.06 208.6,11.75 208.6,14.17 208.93,14.51 209.28,14.51 v3(209.43,14.65)
  IN1 w0.099: v3(214.46,32.7) 214.46,32.11 214.97,31.61 214.97,30.78 215.25,30.5 215.25,30.08 213.83,28.67 213.83,27.14 212.27,25.58 212.27,22.61 211.45,21.79 211.45,18.52 208.9,15.97 208.9,14.67 209.02,14.54 209.32,14.54 v3(209.43,14.65)
  BOTTOM w0.089: v3(214.46,32.7) 214.46,32.78 214.79,33.1 UH1.AV10
SATA_PTX_DRX_N1_C: length 2.5
  TOP w0.127: v3(234.56,14.2) 234.34,13.98 234.34,13.62 CN31.2
  BOTTOM w0.127: v3(234.56,14.2) 234.65,14.12 JSSD1.39
SATA_PTX_DRX_N3: length 77.6
  TOP w0.127: v3(168.71,13.16) 168.86,13.01 168.86,12.69 164.86,8.69 164.86,8.21 164.07,7.42 162.28,7.42 162.11,7.59 162.11,7.6 161.76,7.96 161.74,7.96 161.35,8.36 161.35,8.92 CN47.1
  IN1 w0.099: v3(215.71,33.68) 215.81,33.78 215.81,33.96 215.67,34.1 215.49,34.1 215.44,34.05 212.85,34.05 211.32,35.58 211.07,35.58 210.63,35.14 210.63,32.41 210.2,31.99 210.2,26.35 209.72,25.86 209.72,24.09 208.64,23.01 208.64,22.53 207.8,21.69 207.8,21.17 207.15,20.52 207.15,20.04 202.06,14.95 194.25,14.95 192.36,13.06 177.53,13.06 177.12,12.65 171.5,12.65 171.32,12.47 169.23,12.47 168.97,12.74 168.97,12.9 v3(168.71,13.16)
  BOTTOM w0.089: UH1.AR13 215.71,33.81 v3(215.71,33.68)
SATA_PTX_DRX_N3_C: length 3.1
  TOP w0.127: v3(161.61,10.9) 161.61,10.89 161.46,10.73 161.46,10.63 CN47.2
  BOTTOM w0.127: JSSD4.39 161.65,12.16 161.55,12.05 161.55,11.57 161.39,11.42 161.39,11.1 161.5,10.99 161.6,10.9 v3(161.61,10.9)
SATA_PTX_DRX_N4: length 51.7
  TOP w0.127: CN48.1 184.89,17.11 184.89,18.13 185.18,18.42 v4(188.01,18.42) 188.56,18.42 190.01,16.97 190.01,16.94 190.38,16.58 190.4,16.58 192.51,14.47 v3(192.51,14.35)
  IN1 w0.099: v3(192.51,14.35) 192.51,14.56 192.3,14.77 192.3,15.04 193.26,15.99 201.61,15.99 206.13,20.52 206.13,21.43 207.45,22.75 207.45,23.29 208.04,23.88 208.04,25.75 209.22,26.92 209.22,32.56 209.51,32.85 209.51,35.42 210.24,36.15 210.5,36.15 210.68,36.33 211.66,36.33 212.96,35.03 213.97,35.03 214.18,35.24 214.86,35.24 215.04,35.06 215.04,34.81 215.03,34.8 v3(215.17,34.67)
  BOTTOM w0.089: v3(215.17,34.67) 215.17,34.69 214.88,34.97 UH1.AV15
SATA_PTX_DRX_N4_C: length 3.4
  TOP w0.127: CN48.2 184.85,15.6 184.85,15.47 v3(185.04,15.28)
  BOTTOM w0.127: v3(185.04,15.28) 184.85,15.09 184.85,14.42 185.03,14.24 185.03,13.88 185.15,13.76 JSSD3.39
SATA_PTX_DRX_N5: length 44.8
  TOP w0.127: v3(201.61,17.55) 201.42,17.37 201.42,15.32 203.34,13.4 206.58,13.4 208.69,15.51 210.29,15.51 210.86,14.94 210.86,13.72 CN32.1
  IN6 w0.099: v3(206.61,31.17) 207.01,31.57 211.95,31.57 214.45,34.07 216.92,34.07 217.16,34.3 217.16,34.41 217.18,34.43 217.18,34.65 217.26,34.73 v3(217.26,35.01)
  BOTTOM w0.089: v3(217.26,35.01) 216.81,35.01 UH1.AP15
  BOTTOM w0.127: v3(206.61,31.17) 206.61,31.22 206.48,31.35 206.27,31.35 206.19,31.27 206.19,24.83 206.01,24.65 206.01,23.92 203.19,21.09 203.19,20.72 201.46,18.99 201.46,17.71 v3(201.61,17.55)
SATA_PTX_DRX_N5_C: length 2.7
  TOP w0.127: v3(210.98,11.51) 210.84,11.65 210.84,12.22 CN32.2
  BOTTOM w0.127: JSSD2.39 211.15,12.23 210.98,12.06 v3(210.98,11.51)
SATA_PTX_DRX_P0: length 67.7
  TOP w0.127: CN9.1 166.27,15.72 166.55,15.72 166.73,15.55 166.73,14.56 v3(166.51,14.34)
  IN1 w0.099: v3(166.51,14.34) 166.77,14.08 166.77,13.25 168.45,11.57 171.73,11.57 171.99,11.84 177.55,11.84 177.95,12.24 192.66,12.24 194.56,14.15 204.09,14.15 207.47,17.54 207.47,18.27 208.6,19.39 209.17,19.39 209.77,19.99 209.77,23.03 210.5,23.76 210.5,25.43 211.01,25.94 211.01,31.04 211.58,31.61 213.39,31.61 213.49,31.71 213.92,31.71 214.04,31.59 214.04,31.38 213.93,31.27 v3(213.79,31.27)
  BOTTOM w0.089: UH1.AY8 213.93,31.97 213.93,31.41 v3(213.79,31.27)
SATA_PTX_DRX_P0_C: length 1.7
  TOP w0.127: UN1.1 164.22,15.73 164.23,15.73 164.56,15.73 CN9.2
SATA_PTX_DRX_P0_R: length 21.7
  TOP w0.127: CN13.2 156.43,15.48 155.87,15.48 155.4,15.95 v4(155.4,15.95) 155.4,15.95 154.91,16.44 154.91,17.53 154.9,17.54 154.9,18.2 154.91,18.21 154.91,18.42 v3(154.78,18.56)
  BOTTOM w0.127: JHDD1.2 161.95,31.02 159.96,31.02 159.31,30.37 159.31,29.29 154.16,24.14 154.16,19.65 154.93,18.89 154.93,18.71 v3(154.78,18.56)
SATA_PTX_DRX_P0_RC: length 2.3
  TOP w0.127: CN13.1 158,15.58 158.21,15.58 158.47,15.85 158.93,15.85 159.05,15.73 UN1.15
SATA_PTX_DRX_P1: length 55.4
  TOP w0.127: v3(209.43,14.06) 209.23,14.26 209.03,14.26 208.84,14.07 208.84,11.85 210.39,10.31 215.27,10.31 215.82,9.76 219.89,9.76 220.22,10.09 220.23,10.09 220.48,10.34 221.06,10.34 223.11,12.4 231.95,12.4 233.29,11.07 233.77,11.07 234.23,11.52 234.23,12.35 234.04,12.54 233.87,12.54 CN33.1
  IN1 w0.099: v3(209.43,14.06) 209.13,14.36 208.94,14.36 208.72,14.59 208.72,16.05 211.27,18.6 211.27,21.86 212.09,22.69 212.09,25.66 213.65,27.22 213.65,28.74 215.07,30.15 215.07,30.43 214.79,30.7 214.79,31.53 214.28,32.04 214.28,32.29 v3(213.87,32.7)
  BOTTOM w0.089: UH1.AW10 214.28,33.11 v3(213.87,32.7)
SATA_PTX_DRX_P1_C: length 2.5
  TOP w0.127: CN33.2 234.09,13.67 234.09,14.1 v3(233.98,14.2)
  BOTTOM w0.127: JSSD1.41 234.15,14.03 v3(233.98,14.2)
SATA_PTX_DRX_P3: length 77.8
  TOP w0.127: v3(169.29,13.16) 169.1,12.97 169.1,12.59 165.1,8.59 165.1,8.11 164.17,7.17 162.18,7.17 v4(161.75,7.6) 161.1,8.26 161.1,9.12 CN49.1
  IN1 w0.099: v3(215.79,34.69) 215.79,34.66 215.36,34.23 212.92,34.23 211.4,35.76 210.99,35.76 210.45,35.22 210.45,32.49 210.02,32.06 210.02,26.42 209.54,25.93 209.54,24.17 208.46,23.09 208.46,22.61 207.62,21.77 207.62,21.24 206.97,20.59 206.97,20.12 201.98,15.13 194.17,15.13 192.28,13.24 177.45,13.24 177.04,12.83 171.42,12.83 171.25,12.65 169.31,12.65 169.15,12.81 169.15,13.02 v3(169.29,13.16)
  BOTTOM w0.089: UH1.AT13 215.79,34.48 v3(215.79,34.69)
SATA_PTX_DRX_P3_C: length 3.1
  TOP w0.127: v3(161.03,10.9) 161.23,10.7 161.23,10.67 CN49.2
  BOTTOM w0.127: JSSD4.41 161.15,12.18 161.29,12.04 161.29,11.68 161.14,11.52 161.14,11.01 v3(161.03,10.9)
SATA_PTX_DRX_P4: length 51.9
  TOP w0.127: v3(192.92,14.77) 192.69,14.77 192.68,14.77 192.55,14.77 v4(190.37,16.95) 188.66,18.66 188.29,18.66 188.27,18.68 187.77,18.68 187.75,18.66 185.07,18.66 184.64,18.23 184.64,17.19 CN50.1
  IN1 w0.099: v3(214.57,34.69) 214.66,34.69 214.86,34.89 214.86,34.99 214.79,35.06 214.25,35.06 214.04,34.85 212.89,34.85 211.59,36.15 210.75,36.15 210.57,35.97 210.31,35.97 209.69,35.34 209.69,32.78 209.4,32.49 209.4,26.85 208.22,25.67 208.22,23.8 207.63,23.22 207.63,22.68 206.31,21.36 206.31,20.44 201.68,15.81 193.33,15.81 192.48,14.96 192.48,14.84 192.56,14.77 v3(192.92,14.77)
  BOTTOM w0.089: UH1.AW15 214.28,34.97 v3(214.57,34.69)
SATA_PTX_DRX_P4_C: length 3.3
  TOP w0.127: v3(184.46,15.28) 184.62,15.45 184.62,15.57 CN50.2
  BOTTOM w0.127: JSSD3.41 184.65,13.78 184.77,13.91 184.77,14.13 184.6,14.31 184.6,15.14 v3(184.46,15.28)
SATA_PTX_DRX_P5: length 44.8
  TOP w0.127: v3(201.03,17.55) 201.18,17.4 201.18,15.22 203.24,13.15 206.68,13.15 208.79,15.27 210.19,15.27 210.61,14.84 210.61,13.87 CN34.1
  IN6 w0.099: v3(206.61,31.75) 211.87,31.75 214.37,34.25 216.85,34.25 216.98,34.38 216.98,34.46 216.8,34.63 v3(216.41,34.63)
  BOTTOM w0.089: UH1.AR15 216.41,34.81 v3(216.41,34.63)
  BOTTOM w0.127: v3(201.03,17.55) 201.21,17.74 201.21,19.09 202.95,20.82 202.95,21.2 205.77,24.02 205.77,24.75 205.94,24.93 205.94,31.37 206.17,31.6 206.45,31.6 v3(206.61,31.75)
SATA_PTX_DRX_P5_C: length 2.9
  TOP w0.127: v3(210.39,11.51) 210.59,11.71 210.59,12.12 CN34.2
  BOTTOM w0.127: v3(210.39,11.51) 210.39,11.52 210.73,11.86 210.73,12.12 210.65,12.2 JSSD2.41
SCLK: length 3.4
  TOP w0.127: PR508.2 138.19,130.23 PR504.1 137.53,129.6 v3(137.45,129.6)
  BOTTOM w0.127: PU500.1 137.9,128.85 138.23,129.17 138.23,129.33 137.96,129.6 v3(137.45,129.6)
SD_CD#: length 25
  TOP w0.127: v3(324.08,18.03) 324.46,18.41 UR1.30
  IN1 w0.099: v3(324.08,18.03) 307.82,18.03 v3(303.57,13.78)
  BOTTOM w0.127: JCR.20 303.57,13.78 v3(303.57,13.78)
SD_CLK MS_D0: length 2.4
  TOP w0.127: RR1.2 v1(329.25,22.23) 329.25,22.02 328.68,21.46 UR1.17
SD_CLK MS_D0_R: length 40.1
  TOP w0.127: RR1.1 v3(329.25,24.87)
  IN4 w0.091: v3(329.25,24.87) 328.58,24.2 302.86,24.2 302.73,24.07 302.73,23.27 302.6,23.14 302.31,23.14 302.19,23.27 302.19,24.02 302.06,24.14 301.74,24.14 301.61,24.02 301.61,22.52 301.49,22.39 v3(300.75,22.39)
  BOTTOM w0.127: v3(300.75,22.39) 300.75,21.58 300.95,21.38 JCR.14 ; v3(300.75,22.39) 300.75,23.38 301.03,23.66 JCR.12 ; v3(300.75,22.39) 299.54,22.39 299.3,22.15 RR9.2
