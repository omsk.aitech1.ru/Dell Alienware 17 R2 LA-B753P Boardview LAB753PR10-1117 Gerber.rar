# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BTST_CHG:
  vias: v1(43,40.52)
BUF_CLK1: length 3.4
  BOTTOM w0.127: RM24.2 222.87,112.83 222.87,113.26 223.16,113.55 v4(223.41,113.55) 223.65,113.55 223.86,113.77 223.86,113.92 223.64,114.15 UM4.3
BUF_CLK+: length 3.4
  BOTTOM w0.127: RM22.2 223.13,112.85 223.13,113.16 223.27,113.3 223.75,113.3 224.09,113.64 224.09,113.95 224.29,114.14 UM4.2
BUF_SM_CLK: length 4.1
  BOTTOM w0.127: UM4.11 219.09,120.05 218.32,119.28 217.92,119.28 RM35.1 RM36.2
BUF_SM_DAT: length 4.6
  BOTTOM w0.127: RM37.2 RM30.1 217.22,117.2 217.93,116.49 v1(218.01,116.49) 218.49,116.49 219.09,115.89 UM4.10
C1_C2: length 6.1
  BOTTOM w0.089: CPU1.C2 CPU1.C1 129.8,100.75
  BOTTOM w0.127: v1(133.14,100.29) 132.31,101.12 130.18,101.12 129.81,100.75 129.8,100.75
C3_B2: length 6.8
  BOTTOM w0.089: CPU1.C3 126.79,100.67 127.41,101.28 CPU1.B2 129.8,101.54
  BOTTOM w0.127: v1(133.16,101.69) 133.12,101.73 131.37,101.73 131.18,101.54 129.8,101.54
CALDERA_ PWRGD: length 198.6
  TOP w0.127: v3(239.61,50.03) 239.61,49.4 240.2,48.82 UE6.15
  IN2 w0.099: v3(239.61,50.03) 239.42,50.03 237.23,52.23 236.23,52.23 230.98,57.48 229.02,57.48 227.11,59.4 209.42,59.4 205.59,55.56 202.34,55.56 197.06,60.85 183.69,60.85 180.46,64.07 179.03,64.07 178.26,64.84 176.06,64.84 174.76,66.14 162.59,66.14 161.94,66.79 161.94,70.59 162.43,71.08 162.43,73.9 163.18,74.66 163.18,79.43 162.42,80.19 161.33,80.19 160.58,80.95 160.58,83.32 161.33,84.08 161.33,93.84 160.12,95.05 160.12,109.94 159.69,110.37 159.69,124.09 159.02,124.76 159.02,128.25 159.36,128.59 159.36,131.23 159.73,131.6 160.33,131.6 161.66,132.93 170.22,132.93 v3(170.41,132.74)
  IN5 w0.099: v3(170.41,132.74) 171.13,133.47 171.13,134.98 170.26,135.85 170.26,143.58 172.18,145.49 v3(172.18,146.38)
  BOTTOM w0.127: RM42.1 164.73,140.41 165.56,140.41 167.21,142.06 170.5,142.06 170.75,142.31 JCDRA.2 170.75,144.41 172.18,145.84 v3(172.18,146.38) ; v3(170.41,132.74) v1(169.47,132.74)
CALDERA_ON: length 307.6
  TOP w0.127: v3(291.24,18.04) 291.05,17.85 UE5.108
  IN2 w0.099: v3(155.4,139.04) 154.98,139.46 154.37,139.46 153.99,139.08 153.99,138.71 152.14,136.86 152.14,134.71 151.56,134.13 151.56,130.44 150.93,129.8 150.93,128.28 151.81,127.4 151.81,126.01 149.96,124.15 149.96,119.97 154.36,115.57 154.36,91.92 156.04,90.24 156.04,78.45 156.49,78.01 156.49,77.15 156.16,76.82 156.16,66.94 157.37,65.73 157.37,57.38 157.88,56.87 157.88,55.79 158.27,55.4 158.27,49.79 161.28,46.78 161.28,41.38 161.74,40.92 161.74,39.77 164.63,36.88 165.8,36.88 167.66,35.02 167.66,34.02 171.47,30.22 171.47,29.52 172.25,28.73 172.25,27.73 174.27,25.71 177.81,25.71 178.85,24.67 188.99,24.67 198.39,34.07 198.39,36.39 198.72,36.72 198.72,45.27 201.25,47.8 203.34,47.8 207.25,51.7 207.25,53.24 211.16,57.15 224.39,57.15 226.89,54.65 229.53,54.65 v3(229.99,54.19)
  IN6 w0.099: v3(229.99,54.19) 230.98,55.17 234.63,55.17 235.66,54.14 242.06,54.14 250.29,45.91 250.29,45.18 259.3,36.17 259.3,33.38 259.79,32.89 262.73,32.89 263.81,31.81 264.59,31.81 271.02,25.37 271.77,25.37 275.74,21.4 286.52,21.4 289.88,18.04 v3(291.24,18.04)
  BOTTOM w0.127: v3(229.99,54.19) v1(229.44,54.19) ; JCDRA.1 169.95,144.33 169.61,144.67 166.8,144.67 166.6,144.46 166.6,141.81 165.46,140.67 164.61,140.67 164.37,140.43 162.69,140.43 RM41.2 161.67,139.41 160.75,139.41 160.36,139.79 UM7.2 156.15,139.79 v3(155.4,139.04)
CALDERA_PRSNT#: length 290.4
  TOP w0.127: v3(264.76,25.52) v1(264.76,24.65) ; v3(244.05,47.89) 245.7,47.89 246.19,47.4 246.19,44.73 244.87,43.41 244.87,41.24 244.4,40.77 243.19,40.77 242.19,41.77 242.19,41.99 241.52,42.66 241,42.66 240.7,42.96 UE6.5
  IN2 w0.099: v3(192.24,136.74) 191.54,136.04 187.69,136.04 184.61,132.96 180.04,132.96 179.62,132.54 179.62,132.15 179,131.53 175.61,131.53 v3(174.44,132.7) 173.99,133.16 173.06,133.16 172.81,133.4 161.34,133.4 160.71,132.77 159.86,132.77 158.91,131.83 158.91,128.78 158.55,128.42 158.55,124.59 159.15,123.99 159.15,110.02 159.67,109.5 159.67,89.85 159.54,89.72 159.54,81.39 161.29,79.63 161.29,74.7 160.62,74.04 160.62,67.21 161.26,66.57 161.26,66.57 162.88,64.96 175.24,64.96 175.83,64.36 178.09,64.36 182.13,60.32 196.62,60.32 202.03,54.91 205.82,54.91 209.85,58.94 226.81,58.94 228.73,57.02 230.8,57.02 236.06,51.77 236.81,51.77 239.17,49.41 239.17,48.34 239.51,47.99 240.72,47.99 241.44,47.27 243.44,47.27 v3(244.05,47.89)
  IN5 w0.099: v3(163.32,130.04) 164.54,131.26 166.6,131.26 167.26,131.92 173.65,131.92 v3(174.44,132.7)
  IN6 w0.099: v3(264.76,25.52) 263.56,25.52 260.26,28.81 259.78,28.81 257.16,31.44 257.16,34.45 252.35,39.26 251.41,39.26 250.71,39.96 250.71,40.9 249.24,42.37 249.24,43.11 245.43,46.92 244.23,46.92 244.05,47.1 v3(244.05,47.89) ; v3(191.77,145.57) 191.37,145.16 185.89,145.16 185.14,145.91 182.2,145.91 181.92,146.18 v3(178.69,146.18)
  BOTTOM w0.127: v3(192.24,136.74) 191.52,137.47 191.52,138.57 191.21,138.88 191.21,139.66 RM5.2 191.25,140.57 191.25,145.05 v3(191.77,145.57) ; v3(178.69,146.18) 178.7,146.18 JCDRA.21 ; UE1.28 264.76,25.2 v3(264.76,25.52) ; v3(163.32,130.04) 163.96,130.67 RM61.1
CALDERA_RST#: length 222.3
  TOP w0.127: UE6.16 v3(239.7,48.55)
  IN2 w0.099: v3(173.14,132.75) 172.72,133.17 161.58,133.17 160.24,131.83 159.64,131.83 159.14,131.33 159.14,128.69 158.8,128.35 158.8,124.66 159.4,124.06 159.4,110.14 159.89,109.64 159.89,94.9 161.11,93.68 161.11,84.16 159.84,82.89 159.84,81.4 161.5,79.75 161.5,74.61 160.82,73.94 160.82,67.32 161.58,66.57 161.58,66.57 162.97,65.18 175.36,65.18 175.94,64.61 178.16,64.61 182.16,60.62 196.83,60.62 202.24,55.21 205.7,55.21 209.66,59.17 226.9,59.17 228.82,57.25 230.9,57.25 236.15,52 237.07,52 239.7,49.37 v3(239.7,48.55)
  IN5 w0.099: v3(172.8,146.42) 172.8,145.58 170.49,143.27 170.49,135.96 173.14,133.3 v3(173.14,132.75)
  BOTTOM w0.127: v1(173.4,132.12) 173.14,132.37 v3(173.14,132.75) ; v3(172.8,146.42) 174.58,148.2 189.79,148.2 192.56,145.43 192.56,141.39 193.88,140.07 196.74,140.07 197.32,139.49 RM6.2 196.97,138.98 196.83,139.13 UM3.1
CAPS_LED#: length 329
  TOP w0.127: UE5.91 286.4,12.74 286.72,13.06 286.72,13.67 286.59,13.79 286.59,15.64 v3(286.32,15.9) ; v3(186.96,144.44) 186.96,145.12 186.46,145.62 186.46,146.99 186.65,147.18 JPWR1.28 ; v2(228.83,53.13) 229.1,52.86 v3(229.58,52.86)
  IN2 w0.099: v3(186.96,144.44) 185.31,142.79 171.55,142.79 167.02,138.25 161.12,138.25 160.66,138.72 158.49,138.72 157.07,140.14 153.26,140.14 152.54,139.42 152.54,138.28 150.84,136.58 150.84,130.69 150.25,130.09 150.25,127.97 151.13,127.09 151.13,126.29 149.28,124.43 149.28,119.69 153.68,115.29 153.68,91.28 154.86,90.1 154.86,82.12 154.27,81.54 154.27,78.45 155.06,77.66 155.06,77.22 155.47,76.81 155.47,66.62 156.69,65.39 156.69,57.1 157.2,56.59 157.2,55.51 157.59,55.12 157.59,49.48 160.53,46.54 160.53,41.09 161.06,40.55 161.06,39.49 164.35,36.2 165.41,36.2 166.99,34.63 166.99,32.43 171.57,27.85 171.57,27.19 174.65,24.11 178.38,24.11 178.61,23.88 189.26,23.88 199.68,34.3 199.68,36.39 199.42,36.66 199.42,44.88 201.65,47.12 203.62,47.12 207.97,51.47 207.97,52.93 210.8,55.76 214.07,55.76 214.79,56.47 224.07,56.47 226.76,53.79 228.12,53.79 229.05,52.86 v3(229.58,52.86)
  IN6 w0.099: v3(286.32,15.9) 283.85,18.38 280.04,18.38 279.47,17.81 277.5,17.81 276.65,18.65 275.56,18.65 273.64,20.57 272.41,20.57 266.74,26.24 263.48,26.24 260.45,29.27 259.99,29.27 257.65,31.61 257.65,34.6 249.71,42.54 249.71,43.3 241.05,51.96 238.82,51.96 238.43,51.57 232.88,51.57 232.41,51.11 231.33,51.11 v3(229.58,52.86)
CDCLK_REQ#: length 130.5
  TOP w0.127: v3(325.69,15.08) 325.69,15.76 326.28,16.35 UR1.2
  IN1 w0.099: v3(325.69,15.08) 323.09,17.68 310.62,17.68 310.11,17.17 310.11,13.6 309.35,12.84 307.98,12.84 305.97,10.84 301.23,10.84 296.57,15.5 284.46,15.5 284.2,15.76 281.17,15.76 280.92,16 278.69,16 277.74,15.05 277.05,15.05 276.93,14.92 275.43,14.92 273.67,16.68 269.03,16.68 268.14,17.57 260.63,17.57 258.46,15.39 240.66,15.39 239.46,16.59 233.5,16.59 232.89,17.2 230.85,17.2 230.65,17.4 230.09,17.4 228.05,19.44 228.05,21.91 228.26,22.13 228.26,23.16 226.44,24.97 225.8,24.97 v3(225.49,25.28)
  BOTTOM w0.089: UH1.V3 223,29.88 223,29.42 222.81,29.23 222.81,28.93 222.58,28.69 222.58,27.78
  BOTTOM w0.127: RH80.2 225.49,22.21 226.13,22.85 226.13,24.64 v3(225.49,25.28) 225.49,25.66 224.66,26.5 222.93,26.5 222.58,26.85 222.58,27.78
CDR_BTN#: length 284.5
  TOP w0.127: UE5.120 288.51,22.65 v3(288.22,22.35)
  IN2 w0.099: v3(191.04,136.74) 190.6,136.31 187.31,136.31 184.19,133.19 179.67,133.19 179.25,132.77 174.98,132.77 174.3,133.45 173.21,133.45 172.31,134.36 166.31,134.36 165.8,133.85 161.47,133.85 160.62,133 159.72,133 157.94,131.22 157.94,127.27 158.32,126.89 158.32,124.37 158.7,123.99 158.7,114.06 156.88,112.24 156.88,103.14 159.18,100.83 159.18,90.14 158.49,89.45 158.49,81.42 160.22,79.69 160.22,67.29 162.78,64.73 175.15,64.73 175.74,64.14 178,64.14 182.26,59.87 196.43,59.87 201.88,54.41 206.03,54.41 210.33,58.72 226.71,58.72 228.63,56.8 230.71,56.8 235.98,51.53 236.27,51.53 v3(237.09,50.71)
  IN4 w0.091: v3(237.09,50.71) 237.26,50.54 242.29,50.54 249.58,43.24 249.58,42.33 253.06,38.85 255.89,38.85 260.12,34.62 266.41,34.62 268.41,32.61 284.79,32.61 v3(285.84,31.56)
  BOTTOM w0.127: v3(191.04,136.74) v1(191.04,137.28) 190.26,138.05 190.26,139.65 RM17.2 191,140.39 191,146.63 189.69,147.94 184.52,147.94 183.01,146.43 182.49,146.43 181.36,145.3 181.36,144.85 180.7,144.18 180.7,144.18 JCDRA.26 ; v3(285.84,31.56) 285.84,29.89 285.96,29.77 285.96,27.94 288.22,25.68 v3(288.22,22.35)
CDR_I2C_CLK: length 283.2
  TOP w0.127: v3(306.03,14.47) 305.87,14.63 305.87,15.37 306.21,15.72 306.71,15.72 RM46.1 ; v3(189.79,136.74) 189.93,136.6 189.93,136.16 189.93,136.16 189.93,136.14 190.16,135.92 192.52,135.92 193.14,135.3 193.14,134.36 193.41,134.09 193.64,134.09 RM89.2
  IN4 w0.091: v3(306.03,14.47) 305.85,14.65 305.85,14.91 305.97,15.04 309.85,15.04 311.9,12.99 326.67,12.99 331.42,17.75 331.42,27.77 330.06,29.13 317.32,29.13 316.78,29.67 316.78,38.72 315.35,40.15 308,40.15 307.04,39.19 306.36,39.19 v3(306.17,39.37)
  IN5 w0.099: v3(306.17,39.37) 305.99,39.19 304.71,39.19 304.11,38.6 286.74,38.6 285.89,37.75 271.57,37.75 270.96,38.35 263.49,38.35 260.52,41.33 259.38,41.33 258.32,42.38 256.36,42.38 252.87,45.87 251.8,45.87 242.28,55.4 237.58,55.4 234.49,58.49 234.49,60.11 234.28,60.33 234.28,64.38 234.79,64.89 234.79,70.51 235.51,71.22 235.51,96.9 233.31,99.1 233.31,99.46 230.7,102.07 230.37,102.07 225.53,106.91 225.53,110.99 224.15,112.36 224.15,114.55 224.57,114.97 224.57,118.97 224.25,119.29 223.4,119.29 217.9,124.79 214.07,124.79 213.63,125.24 209.59,125.24 206.43,128.4 201.86,128.4 198.21,132.05 198.21,133.85 197.4,134.66 197.4,136.27 196.41,137.26 193.05,137.26 192.53,137.78 190.46,137.78 189.99,137.31 189.99,136.94 189.89,136.84 189.89,136.84 v3(189.79,136.74)
  BOTTOM w0.127: JCDRA.45 188.55,142.25 188.83,141.98 188.83,141.45 189.36,140.92 189.36,137.17 v3(189.79,136.74)
CDR_I2C_DAT: length 282.6
  TOP w0.127: v3(305.45,14.47) 305.61,14.63 305.61,15.48 306.1,15.97 306.71,15.97 RM45.1 ; v3(190.41,136.73) 190.18,136.5 190.18,136.26 190.19,136.26 190.19,136.25 190.26,136.17 192.63,136.17 193.4,135.4 193.4,134.46 193.51,134.35 193.64,134.35 RM90.2
  IN4 w0.091: v3(306.17,38.79) 306.26,38.88 306.27,38.88 306.36,38.97 307.13,38.97 308.09,39.93 315.26,39.93 316.56,38.63 316.56,29.58 317.23,28.91 329.97,28.91 331.21,27.68 331.21,17.84 326.58,13.21 312.02,13.21 309.97,15.26 305.88,15.26 305.63,15 305.63,14.65 v3(305.45,14.47)
  IN5 w0.099: v3(306.17,38.79) 305.99,38.97 304.8,38.97 304.21,38.37 286.84,38.37 285.99,37.52 271.47,37.52 270.87,38.13 263.4,38.13 260.43,41.1 259.29,41.1 258.23,42.16 256.27,42.16 252.78,45.65 251.71,45.65 242.18,55.17 237.49,55.17 234.27,58.39 234.27,60.02 234.05,60.24 234.05,64.47 234.57,64.99 234.57,70.6 235.28,71.32 235.28,96.81 233.09,99.01 233.09,99.36 230.6,101.85 230.27,101.85 225.3,106.82 225.3,110.9 223.93,112.27 223.93,114.64 224.35,115.06 224.35,118.87 224.16,119.06 223.31,119.06 217.8,124.57 213.98,124.57 213.54,125.01 209.5,125.01 206.34,128.17 201.77,128.17 197.98,131.96 197.98,133.76 197.17,134.57 197.17,136.18 196.32,137.04 192.95,137.04 192.43,137.56 190.55,137.56 190.25,137.25 190.21,137.22 190.21,136.94 190.31,136.84 190.41,136.74 v3(190.41,136.73)
  BOTTOM w0.127: v3(190.41,136.73) 189.61,137.53 189.61,141.03 189.08,141.56 189.08,141.99 189.35,142.26 JCDRA.46
CDR_ON_ELC: length 230.7
  TOP w0.127: v3(265.36,25.52) 265.36,26.1 v1(265.52,26.27)
  IN2 w0.099: v3(245.09,38.42) 245.34,38.67 245.34,42.09 244.73,42.7 243.92,42.7 242.04,44.58 242.04,45.99 240.51,47.51 239.32,47.51 238.71,48.13 238.71,48.37 238.06,49.02 237.76,49.02 237.05,49.73 236.58,49.73 234.01,52.3 232.75,52.3 232.29,52.76 231.88,52.76 230.63,54.01 230.63,54.6 230.14,55.1 227.14,55.1 224.61,57.63 210.97,57.63 209.29,55.95 206.77,53.43 206.77,51.87 203.55,48.65 201.86,48.65 192.86,57.65 165.19,57.65 163.4,55.86 160.03,55.86 157.96,57.93 157.96,63.96 158.22,64.21 158.22,65.86 157.81,66.28 157.81,78.89 156.27,80.42 156.27,90.33 154.59,92.02 154.59,115.66 150.23,120.01 150.23,123.69 152.04,125.49 152.04,134.29 152.41,134.67 152.41,136.73 154.31,138.63 155.62,138.63 v3(156.06,139.07)
  IN4 w0.091: v3(265.35,25.52) 264.75,26.13 263.23,26.13 261.44,27.91 259.07,27.91 254.59,32.39 246.86,32.39 244.91,34.34 244.91,37.17 244.67,37.42 244.67,38 v3(245.09,38.42)
  BOTTOM w0.127: v3(265.36,25.52) 265.36,24.67 UE1.27 ; UM7.4 156.13,139.14 v3(156.06,139.07)
CDR_TXRX_GOOD: length 251.9
  TOP w0.127: v3(278.58,13.11) 278.4,12.93 UE5.71
  IN2 w0.089: v3(160.81,106.05) 160.58,105.82 160.58,95.17 161.77,93.98 161.77,83.76 161.57,83.56 161.57,80.96 161.82,80.72 162.64,80.72 163.71,79.66 163.71,74.57 162.86,73.72 162.86,70.95 162.34,70.42 162.34,67.02 162.8,66.55 165.28,66.55
  IN2 w0.101: v3(240.97,51.46) 239.65,52.77 236.33,52.77 231.14,57.96 229.26,57.96 227.36,59.87 209.05,59.87 205.45,56.26 202.69,56.26 199.25,59.7 199.25,59.73 197.45,61.53 183.77,61.53 180.77,64.53 179.25,64.53 178.44,65.34 176.33,65.34 175.12,66.55 165.28,66.55
  IN3 w0.091: v3(282.64,34.99) 282.64,35.4 281.82,36.22 277.57,36.22 275.4,34.05 268.77,34.05 266.99,35.83 262.03,35.83 258.49,39.37 254.18,39.37 248.13,45.43 244.37,45.43 241.87,47.92 241.87,49.91 240.97,50.82 v3(240.97,51.46)
  IN5 w0.099: v3(160.81,106.05) 161.76,107 161.76,128.25 162.88,129.36 162.88,131.14 160.8,133.23 160.8,133.9 160.36,134.33 157.57,134.33 156.1,135.8 156.1,137.5 158.9,140.31 v3(158.9,140.78)
  BOTTOM w0.127: v3(278.58,13.11) 278.58,12.77 278.92,12.42 280.02,12.42 280.44,12.84 280.44,13.9 282.12,15.57 282.12,18.43 283.29,19.6 283.29,22.51 283.63,22.85 283.63,23.94 282.93,24.65 282.93,30.15 282.63,30.44 282.63,34.98 v3(282.64,34.99) ; UM7.1 159.25,140.44 v3(158.9,140.78)
CDRA_LED RED: length 203.3
  TOP w0.127: v1(296.74,30.27) 296.99,30.52 v3(296.99,31.42) 296.99,31.92 296.78,32.13 QM3.1
  IN2 w0.099: v3(233.91,99.38) 233.77,99.52 231.31,99.52 229.81,101.02 228.86,101.02 222.34,107.53 222.34,119.67 220.89,121.12 217.84,121.12 212.29,126.66 207.47,126.66 202.2,131.93 202.2,133.02 200.49,134.73 200.01,134.73 195.3,139.44 194.22,139.44 193.94,139.71 193.38,139.71 189.37,143.73 189.37,144.35 187.89,145.82 v3(186.92,145.82)
  IN6 w0.099: v3(296.99,31.42) 296.05,30.48 278.25,30.48 274.82,33.91 265.05,33.91 253.47,45.49 251.99,45.49 241.94,55.54 236.11,55.54 233.01,58.65 233.01,63.51 234.34,64.84 234.34,66.07 234.69,66.42 234.69,70.57 235.41,71.28 235.41,98.81 234.83,99.38 v3(233.91,99.38)
  BOTTOM w0.127: JCDRA.28 181.5,144.06 181.5,144.07 181.5,144.16 181.98,144.64 181.98,145.1 182.7,145.82 v3(186.92,145.82)
CDRA_LED RED_R: length 4.9
  TOP w0.127: UE5.126 290.9,25.05 291.16,25.31 291.16,26.02 290.98,26.2 290.98,27.17 v1(291.33,27.52) 291.93,28.11 QM2.5
CDRA_LED RED_R_R: length 3.3
  TOP w0.127: QM3.3 RM93.2 295.2,36.97 v1(294.78,37.39)
CDRA_LED WHITE: length 198.3
  TOP w0.127: v1(290.72,30.13) 290.72,31.28 v3(290.92,31.49) 291.58,32.15 QM1.1
  IN2 w0.099: v3(186.91,146.41) 187.63,146.41 189.64,144.4 189.64,143.8 193.49,139.96 194.02,139.96 194.31,139.66 195.39,139.66 200.08,134.98 200.6,134.98 202.45,133.12 202.45,132 207.54,126.91 212.4,126.91 217.94,121.37 221,121.37 222.57,119.79 222.57,107.63 228.94,101.26 229.89,101.26 231.39,99.76 233.7,99.76 v3(233.91,99.97)
  IN6 w0.099: v3(290.92,31.49) 290.15,30.71 278.34,30.71 274.91,34.14 265.14,34.14 253.53,45.75 252.06,45.75 242.04,55.77 236.2,55.77 233.24,58.74 233.24,63.42 234.57,64.75 234.57,65.98 234.93,66.33 234.93,70.48 235.64,71.19 235.64,99.11 234.78,99.97 v3(233.91,99.97)
  BOTTOM w0.127: JCDRA.27 181.1,144.12 181.1,144.13 181.1,144.18 181.69,144.77 181.69,145.2 182.56,146.08 186.58,146.08 v3(186.91,146.41)
CDRA_LED WHITE_R: length 25.3
  TOP w0.127: v3(297.6,31.43) 297.6,30.01 v1(296.08,28.49) 295.7,28.11 QM2.2 ; v3(280.28,28.73) 280.4,28.61 UE5.21
  IN6 w0.099: v3(280.28,28.73) 281.8,30.25 296.42,30.25 v3(297.6,31.43)
CDRA_LED WHITE_R#: length 9.8
  TOP w0.127: v1(292.88,36.37) QM1.2 292.88,30.52 RM92.2 293.42,29.95 293.42,28.23 292.65,27.46 QM2.6
CDRA_LED WHITE_R_R: length 3.3
  TOP w0.127: v1(291.3,37.35) RM91.2 290.95,35.66 QM1.3
CDRA_RST#: length 26.4
  IN6 w0.099: v3(179.28,145.76) 179.43,145.91 181.83,145.91 182.06,145.68 185.04,145.68 185.8,144.92 191.78,144.92 v3(191.77,144.93)
  BOTTOM w0.127: JCDRA.22 179.1,145.58 v3(179.28,145.76) ; v3(191.77,144.93) 192.28,144.42 192.28,141.31 193.77,139.82 194.55,139.82 195.14,139.23 195.14,138.1 194.86,137.83 UM3.4 194.39,136.88 v1(194.57,136.7)
CE_EN_R: length 5.9
  TOP w0.127: v1(100.95,125.4) 99.53,126.83 RV36.1 99.13,127.93 99,127.93 JEDP1.18
CFG0: length 1.2
  TOP w0.089: v3(95.51,84.32) 95.06,83.88 T102.1
  BOTTOM w0.089: v3(95.51,84.32) 95.87,84.68 CPU1.AG49
CFG1: length 1.9
  TOP w0.089: T103.1 95.95,85.5 v3(95.5,85.95)
  BOTTOM w0.089: v3(95.5,85.95) 95.87,86.32 CPU1.AD49
CFG2: length 7.9
  TOP w0.127: v3(95.49,86.81) 95.06,86.38 91.95,86.38 91.91,86.34 91.88,86.34 91.55,86.01 91.11,86.01 RC36.2 89.97,84.86 T104.1
  BOTTOM w0.089: CPU1.AC49 v3(95.49,86.81)
CFG3: length 1.2
  TOP w0.089: T105.1 95.13,85.49 v3(95.51,85.1)
  BOTTOM w0.089: v3(95.51,85.1) 95.87,85.47 CPU1.AE49
CFG4: length 7.2
  TOP w0.127: v3(94.8,89.22) 94.4,88.81 91.91,88.81 91.52,88.42 90.86,88.42 RC37.1 89.78,87.34 T106.1
  BOTTOM w0.089: v3(94.8,89.22) 95.17,88.85 CPU1.Y50
CFG5: length 9.4
  TOP w0.127: T108.1 89.72,86.32 RC42.2 90.85,86.45 91.63,86.45 92.39,87.21 95.11,87.21 v3(95.47,87.57)
  BOTTOM w0.089: v3(95.47,87.57) 95.87,87.97 CPU1.AB49
CFG6: length 6.4
  TOP w0.127: T107.1 89.4,89.24 RC41.2 90.79,90.64 91.6,90.64 91.8,90.45 93.69,90.45 v3(94.09,90.84)
  BOTTOM w0.089: v3(94.09,90.84) 94.47,90.46 CPU1.V51
CFG7: length 8.2
  TOP w0.127: T109.1 89.5,88.42 RC43.2 90.91,88.71 91.45,88.71 91.99,89.24 92.71,89.24 93.11,89.64 93.55,89.64 93.94,90.03 v3(94.09,90.03)
  BOTTOM w0.089: v3(94.09,90.03) 94.47,89.65 CPU1.W51
CFG8: length 1.8
  TOP w0.089: v3(95.47,88.4) 95.04,87.97 T111.1
  BOTTOM w0.089: v3(95.47,88.4) 95.47,88.41 CPU1.Y49
CFG9: length 4.3
  BOTTOM w0.127: T113.1 89.73,86.9 91.64,88.81 CPU1.Y54
CFG10: length 6.5
  BOTTOM w0.089: CPU1.Y53 92.76,89.12 92.24,89.12 92.17,89.05 91.32,89.05 90.81,88.55
  BOTTOM w0.127: T110.1 90.24,87.97 90.81,88.55
CFG11: length 4.6
  BOTTOM w0.089: 90.81,89.19 91.06,89.44 92.08,89.44 92.2,89.31 92.76,89.31 CPU1.W53
  BOTTOM w0.127: T112.1 90.48,88.86 90.81,89.19
CFG12: length 2.6
  TOP w0.089: T116.1 91,91.21 92.33,91.21 v3(92.71,90.83)
  BOTTOM w0.089: v3(92.71,90.83) 93.07,91.19 CPU1.U53
CFG13: length 5.8
  BOTTOM w0.127: T117.1 90.3,89.44 91.3,90.44 CPU1.V54
CFG14: length 6.2
  BOTTOM w0.089: CPU1.R53 93.07,91.89 92.74,91.56 92.14,91.56 91.98,91.4 90.81,91.4
  BOTTOM w0.127: 90.81,91.4 90.11,91.4 89.09,92.42 T114.1
CFG15: length 8.7
  BOTTOM w0.089: CPU1.R52 93.77,92.07 93.37,92.47 93.01,92.47 92.71,92.17 92.71,91.88 92.59,91.75 90.81,91.75
  BOTTOM w0.127: T115.1 88.97,93.31 90.52,91.75 90.81,91.75
CFG16: length 2.1
  TOP w0.089: T119.1 94.3,89.63 93.92,89.63 93.51,89.22 v3(93.41,89.22)
  BOTTOM w0.089: v3(93.41,89.22) 93.77,88.86 CPU1.Y52
CFG17: length 1.1
  TOP w0.089: T120.1 92.33,89.68 v3(92.68,90.03)
  BOTTOM w0.089: v3(92.68,90.03) 93.07,90.42 CPU1.V53
CFG18: length 3.1
  TOP w0.089: v3(94.09,89.22) 94.27,89.22 94.63,89.58 95.75,89.58 96.01,89.31 T121.1
  BOTTOM w0.089: v3(94.09,89.22) 94.47,88.83 CPU1.Y51
CFG19: length 5.6
  TOP w0.089: v3(93.39,90.84) 93.27,90.84 92.65,91.47 91.57,91.47 91.12,91.91 90.81,91.91
  TOP w0.127: 90.81,91.91 89.79,91.91 T122.1
  BOTTOM w0.089: CPU1.V52 93.77,90.46 v3(93.39,90.84)
CFG_RCOMP: length 2.7
  TOP w0.127: v3(91.82,92.18) RC39.2 91.2,93.36 v1(90.74,93.82)
  BOTTOM w0.127: CPU1.R54 91.94,92.06 v3(91.82,92.18)
CHG:
  vias: v1(64.05,47.93)
CHG_B+:
  vias: v2(56.56,31.7) v3(51.51,33.87) v3(51.51,33.24) v3(51.51,32.6) v3(52.26,33.87) v3(52.9,33.87) v3(53.53,33.87) v3(54.17,33.87) v3(54.8,33.87) v3(55.56,33.3) v3(55.88,32.73) v3(56.2,33.3) v3(56.52,32.73) v3(56.83,33.3) v3(57.15,32.73)
CLK_BUF_BCLK: length 9.6
  TOP w0.102: v3(215.83,39.15) 216,39.33 216,39.45 215.89,39.56 215.23,39.56 214.95,39.84 214.95,40.31 214.72,40.54 212.51,40.54 212.02,40.05 211.93,40.05 211.91,40.03
  TOP w0.127: 211.91,40.03 209.59,40.03 209.33,40.29 208.93,40.29 208.81,40.17 RPH1.3
  BOTTOM w0.089: v3(215.83,39.15) 215.48,38.8 UH1.AT24
CLK_BUF_BCLK#: length 10
  TOP w0.102: v3(216.48,39.18) 216.26,39.4 216.26,39.55 216.02,39.79 215.36,39.79 215.2,39.95 215.2,40.43 214.83,40.8 212.4,40.8 211.92,40.32 211.75,40.32
  TOP w0.127: 211.75,40.32 v4(210.26,40.32) 209.71,40.32 209.45,40.58 208.92,40.58 208.83,40.67 RPH1.4
  BOTTOM w0.089: UH1.AR24 216.08,38.78 v3(216.48,39.18)
CLK_BUF_CKSSCD: length 6.6
  BOTTOM w0.089: 210.89,29.64 211.14,29.9 211.14,31.27 211.63,31.76 211.91,31.76 212.19,31.48 UH1.BC6
  BOTTOM w0.127: 210.89,29.64 210.35,29.11 208.36,29.11 RH155.1
CLK_BUF_CKSSCD#: length 5.7
  BOTTOM w0.089: 210.89,29.24 211.38,29.73 211.38,31.17 211.67,31.46 UH1.BE6
  BOTTOM w0.127: RH122.1 208.58,28.82 210.47,28.82 210.89,29.24
CLK_BUF_DMI: length 7.2
  TOP w0.102: 212.49,39.55 212.5,39.53 212.77,39.53 213.02,39.78 214.11,39.78 214.34,39.55 214.34,39.34 v3(214.53,39.15)
  TOP w0.127: RPH1.2 208.9,39.67 209.02,39.55 v4(211.89,39.55) 212.49,39.55
  BOTTOM w0.089: UH1.AW24 214.28,38.91 v3(214.53,39.15)
CLK_BUF_DMI#: length 6.7
  TOP w0.102: v3(213.88,39.15) 214.08,39.35 214.08,39.44 213.95,39.57 213.22,39.57 213.17,39.52 213.13,39.52 212.88,39.27 212.61,39.27 212.6,39.26 212.58,39.26
  TOP w0.127: 212.58,39.26 208.97,39.26 208.88,39.17 RPH1.1
  BOTTOM w0.089: v3(213.88,39.15) 213.69,38.96 UH1.AY24
CLK_BUF_DOT96: length 5.6
  TOP w0.089: 228.99,43.61 228.98,43.61 228.6,43.23 228.6,43.22 228.47,43.09 v3(228.27,43.09)
  TOP w0.127: 228.99,43.61 230.11,43.61 v4(230.68,43.03) 230.98,42.73 231.65,42.73 232,43.08 232,43.31 232.04,43.35 RPH2.4
  BOTTOM w0.089: UH1.G33 227.85,42.68 v3(228.27,43.09)
CLK_BUF_DOT96#: length 6.5
  TOP w0.089: v3(227.62,43.16) 227.93,43.47 228.5,43.47 228.9,43.87 228.96,43.87 228.98,43.89 228.99,43.89
  TOP w0.127: RPH2.3 231.97,43.85 231.71,43.59 231.71,43.2 231.53,43.02 231.1,43.02 230.23,43.89 v4(229.29,43.89) 228.99,43.89
  BOTTOM w0.089: v3(227.62,43.16) 227.25,42.79 UH1.H33
CLK_CPU_DMI: length 159.3
  IN1 w0.099: v3(125.06,88.86) 125.06,88.79 125.41,88.44 125.99,88.44 126.25,88.7 127.69,88.7 128.58,87.81 131.97,87.81 136.31,83.47 136.31,67.97 140.06,64.22 140.06,58.47 144.48,54.05 147.43,54.05 153.8,47.67 155.4,47.67 158.69,44.38 158.69,42.88 159.81,41.76 159.81,38.88 160.05,38.63 160.05,34.02 164.35,29.71 168.89,29.71 170.56,28.05 170.56,25.16 171.07,24.65 172.24,24.65 174.99,21.9 182.12,21.9 187.49,21.9 193.46,27.87 193.46,29.22 199.53,35.28 199.53,41.26 204,45.74 207.52,45.74 209.17,47.39 212.33,47.39 212.7,47.76 218.14,47.76 218.97,46.93 218.97,46.09 219.11,45.94 219.11,45.7 v3(219.29,45.51)
  BOTTOM w0.089: UH1.AF40 219.55,45.77 v3(219.29,45.51) ; CPU1.AA6 124.72,88.52 v3(125.06,88.86)
CLK_CPU_DMI#: length 159.5
  IN1 w0.099: v3(219.29,44.92) 218.9,45.32 218.9,45.86 218.75,46 218.75,46.84 218.05,47.55 212.79,47.55 212.42,47.18 209.26,47.18 207.61,45.53 204.09,45.53 199.74,41.17 199.74,35.2 193.67,29.13 193.67,27.78 187.58,21.69 182.2,21.69 182.2,21.69 174.91,21.69 172.15,24.44 170.98,24.44 170.35,25.08 170.35,27.96 168.8,29.5 164.27,29.5 159.84,33.93 159.84,38.55 159.6,38.79 159.6,41.67 158.48,42.79 158.48,44.29 155.31,47.46 153.72,47.46 147.34,53.84 144.39,53.84 139.85,58.38 139.85,64.14 136.1,67.89 136.1,83.39 131.88,87.6 128.49,87.6 127.6,88.49 126.34,88.49 126.08,88.23 125.25,88.23 125.09,88.07 v3(125.09,88.06)
  BOTTOM w0.089: v3(219.29,44.92) 219.54,44.92 UH1.AF39 ; CPU1.AB6 124.72,87.69 v3(125.09,88.06)
CLK_CPU_DPLL: length 161.5
  IN1 w0.099: v3(124.44,86.41) 124.57,86.54 124.57,86.76 124.9,87.09 127.52,87.09 128.38,86.22 131.24,86.22 134.93,82.54 134.93,67.4 138.68,63.65 138.68,57.56 143.6,52.63 146.89,52.63 153.25,46.28 154.81,46.28 157.24,43.84 157.24,42.15 158.41,40.99 158.41,36.79 157.95,36.33 157.95,33.99 163.61,28.33 168.32,28.33 169.18,27.47 169.18,23.12 170.46,21.83 172.8,21.83 174.33,20.3 180.41,20.3 180.75,19.97 182.32,19.97 182.87,20.52 188.06,20.52 194.85,27.31 194.85,28.62 201.08,34.84 201.08,40.42 201.09,40.44 201.09,40.44 204.83,44.18 208.02,44.18 209.15,45.31 212.29,45.31 212.95,44.65 214.76,44.65 215.23,44.18 215.65,44.18 217.35,42.48 218.5,42.48 218.7,42.69 218.7,43.32 218.93,43.55 219.12,43.55 v3(219.29,43.72)
  BOTTOM w0.089: UH1.AF36 219.55,43.98 v3(219.29,43.72) ; v3(124.44,86.41) 124.72,86.13 CPU1.AE6
CLK_CPU_DPLL#: length 161.4
  IN1 w0.099: v3(219.29,43.12) 219.08,43.33 219.01,43.33 218.92,43.24 218.92,42.6 218.59,42.27 217.26,42.27 215.57,43.97 215.14,43.97 214.68,44.44 212.86,44.44 212.21,45.09 209.23,45.09 208.1,43.97 204.92,43.97 201.3,40.35 201.3,40.35 201.29,40.34 201.29,34.76 195.06,28.53 195.06,27.22 188.15,20.31 182.96,20.31 182.4,19.76 180.66,19.76 180.32,20.09 174.24,20.09 172.72,21.62 170.38,21.62 168.97,23.03 168.97,27.39 168.23,28.12 163.52,28.12 157.74,33.9 157.74,36.41 158.2,36.88 158.2,40.9 157.03,42.07 157.03,43.76 154.72,46.06 153.16,46.06 146.8,52.42 143.51,52.42 138.47,57.47 138.47,63.56 134.72,67.31 134.72,82.45 131.15,86.01 128.3,86.01 127.43,86.88 124.99,86.88 124.78,86.67 124.78,86.57 124.94,86.41 v3(125.12,86.41)
  BOTTOM w0.089: v3(219.29,43.12) 219.29,43.15 219.52,43.38 UH1.AF35 ; CPU1.AC6 124.72,86.8 v3(125.12,86.41)
CLK_CPU_SSC_DPLL: length 162.7
  IN1 w0.099: v3(124.37,89.64) 124.18,89.83 123.85,89.83 123.75,89.73 123.75,88.38 124.54,87.59 127.73,87.59 128.32,87 131.71,87 135.62,83.09 135.62,67.69 139.37,63.94 139.37,57.89 143.94,53.32 147.17,53.32 153.53,46.97 155.09,46.97 157.99,44.07 157.99,42.38 159.1,41.27 159.1,37.97 159.32,37.74 159.32,33.64 163.94,29.02 168.6,29.02 169.87,27.76 169.87,24.16 170.99,23.05 172.56,23.05 174.4,21.21 182.49,21.21 182.49,21.21 187.78,21.21 194.15,27.58 194.15,28.93 200.22,35 200.22,40.64 204.53,44.96 207.72,44.96 208.8,46.04 208.8,46.04 208.83,46.06 211.99,46.06 212.31,46.38 213.69,46.38 214.4,47.09 218.09,47.09 218.47,46.71 218.47,46 218.68,45.78 218.68,45.3 v3(218.32,44.93)
  BOTTOM w0.089: UH1.AJ39 218.56,45.17 v3(218.32,44.93) ; CPU1.Y6 124.72,89.29 v3(124.37,89.64)
CLK_CPU_SSC_DPLL#: length 162.9
  IN1 w0.099: v3(124.41,90.47) 124.53,90.47 124.65,90.35 124.65,90.17 124.53,90.05 123.76,90.05 123.54,89.82 123.54,88.29 124.45,87.38 127.64,87.38 128.24,86.79 131.63,86.79 135.41,83.01 135.41,67.6 139.16,63.85 139.16,57.81 143.85,53.11 147.09,53.11 153.44,46.76 155.01,46.76 157.78,43.98 157.78,42.29 158.89,41.18 158.89,37.88 159.11,37.66 159.11,33.56 163.86,28.81 168.52,28.81 169.66,27.67 169.66,24.08 170.9,22.84 172.47,22.84 174.31,21 182.58,21 182.58,21 187.86,21 194.36,27.49 194.36,28.84 200.43,34.91 200.43,40.56 204.62,44.75 207.81,44.75 208.89,45.83 208.89,45.83 208.92,45.85 212.08,45.85 212.4,46.17 213.78,46.17 214.49,46.88 218,46.88 218.26,46.62 218.26,45.87 218.32,45.82 v3(218.32,45.58)
  BOTTOM w0.089: UH1.AJ40 218.5,45.77 v3(218.32,45.58) ; CPU1.V6 124.41,90.4 v3(124.41,90.47)
CLK_PCH_14M: length 4.8
  BOTTOM w0.127: RH79.1 227.28,51.03 227.04,50.79 v1(227.04,50.7) 227.04,50.34 228.27,49.11 228.27,47.98 UH1.F45
CLK_PCI0: length 25.4
  TOP w0.127: v3(229.4,46.74) 228.98,46.32 228.54,46.32 228.33,46.53 228.33,46.91 228.03,47.21 228.03,51.78 227.73,52.08 224.17,52.08 224.04,51.96 224.04,51.67 224.17,51.54 227.01,51.54 227.14,51.41 227.14,51.06 227.01,50.93 225.1,50.93 224.97,50.8 224.97,50.46 225.1,50.33 v1(226.21,50.33) 227.05,50.33 227.18,50.21 227.18,47.3 227.9,46.57 227.9,46.13 228.39,45.64 RH87.1
  BOTTOM w0.089: v3(229.4,46.74) 229.06,47.07 UH1.D44
CLK_PCI1: length 2.4
  TOP w0.089: v1(229.2,48.34) 228.65,47.79 RH89.1 228.65,46.76 v3(228.71,46.71)
  BOTTOM w0.089: v3(228.71,46.71) 228.71,46.86 UH1.E44
CLK_PCI2: length 1.2
  TOP w0.089: T96.1 229.81,45.78 v3(229.81,45.78)
  BOTTOM w0.089: v3(229.81,45.78) 229.74,45.85 UH1.B42
CLK_PCI3: length 1.1
  TOP w0.089: v3(227.51,46.4) 227.26,46.65 T95.1
  BOTTOM w0.089: v3(227.51,46.4) 227.81,46.1 UH1.F41
CLK_PCI4: length 3.4
  BOTTOM w0.089: 231.02,45.8 230.53,45.32 UH1.A40
  BOTTOM w0.102: 231.02,45.8 231.14,45.93
  BOTTOM w0.127: 231.14,45.93 233.41,45.93 T83.1
CLK_PCI_LPBACK: length 30
  TOP w0.089: v3(227.37,44.69) 227.64,44.97 RH87.2
  IN6 w0.089: v3(228.22,35.63) 228.22,36.73 227.89,37.06 226.86,37.06 226.63,37.29 226.63,38.28 226.89,38.53 228.73,38.53 228.86,38.66 228.86,39.59 228.73,39.71 225.3,39.71 225.17,39.84 225.17,40.48 225.31,40.62 229.38,40.62 229.49,40.73 229.49,41.49 229.36,41.62 225.81,41.62 225.68,41.75 225.68,42.38 225.81,42.51 228.54,42.51 228.67,42.64 228.67,43.4 228.54,43.52 227.31,43.52 227.18,43.65 227.18,44.51 v3(227.37,44.69)
  BOTTOM w0.089: UH1.D17 228.68,35.95 228.36,35.63 v3(228.22,35.63)
CLK_PCI_LPC: length 74.5
  TOP w0.127: v3(284.58,31.52) 284.33,31.27 284.33,30.33 RE89.2 284.48,29.54 284.48,28.97 284,28.48 UE5.12 ; v3(236.49,50.72) 235.72,49.94 v1(230.72,49.94) 229.99,49.94 CH72.1 229.52,49.47 229.52,47.45 RH89.2
  IN1 w0.099: v3(236.49,50.72) 238.41,52.63 243.4,52.63 250.17,45.86 253.34,45.86 255.92,43.28 255.92,42.61 258.51,40.02 259.53,40.02 260.09,39.46 262.64,39.46 264.51,37.58 268.63,37.58 268.91,37.86 270.72,37.86 271.4,37.17 282.4,37.17 283.89,35.69 283.89,32.22 v3(284.58,31.52)
CLK_PCIE_CD: length 133.6
  TOP w0.127: UR1.5 327.48,16.47 327.54,16.42 327.54,14.91 326.34,13.71 321.74,13.71 308.04,27.41 308.04,31.19 307.72,31.52 307.47,31.52 v3(307.28,31.71)
  IN4 w0.091: v3(220.22,49.32) 220.46,49.08 220.67,49.08 220.92,48.83 220.92,48.08 221.54,47.46 223.65,47.46 226.3,50.11 232.46,50.11 234.41,52.06 242.02,52.06 254.3,39.78 256.28,39.78 260.51,35.55 266.91,35.55 268.73,33.73 276.4,33.73 276.77,34.1 280.02,34.1 280.47,33.66 301.48,33.66 303.34,31.8 305.86,31.8 306.2,31.46 307.02,31.46 v3(307.28,31.71)
  BOTTOM w0.089: 219.79,48.48 219.79,48.29 220,48.08 220,47.86 UH1.AF45
  BOTTOM w0.127: 219.79,48.48 219.79,48.89 v3(220.22,49.32)
CLK_PCIE_CD#: length 134.1
  TOP w0.127: v3(307.27,31.08) 307.42,31.23 307.6,31.23 307.75,31.07 307.75,27.29 321.62,13.43 326.46,13.43 327.82,14.79 327.82,16.43 327.88,16.49 UR1.6
  IN4 w0.091: v3(307.27,31.08) 307.08,31.27 306.12,31.27 305.78,31.61 303.26,31.61 301.4,33.47 280.39,33.47 279.94,33.91 276.85,33.91 276.48,33.54 268.65,33.54 266.83,35.35 260.43,35.35 256.2,39.59 254.22,39.59 241.94,51.87 234.49,51.87 232.54,49.92 226.38,49.92 223.73,47.27 221.46,47.27 220.73,48 220.73,48.75 220.59,48.89 220.4,48.89 v3(220.22,48.71)
  BOTTOM w0.089: UH1.AF43 219.85,47.3 220.22,47.67 220.22,47.72 220.25,47.75 220.25,48.18 220.22,48.21 220.22,48.48
  BOTTOM w0.127: 220.22,48.48 v3(220.22,48.71)
CLK_PCIE_DGPU: length 77.5
  IN6 w0.099: v3(223.53,110.31) 223.69,110.15 224.31,110.15 224.59,109.87 224.59,106.01 231.55,99.06 231.55,96.88 233.41,95.02 233.41,72.01 232.86,71.45 232.86,67.22 232.51,66.87 232.51,65.87 223.86,57.22 223.86,46.38 222.9,45.41 222.63,45.41 222.31,45.09 222.02,45.09 v3(221.86,44.93)
  BOTTOM w0.089: UH1.Y38 222.22,44.57 v3(221.86,44.93)
  BOTTOM w0.127: v3(223.53,110.31) 223.4,110.18 223.29,110.18 223.14,110.33 223.14,111.32 RM22.1
CLK_PCIE_DGPU#: length 77.5
  IN6 w0.099: v3(223.53,109.73) 223.74,109.94 224.22,109.94 224.38,109.78 224.38,105.93 231.34,98.97 231.34,96.8 233.2,94.94 233.2,72.09 232.65,71.54 232.65,67.3 232.3,66.95 232.3,65.95 223.65,57.3 223.65,46.46 222.81,45.62 222.54,45.62 222.22,45.3 221.93,45.3 221.86,45.37 v3(221.86,45.58)
  BOTTOM w0.089: v3(221.86,45.58) 222.27,45.17 UH1.Y39
  BOTTOM w0.127: RM24.1 222.85,111.35 222.85,110.21 223.17,109.89 223.37,109.89 v3(223.53,109.73)
CLK_PCIE_DGPU#_C: length 48.9
  IN4 w0.091: v3(219.97,127.26) 220.14,127.08 220.14,126.72 220.08,126.66 219.1,126.66 218.78,126.98 208.88,126.98 200.84,135.02 200.06,135.02 193.71,141.37 192.92,141.37 189.24,145.05 183.34,145.05 v3(183.14,145.26)
  BOTTOM w0.127: JCDRA.34 183.9,144.86 183.59,145.16 183.23,145.16 v3(183.14,145.26) ; v3(219.97,127.26) 219.97,126.8 CM99.2
CLK_PCIE_DGPU_C: length 48.8
  IN4 w0.091: v3(183.14,144.67) 183.32,144.86 189.16,144.86 192.84,141.17 193.63,141.17 199.98,134.82 200.76,134.82 208.8,126.79 218.7,126.79 219.02,126.47 220.16,126.47 220.34,126.64 220.34,127.09 220.5,127.26 v3(220.56,127.26)
  BOTTOM w0.127: v3(183.14,144.67) 183.14,144.69 183.32,144.88 183.47,144.88 183.61,144.74 183.61,144.2 183.5,144.09 JCDRA.33 ; v3(220.56,127.26) 220.56,126.77 CM98.2
CLK_PCIE_LAN: length 110
  TOP w0.127: UL1.33 315.43,35 315.29,35.15 314.89,35.15 314.58,35.46 v3(314.33,35.46)
  IN4 w0.091: v3(314.33,35.46) 314.63,35.46 315.12,34.97 315.12,33.13 314.68,32.68 308.71,32.68 307.02,34.37 280.85,34.37 280.43,34.79 276.44,34.79 276.07,34.42 269.04,34.42 267.19,36.27 261.24,36.27 257.07,40.44 254.57,40.44 242.29,52.72 234.02,52.72 232.15,50.85 226.02,50.85 223.33,48.16 222.83,48.16 222.67,48.32 222.27,48.32 v3(221.9,48.69)
  BOTTOM w0.089: UH1.AB45 221.47,48.14
  BOTTOM w0.127: v3(221.9,48.69) 221.9,48.57 221.47,48.14
CLK_PCIE_LAN#: length 109.9
  TOP w0.127: UL1.32 315.44,35.4 315.41,35.44 315.01,35.44 314.9,35.55 v3(314.9,35.78)
  IN4 w0.091: v3(221.92,48.05) 222,48.12 222.59,48.12 222.75,47.97 223.41,47.97 226.1,50.66 232.23,50.66 234.1,52.53 242.21,52.53 254.49,40.25 256.99,40.25 261.16,36.08 267.11,36.08 268.96,34.23 276.15,34.23 276.52,34.59 280.35,34.59 280.77,34.18 306.94,34.18 308.63,32.49 314.76,32.49 315.32,33.05 315.32,35.05 314.9,35.47 v3(314.9,35.78)
  BOTTOM w0.089: v3(221.92,48.05) 221.92,47.74 221.47,47.29 UH1.AB43
CLK_PCIE_WLAN: length 89.7
  IN1 w0.099: v3(221.44,49.89) 221.44,49.79 221.21,49.55 220.94,49.55 220.53,49.96 207.08,49.96 203.73,46.61 203.73,46.48 203.71,46.46 203.7,46.46 198.84,41.6 198.84,37.38 198.01,36.56 198.01,34.75 192.77,29.5 192.77,28.2 187.15,22.59 181.73,22.59 181.73,22.59 176.28,22.59 171.34,27.53 171.34,28.24 169.18,30.41 166.94,30.41 163.59,33.76 163.59,38.47 163.7,38.58 163.7,39.28 164.06,39.64 v3(164.19,39.64)
  BOTTOM w0.102: 220.91,47.9 220.71,47.7 UH1.AD45
  BOTTOM w0.127: v3(221.44,49.89) 221.06,49.51 221.06,49.23 220.91,49.08 220.91,47.9 ; v3(164.19,39.64) 164.05,39.64 163.85,39.44 163.85,39.28 163.65,39.07 163.65,38.97 163.93,38.69 LM2.1 163.93,38.17 RM39.1
CLK_PCIE_WLAN#: length 89.7
  IN1 w0.099: v3(163.48,39.64) 163.48,38.67 163.37,38.56 163.37,33.67 166.85,30.19 169.09,30.19 171.13,28.16 171.13,27.45 176.2,22.38 181.81,22.38 181.82,22.38 187.24,22.38 192.98,28.12 192.98,29.42 198.22,34.66 198.22,36.47 199.05,37.29 199.05,41.51 203.79,46.25 203.8,46.25 203.95,46.4 203.95,46.52 207.17,49.75 220.44,49.75 220.85,49.34 221.38,49.34 v3(221.48,49.24)
  BOTTOM w0.089: 220.97,47.56 220.66,47.25 UH1.AD43
  BOTTOM w0.102: 220.97,47.56 221.18,47.78 221.18,48.14 221.2,48.15 221.2,48.16
  BOTTOM w0.127: RM40.1 163.13,38.17 LM2.4 163.13,38.72 163.36,38.96 163.36,39.19 163.57,39.4 163.57,39.56 v3(163.48,39.64) ; 221.2,48.16 221.2,48.96 v3(221.48,49.24)
CLK_PCIE_WLAN#_R: length 15.2
  BOTTOM w0.127: JWLAN1.41 165.15,24.03 164.89,24.3 164.89,26.63 164.03,27.49 v4(164.03,34.18) 164.03,34.72 163.13,35.62 LM2.3 163.13,37.04 RM40.2
CLK_PCIE_WLAN_R: length 15.2
  BOTTOM w0.127: RM39.2 163.93,37.04 LM2.2 163.93,36.22 163.81,36.1 163.51,36.1 163.41,36 163.41,35.74 164.31,34.84 v4(164.31,29.26) 164.31,27.61 165.17,26.75 165.17,24.42 165.27,24.32 165.43,24.32 165.64,24.53 JWLAN1.39
CLK_PEG_GPU: length 91.2
  IN6 w0.099: v3(221.85,43.65) 221.64,43.45 221.34,43.45 221.25,43.54 221.25,45.61 221.6,45.96 221.6,47.02 220.93,47.69 220.93,55.89 219.15,57.67 210.88,57.67 208.74,55.54 202.08,55.54 199.73,57.88 198.77,57.88 196.13,60.53 189.21,60.53 186.88,62.85 184.99,62.85 182.4,65.44 181.17,65.44 178.08,68.54 177.26,68.54 176.11,69.69 174.64,69.69 174.07,70.26 174.07,71.17 170.96,74.28 169.43,74.28 167.76,75.95 167.11,75.95 166.25,76.81 166.25,80.2 166.77,80.73 167.69,80.73 168.22,81.26 168.22,82.53 167.53,83.23 165.76,83.23 165.36,82.82 165.36,82.53 165.21,82.38 v3(165.2,82.38)
  BOTTOM w0.089: UH1.AB36 221.69,43.65 v3(221.85,43.65)
  BOTTOM w0.101: UV1.BD20 v3(165.2,82.38)
CLK_PEG_GPU#: length 91.4
  IN6 w0.099: v3(221.85,43.04) 221.65,43.24 221.25,43.24 221.04,43.45 221.04,45.7 221.39,46.05 221.39,46.94 220.72,47.6 220.72,55.8 219.06,57.46 210.97,57.46 208.83,55.33 201.99,55.33 199.65,57.67 198.69,57.67 196.05,60.31 189.12,60.31 186.8,62.64 184.9,62.64 182.31,65.23 181.09,65.23 177.99,68.33 177.17,68.33 176.03,69.48 174.55,69.48 173.86,70.17 173.86,71.08 170.87,74.07 169.34,74.07 167.67,75.74 167.02,75.74 166.03,76.72 166.03,80.29 166.68,80.94 167.6,80.94 168.01,81.35 168.01,82.44 167.44,83.02 165.85,83.02 165.57,82.73 165.57,82.43 165.67,82.32 165.95,82.32 v3(166,82.38)
  BOTTOM w0.089: UH1.AB35 221.51,43.38 v3(221.85,43.04)
  BOTTOM w0.101: v3(166,82.38) 165.68,82.38 165.6,82.45 UV1.BC20
CLK_REQ#: length 33.2
  IN6 w0.099: v3(166.8,82.38) 165.34,80.91 157.3,80.91 154.59,83.63 148.64,83.63 v3(148.17,84.1)
  BOTTOM w0.1: UV1.BB20 v3(166.8,82.38)
  BOTTOM w0.127: QV12.3 143.59,75.99 RV62.1 145.75,75.99 v1(146.03,76.27) 146.52,76.76 146.52,81.54 148.17,83.19 v3(148.17,84.1)
CLK_SMB: length 7.1
  TOP w0.127: v2(68.37,30.56) 69.03,29.9 PR19.1
  TOP w0.254: v3(70.27,29.75) 69.75,29.75 PR19.1
  BOTTOM w0.254: v3(70.27,29.75) 70.27,29.47 69.59,28.78 66.8,28.78 66.8,28.78 PBATT1.5
CLKREQ#_DGPU: length 199.2
  TOP w0.127: v3(280.29,29.34) 280.81,28.82 280.81,28.65 281.2,28.27 UE5.19 ; v3(223.08,28.05) 223.29,28.05 223.7,27.64 223.7,26.17 222.63,25.11 RH76.1 ; v3(270.28,36.79) 270.85,36.79 v1(270.94,36.88)
  IN2 w0.099: v3(280.29,29.34) 280.11,29.52 280.11,36.46 279.49,37.09 270.58,37.09 v3(270.28,36.79) 269.79,37.29 265.82,37.29 261.72,33.19 257.88,33.19 257.01,34.05 246.56,34.05 243.54,31.03 v3(242.08,31.03)
  IN4 w0.089: 225.69,27.65 225.47,27.88 224.68,27.88 224.45,27.65 ; v3(223.08,28.05) 223.47,27.65
  IN4 w0.091: 224.45,27.65 224.35,27.55 223.57,27.55 223.47,27.65 ; v3(242.08,31.03) 242.08,30.62 239.63,28.17 239.63,27.69 239.37,27.44 237.89,27.44 237.37,26.91 234.8,26.91 233.69,28.03 231.93,28.03 231.19,27.28 226.06,27.28 225.69,27.65 ; v3(223.85,118.58) 225.01,117.43 225.01,113.65 225.54,113.12 225.54,107.15 229.69,103.01 233.65,103.01 235.41,101.25 235.41,68.25 234.48,67.32 234.48,61.62 233.15,60.29 233.15,57.56 237,53.71 242.79,53.71 251.95,44.55 253.86,44.55 256.64,41.76 257.52,41.76 258.24,41.04 260.22,41.04 263.9,37.35 269.72,37.35 v3(270.28,36.79)
  BOTTOM w0.089: v3(223.08,28.05) 223.43,28.4 223.43,29.21 223.22,29.42 223.22,29.66 223.51,29.94 UH1.U4
  BOTTOM w0.127: UM4.17 222.99,119.45 v3(223.85,118.58)
CLKREQ#_GPU: length 141
  TOP w0.089: v3(219.32,31.24) 219.05,31.51 218.14,31.51 217.95,31.33 217.95,30.88 218.3,30.53 218.3,30.23
  TOP w0.127: v2(140.57,57.99) v3(140.57,58.66) ; 218.3,30.23 217.56,29.49 216.89,29.49 216.09,28.69 216.09,25.74 RH74.1
  IN2 w0.099: v3(139.64,75.31) 137,75.31 136.65,74.97 136.65,68.12 140.32,64.45 140.32,58.9 v3(140.57,58.66)
  IN6 w0.099: v3(219.32,31.24) 219.04,31.52 217.83,31.52 217.68,31.37 217.15,31.37 216.52,30.75 215.93,30.75 214.84,29.66 210.42,29.66 210.17,29.42 207.63,29.42 207.05,28.83 203.99,28.83 201.97,30.85 197.61,30.85 189.11,22.35 180.38,22.35 179.96,21.93 176.92,21.93 176.5,22.35 172.87,22.35 172.18,23.04 170.63,23.04 168.45,25.21 168.45,27.42 165.64,30.24 165.64,32.07 160.99,36.71 160.99,40.56 160.47,41.09 160.47,43 156.68,46.79 155.93,46.79 152.07,50.65 149.4,50.65 141.92,58.13 141.1,58.13 v3(140.57,58.66)
  BOTTOM w0.089: UH1.AF6 219.55,31.01 v3(219.32,31.24)
  BOTTOM w0.127: v3(139.64,75.31) 140.1,75.77 RV531.2 140.1,76.71 QV12.1
CMSRC_CHG: length 6.7
  TOP w0.203: PU700.3 39.9,37.79 v3(39.75,37.94)
  TOP w0.254: v3(37.4,40.15) 37,40.15 PR706.2
  IN1 w0.254: v3(39.75,37.94) 38.27,39.42 37.82,39.42 37.4,39.84 v3(37.4,40.15)
  BOTTOM w0.127: v3(39.75,37.94) v1(40.87,37.94)
COMP: length 8.8
  BOTTOM w0.254: 141,127.42 142.33,127.42 v1(142.51,127.6) 145.87,127.6 147.22,126.25 PC525.2 146.36,125.22 PR539.2
CPU_B+: length 16.6
  IN6 w0.254: v3(123.5,124.36) 123.5,121.01 125.69,118.82 v3(135.15,118.82)
  BOTTOM w0.254: PR526.2 135.5,119.17 v3(135.15,118.82)
  vias: v2(112.1,132.32) v3(105.97,124.42) v3(106.56,125.88) v3(106.61,124.42) v3(114.33,124.36) v3(114.68,127.54) v3(114.98,125.97) v3(114.97,124.36) v3(115.32,127.54) v3(122.86,124.36) v3(123.26,127.54) v3(123.48,125.97) v3(123.89,127.54)
CPU_DPB_CTRLCLK_R: length 22.3
  TOP w0.127: UV4.32 113.09,137.9 113.17,137.98 113.29,137.98 v3(113.5,137.78)
  IN4 w0.091: v3(113.5,137.78) 113.66,137.94 114.59,137.94 115.91,136.61 126.71,136.61 127.32,137.23 127.32,137.95 127.57,138.2 128.4,138.2 128.72,138.52 128.72,139.32 128.27,139.77 127.11,139.77 JHDMI1.15
  BOTTOM w0.127: RV31.1 113.13,137.78 v3(113.5,137.78)
CPU_DPB_CTRLDAT_R: length 18.2
  TOP w0.127: UV4.33 113.07,138.3 113.15,138.21 113.35,138.21 v3(113.5,138.36)
  IN4 w0.091: JHDMI1.16 127.38,138.79 127.38,138.37 127.1,138.08 127.1,137.32 126.62,136.83 116,136.83 114.68,138.16 113.71,138.16 v3(113.5,138.36)
  BOTTOM w0.127: v3(113.5,138.36) 113.49,138.36 RV32.1
CPU_EDP_AUX: length 61.5
  IN1 w0.099: v3(97.07,132.4) 97.07,132.13 97.22,131.98 97.22,131.63 92.73,127.14 92.73,105.8 94.66,103.87 113.9,103.87 114.69,103.08 118.38,103.08 119.2,102.25 119.2,100.31 119.51,100 119.51,99.28 v3(119.83,98.95)
  BOTTOM w0.089: v3(119.83,98.95) 119.45,98.57 CPU1.F14
  BOTTOM w0.127: CV12.2 97.26,132.03 97.07,132.22 v3(97.07,132.4)
CPU_EDP_AUX#: length 61.4
  IN1 w0.099: v3(96.66,131.99) 96.96,131.99 97.04,131.91 97.04,131.71 92.55,127.21 92.55,105.73 94.59,103.69 113.83,103.69 114.62,102.9 118.3,102.9 119.02,102.18 119.02,100.24 119.33,99.93 119.33,99.27 v3(119.01,98.95)
  BOTTOM w0.089: CPU1.F15 118.63,98.57 v3(119.01,98.95)
  BOTTOM w0.127: v3(96.66,131.99) 96.96,131.99 97.03,131.92 CV13.2
CPU_EDP_HPD: length 48.4
  TOP w0.254: v3(96.24,131.5) 96.84,131.5 97.95,130.39
  TOP w0.508: RC35.1 116.77,109.88 v3(116.77,110.3) 117.76,110.3 118.3,110.84 QC1.2
  IN2 w0.508: v3(94.05,117.76) 94.05,115.22 98.87,110.39 109.54,110.39 111.13,108.8 114.87,108.8 116.37,110.3 v3(116.77,110.3)
  IN6 w0.508: v3(96.24,131.5) 96.24,130.3 95.32,129.38 95.32,119.03 v3(94.05,117.76)
CPU_EDP_TX0N: length 62.6
  IN1 w0.099: v3(101.91,137.19) 102.37,137.19 102.53,137.04 102.53,133.02 103.43,132.12 103.43,130.81 98.12,125.5 98.12,124.61 97.65,124.15 97.65,113.93 101.25,110.33 111.7,110.33 112.92,109.11 120.09,109.11 121.41,107.79 121.41,103.28 121.33,103.19 121.33,102.45 120.28,101.41 120.28,100.77 120.2,100.7 120.06,100.7 119.83,100.92 v3(119.83,101.05)
  BOTTOM w0.089: CPU1.C14 119.45,100.67 v3(119.83,101.05)
  BOTTOM w0.127: v3(101.91,137.19) 101.95,137.24 102.15,137.24 102.23,137.15 CV2.2
CPU_EDP_TX0P: length 62.6
  IN1 w0.099: v3(119.83,100.35) 120,100.51 120.28,100.51 120.46,100.7 120.46,101.34 121.51,102.38 121.51,103.12 121.59,103.2 121.59,107.86 120.17,109.29 112.99,109.29 111.77,110.51 101.33,110.51 97.84,114 97.84,124.07 98.3,124.54 98.3,125.43 103.61,130.74 103.61,132.2 102.71,133.1 102.71,137.11 102.35,137.47 v3(102.35,137.6)
  BOTTOM w0.089: CPU1.D14 119.45,99.97 v3(119.83,100.35)
  BOTTOM w0.127: v3(102.35,137.6) 102.35,137.38 102.54,137.19 CV1.2
CPU_EDP_TX1N: length 62.6
  IN1 w0.099: v3(100.57,135.88) 101.04,135.88 101.21,135.71 101.21,131.95 101.37,131.79 101.37,129.69 97.42,125.74 97.42,125.01 96.96,124.54 96.96,112.21 99.62,109.55 99.62,109.16 100.36,108.43 114.12,108.43 114.22,108.33 114.22,107.07 114.46,106.82 114.87,106.82 115.11,107.07 115.11,108.33 115.21,108.43 115.51,108.43 115.61,108.33 115.61,106.86 115.82,106.64 120.19,106.64 120.64,106.19 120.64,102.54 120.23,102.13 119.96,102.13 119.83,102.26 v3(119.83,102.49)
  BOTTOM w0.089: v3(119.83,102.49) 120.23,102.09 CPU1.A12
  BOTTOM w0.127: v3(100.57,135.88) 100.81,135.88 100.89,135.79 CV4.2
CPU_EDP_TX1P: length 62.7
  IN1 w0.099: v3(119.83,101.75) 120.03,101.94 120.31,101.94 120.83,102.46 120.83,106.26 120.26,106.82 115.9,106.82 115.79,106.94 115.79,108.41 115.58,108.61 115.14,108.61 114.93,108.41 114.93,107.14 114.79,107 114.54,107 114.4,107.14 114.4,108.41 114.19,108.61 100.43,108.61 99.8,109.24 99.8,109.62 97.14,112.29 97.14,124.47 97.6,124.93 97.6,125.67 101.55,129.62 101.55,131.87 101.39,132.03 101.39,135.78 100.98,136.19 v3(100.98,136.29)
  BOTTOM w0.089: v3(119.83,101.75) 119.88,101.75 120.23,101.4 CPU1.B12
  BOTTOM w0.127: 101.57,135.92 101.11,135.92 100.98,136.05 v3(100.98,136.29)
CPU_EDP_TX2N: length 60.5
  IN1 w0.099: v3(99.25,134.58) 99.54,134.58 99.75,134.37 99.75,132.29 95.39,127.93 95.39,112.64 97.4,110.62 97.4,107.45 98.21,106.64 110.46,106.64 111.35,105.75 119.44,105.75 119.75,105.45 119.75,104.97 v3(119.45,104.67)
  BOTTOM w0.089: CPU1.C12 120.23,100.38 120.32,100.29 120.41,100.29 120.54,100.42 120.54,101.94 120.54,101.94 120.54,102.79 120.35,102.98
  BOTTOM w0.127: 120.35,102.98 119.65,103.69 119.65,104.48 v3(119.45,104.67) ; CV6.2 99.63,134.46 99.51,134.58 v3(99.25,134.58)
CPU_EDP_TX2P: length 60.6
  IN1 w0.099: v3(120.04,104.67) 119.93,104.78 119.93,105.52 119.52,105.94 111.43,105.94 110.54,106.82 98.28,106.82 97.58,107.52 97.58,110.7 95.57,112.71 95.57,127.85 99.93,132.21 99.93,134.45 99.67,134.71 v3(99.67,135)
  BOTTOM w0.089: CPU1.D12 120.35,100.1 120.49,100.1 120.73,100.34 120.73,102.95 120.53,103.15
  BOTTOM w0.127: CV8.2 99.81,134.62 99.67,134.77 v3(99.67,135) ; 120.53,103.15 119.89,103.79 119.89,104.53 v3(120.04,104.67)
CPU_EDP_TX3N: length 60.8
  IN1 w0.099: v3(118.61,104.67) 118.53,104.59 118.53,104.14 118.18,103.79 116.14,103.79 115.56,104.37 96.26,104.37 95.83,104.79 95.83,110.51 94.63,111.71 94.63,116.24 94.68,116.29 94.68,128.38 98.56,132.27 98.56,132.74 98,133.3 v3(97.97,133.3)
  BOTTOM w0.089: 119.05,102.88 119.05,102.87 119.05,102.84 119.1,102.8 119.1,102.77 119.12,102.75 119.12,102.38 119.11,102.37 119.11,101.78 119.19,101.69 119.33,101.69 119.42,101.78 CPU1.A14
  BOTTOM w0.127: CV11.2 98.33,133.22 98.25,133.3 v3(97.97,133.3) ; v3(118.61,104.67) 118.49,104.55 118.49,104.51 118.5,104.5 118.5,104.08 118.23,103.81 117.92,103.81 117.79,103.69 117.79,103.27 117.92,103.14 118.78,103.14 119.05,102.88
CPU_EDP_TX3P: length 60.7
  IN1 w0.099: v3(98.4,133.69) 98.38,133.67 98.38,133.18 98.74,132.81 98.74,132.19 94.86,128.31 94.86,116.22 94.81,116.17 94.81,111.79 96.01,110.58 96.01,104.87 96.33,104.55 115.64,104.55 116.22,103.97 118.1,103.97 118.35,104.22 118.35,104.35 118.21,104.5 118.21,104.56 118.1,104.67 v3(118.03,104.67)
  BOTTOM w0.089: 118.87,102.71 118.91,102.67 118.91,101.69 119.11,101.5 119.33,101.5 119.42,101.41 CPU1.B14
  BOTTOM w0.127: v3(98.4,133.69) 98.4,133.49 98.56,133.34 CV7.2 ; 118.87,102.71 118.68,102.9 117.82,102.9 117.55,103.17 117.55,103.79 117.82,104.06 118.13,104.06 118.26,104.18 118.26,104.4 118.25,104.41 118.25,104.45 v3(118.03,104.67)
CPU_FAN_FB: length 275.5
  TOP w0.127: UE5.28 277.6,25.77 278.51,24.86 v3(278.51,23.52) ; v3(66.8,56.5) 66.98,56.5 69.55,53.94 73.05,53.94 74.3,52.69 74.3,36.4 v2(72.06,34.17) 70.27,32.37 69.43,32.37 67.95,30.89 67.95,22.73 71.34,19.34 72.57,19.34 v3(73.09,18.82)
  IN1 w0.099: v3(67.73,59.87) 66.8,58.94 v3(66.8,56.5)
  IN2 w0.099: v3(73.09,18.82) 73.51,18.4 146.76,18.4 150.85,14.3 155.26,14.3 156.96,12.6 169.38,12.6 169.52,12.74 177.07,12.74 177.47,13.15 193.02,13.15 194.13,14.26 206.9,14.26 209.08,12.09 216.23,12.09 217.69,10.63 220.89,10.63 221.8,11.54 226.79,11.54 227.42,12.17 230.5,12.17 234.41,16.09 239.79,16.09 240.56,15.32 241.69,15.32 242.39,14.62 252.54,14.62 252.6,14.68 257.56,14.68 261.54,18.66 266.72,18.66 268.25,20.19 273.79,20.19 275.68,22.07 277.07,22.07 v3(278.51,23.52)
  BOTTOM w0.127: RF1.1 v3(67.73,59.87) 67.53,60.07 DF1.2
CPU_FAN_PWM: length 284.6
  TOP w0.127: v3(72.11,18.87) 71.45,18.87 67.69,22.63 67.69,31 69.64,32.94 v2(70.25,32.94) 73.9,36.6 73.9,52.49 72.91,53.48 69.42,53.48 67.06,55.84 v3(66.3,55.84) ; UE5.26 278.4,25.75 279.1,25.05 279.1,24.11 v3(279.68,23.52)
  IN2 w0.099: v3(72.11,18.87) 72.84,18.15 146.67,18.15 150.75,14.07 155.14,14.07 156.86,12.35 171.52,12.35 171.64,12.47 177.28,12.47 177.62,12.81 193.08,12.81 194.28,14.02 206.66,14.02 210.34,10.34 220.92,10.34 221.89,11.31 226.89,11.31 227.49,11.92 230.6,11.92 234.54,15.86 239.38,15.86 240.14,15.1 241.6,15.1 242.39,14.3 252.54,14.3 252.69,14.45 257.69,14.45 261.66,18.43 266.85,18.43 268.38,19.96 274.27,19.96 276.14,21.84 277.99,21.84 v3(279.68,23.52)
  BOTTOM w0.127: RF2.1 66.36,57.2 66.36,55.91 v3(66.3,55.84) 66.3,54.27 66.69,53.88 66.69,53.14 65.06,51.51 61.65,51.51 JFAN1.2
CPU_HDMI_N0: length 77.6
  TOP w0.127: v3(109.51,145.66) 109.51,145.62 109.79,145.34 109.79,144.85 109.67,144.72 CV43.2
  IN1 w0.099: v3(109.51,145.66) 109.92,145.26 109.92,145.02 109.28,144.39 108.14,144.39 105.81,142.05 105.81,141.3 103.15,138.65 102.05,138.65 101.39,137.99 100.64,137.99 91.87,129.22 91.87,105.13 93.97,103.03 113.48,103.03 113.84,102.67 113.84,100.9 113.59,100.65 113.59,100.38 113.5,100.29 v3(113.29,100.29)
  BOTTOM w0.089: v3(113.29,100.29) 113.29,100.3 CPU1.C24
CPU_HDMI_N1: length 83.1
  TOP w0.127: v3(111.28,146.5) 111.49,146.29 111.49,145.9 CV41.2
  IN1 w0.099: v3(111.28,146.5) 111.05,146.27 110.54,146.27 109.84,146.97 107.09,146.97 106.22,146.1 106.22,145.25 103.34,142.37 103.34,141.12 102.76,140.54 101.09,140.54 89.9,129.35 89.9,113.93 89.1,113.13 89.1,105.31 94.62,99.79 95.35,99.79 96.03,100.47 111.21,100.47 111.55,100.8 111.96,100.8 112.29,101.13 112.29,101.5 v3(112.49,101.7)
  BOTTOM w0.089: v3(112.49,101.7) 112.47,101.7 CPU1.A25
