# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
I-PEX_20455-040E-12_40P
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.397x1.905 smd: 41(-3.1,-2.82) 42(22.6,-2.82)
  rect 0.559x0.889 smd: 43(20.4,0) 44(-0.9,0)
INA3221AIRGVR_VQFN16_4X4
  oval 0.457x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 9(1.95,3.95) 10(1.3,3.95) 11(0.65,3.95) 12(0,3.95)
  oval 1.041x0.457 smd: 5(2.95,1) 6(2.95,1.65) 7(2.95,2.3) 8(2.95,2.95) 13(-1,2.95) 14(-1,2.3) 15(-1,1.65) 16(-1,1)
  rect 2.108x2.108 smd: 17(0.975,1.975)
ISL6208BCRZ-T_QFN8_2X2
  oval 0.254x0.914 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.075) 6(1,2.075) 7(0.5,2.075) 8(0,2.075)
  rect 1.549x0.889 smd: 9(0.75,1.038)
ISL54405IRUZ-T_UTQFN16_2P6X1P8
  oval 0.203x0.991 smd: 1(0,0)
  oval 0.203x0.889 smd: 2(0.4,-0.051) 3(0.8,-0.051) 4(1.2,-0.051) 9(1.2,1.849) 10(0.8,1.849) 11(0.4,1.849) 12(0,1.849)
  oval 0.889x0.203 smd: 5(1.95,0.299) 6(1.95,0.699) 7(1.95,1.099) 8(1.95,1.499) 13(-0.75,1.499) 14(-0.75,1.099) 15(-0.75,0.699) 16(-0.75,0.299)
ISL95812HRZ-T_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.642x2.642 smd: 33(1.4,2.039)
JESSL_TNBNRAC70013009_9P-T
  round 1.295 hole 0.787: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x3.2 hole 0.711x2.591: 10(4.5,-4.08) 11(-11.5,-4.08)
  oval 1.295x2.794 hole 0.711x2.21: 12(-11.5,-9.73) 13(4.5,-9.73)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KB9012QF-A2_LQFP128_14X14
  oval 0.203x1.753 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 21(8,0) 22(8.4,0) 23(8.8,0) 24(9.2,0) 25(9.6,0) 26(10,0) 27(10.4,0) 28(10.8,0) 29(11.2,0) 30(11.6,0) 31(12,0) 32(12.4,0) 65(12.4,15.654) 66(12,15.654) 67(11.6,15.654) 68(11.2,15.654) 69(10.8,15.654) 70(10.4,15.654) 71(10,15.654) 72(9.6,15.654) 73(9.2,15.654) 74(8.8,15.654) 75(8.4,15.654) 76(8,15.654) 77(7.6,15.654) 78(7.2,15.654) 79(6.8,15.654) 80(6.4,15.654) 81(6,15.654) 82(5.6,15.654) 83(5.2,15.654) 84(4.8,15.654) 85(4.4,15.654) 86(4,15.654) 87(3.6,15.654) 88(3.2,15.654) 89(2.8,15.654) 90(2.4,15.654) 91(2,15.654) 92(1.6,15.654) 93(1.2,15.654) 94(0.8,15.654) 95(0.4,15.654) 96(0,15.654)
  oval 1.753x0.203 smd: 33(14.027,1.627) 34(14.027,2.027) 35(14.027,2.427) 36(14.027,2.827) 37(14.027,3.227) 38(14.027,3.627) 39(14.027,4.027) 40(14.027,4.427) 41(14.027,4.827) 42(14.027,5.227) 43(14.027,5.627) 44(14.027,6.027) 45(14.027,6.427) 46(14.027,6.827) 47(14.027,7.227) 48(14.027,7.627) 49(14.027,8.027) 50(14.027,8.427) 51(14.027,8.827) 52(14.027,9.227) 53(14.027,9.627) 54(14.027,10.027) 55(14.027,10.427) 56(14.027,10.827) 57(14.027,11.227) 58(14.027,11.627) 59(14.027,12.027) 60(14.027,12.427) 61(14.027,12.827) 62(14.027,13.227) 63(14.027,13.627) 64(14.027,14.027) 97(-1.627,14.027) 98(-1.627,13.627) 99(-1.627,13.227) 100(-1.627,12.827) 101(-1.627,12.427) 102(-1.627,12.027) 103(-1.627,11.627) 104(-1.627,11.227) 105(-1.627,10.827) 106(-1.627,10.427) 107(-1.627,10.027) 108(-1.627,9.627) 109(-1.627,9.227) 110(-1.627,8.827) 111(-1.627,8.427) 112(-1.627,8.027) 113(-1.627,7.627) 114(-1.627,7.227) 115(-1.627,6.827) 116(-1.627,6.427) 117(-1.627,6.027) 118(-1.627,5.627) 119(-1.627,5.227) 120(-1.627,4.827) 121(-1.627,4.427) 122(-1.627,4.027) 123(-1.627,3.627) 124(-1.627,3.227) 125(-1.627,2.827) 126(-1.627,2.427) 127(-1.627,2.027) 128(-1.627,1.627)
KC3810_QFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.438x2.438 smd: 25(1.25,1.975)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-201209-221LMA30_2P
  rect 0.838x1.397 smd: 1(0,0) 2(1.65,0)
KC_WCM-2012HS-900T_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,-0.8) 4(0,-0.8)
L03ESDL5V0CG3-2_SOT-523-3
  oval 0.406x0.787 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_10X10X4_M_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
L_1812-1806
  oval 1.016x3.708 smd: 1(0,0) 2(4.013,0)
LBSS138LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LL4148_LL34-2
  oval 0.889x1.803 smd: 1(0,0) 2(3.5,0)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.96) 10(1.5,2.96) 11(1,2.96) 12(0.5,2.96) 13(0,2.96)
  oval 0.864x0.305 smd: 6(2.48,0.98) 7(2.48,1.48) 8(2.48,1.98) 14(-0.48,1.98) 15(-0.48,1.48) 16(-0.48,0.98)
LOTES_APCI0019-P009A_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
LYNXPOINT_BGA_695P-T
  round 0.356 smd: A2(0.624,0) A4(1.217,0) A5(1.81,0) A41(16.915,0) A43(17.508,0) A44(18.101,0) B1(0,-0.624) B2(0.603,-0.603) B44(18.022,-0.603) B45(18.625,-0.524) BA1(0,-16.915) BA45(18.625,-16.915) BC1(0,-17.508) BC45(18.625,-17.508) BD1(0,-18.101) BD2(0.603,-18.022) BD44(18.022,-18.022) BD45(18.625,-18.101) BE2(0.524,-18.625) BE3(1.117,-18.625) BE5(1.71,-18.625) BE41(16.915,-18.625) BE43(17.508,-18.625) BE44(18.101,-18.625) C45(18.625,-1.117) D1(0,-1.217) E1(0,-1.81) E45(18.625,-1.71)
  round 0.33 smd: A6(2.483,0) A40(16.242,0) AY1(0,-16.242) AY45(18.625,-16.242) B4(1.315,-0.586) B42(17.233,-0.637) BA2(0.551,-16.664) BB2(0.563,-17.31) BB44(17.988,-17.233) BD4(1.391,-17.988) BD41(16.664,-18.074) BD42(17.31,-18.061) BE6(2.383,-18.625) BE40(16.242,-18.625) D2(0.637,-1.391) D44(18.061,-1.315) E44(18.074,-1.96) F1(0,-2.483) F45(18.625,-2.383)
  round 0.305 smd: A8(3.216,0) A10(4.029,0) A12(4.842,0) A14(5.655,0) A16(6.468,0) A18(7.28,0) A20(8.093,0) A22(8.906,0) A24(9.719,0) A26(10.532,0) A28(11.344,0) A30(12.157,0) A32(12.97,0) A34(13.783,0) A36(14.596,0) A38(15.408,0) AA2(0.452,-8.478) AA4(1.336,-8.5) AA14(5.515,-8.827) AA16(6.328,-8.827) AA18(7.141,-8.827) AA20(7.954,-8.827) AA22(8.766,-8.827) AA24(9.579,-8.827) AA26(10.392,-8.827) AA28(11.205,-8.827) AA30(12.018,-8.827) AA32(12.83,-8.827) AA42(17.289,-8.5) AA44(18.173,-8.521) AB1(0,-8.906) AB3(0.904,-8.906) AB6(1.934,-9.008) AB7(2.531,-9.008) AB8(3.128,-9.008) AB10(3.724,-9.008) AB11(4.321,-9.008) AB12(4.918,-9.008) AB34(13.707,-9.008) AB35(14.304,-9.008) AB36(14.9,-9.008) AB38(15.497,-9.008) AB39(16.094,-9.008) AB40(16.691,-9.008) AB43(17.721,-8.906) AB45(18.625,-8.906) AC2(0.472,-9.312) AC44(18.152,-9.312) AD1(0,-9.719) AD3(0.904,-9.719) AD6(1.934,-9.617) AD7(2.531,-9.617) AD8(3.128,-9.617) AD10(3.724,-9.617) AD11(4.321,-9.617) AD12(4.918,-9.617) AD14(5.515,-9.488) AD16(6.328,-9.488) AD18(7.141,-9.488) AD20(7.954,-9.488) AD22(8.766,-9.488) AD24(9.579,-9.488) AD26(10.392,-9.488) AD28(11.205,-9.488) AD30(12.018,-9.488) AD32(12.83,-9.488) AD34(13.707,-9.617) AD35(14.304,-9.617) AD36(14.9,-9.617) AD38(15.497,-9.617) AD39(16.094,-9.617) AD40(16.691,-9.617) AD43(17.721,-9.719) AD45(18.625,-9.719) AE2(0.452,-10.103) AE4(1.336,-10.125) AE14(5.515,-10.148) AE16(6.328,-10.148) AE18(7.141,-10.148) AE20(7.954,-10.148) AE22(8.766,-10.148) AE24(9.579,-10.148) AE26(10.392,-10.148) AE28(11.205,-10.148) AE30(12.018,-10.148) AE32(12.83,-10.148) AE42(17.289,-10.125) AE44(18.173,-10.147) AF1(0,-10.532) AF3(0.904,-10.532) AF6(1.934,-10.595) AF7(2.531,-10.595) AF8(3.128,-10.595) AF10(3.724,-10.595) AF11(4.321,-10.595) AF12(4.918,-10.595) AF34(13.707,-10.595) AF35(14.304,-10.595) AF36(14.9,-10.595) AF38(15.497,-10.595) AF39(16.094,-10.595) AF40(16.691,-10.595) AF43(17.721,-10.532) AF45(18.625,-10.532) AG2(0.472,-10.938) AG14(5.515,-10.808) AG16(6.328,-10.808) AG18(7.141,-10.808) AG20(7.954,-10.808) AG22(8.766,-10.808) AG24(9.579,-10.808) AG26(10.392,-10.808) AG28(11.205,-10.808) AG30(12.018,-10.808) AG32(12.83,-10.808) AG44(18.152,-10.938) AH1(0,-11.344) AH3(0.904,-11.344) AH43(17.721,-11.344) AH45(18.625,-11.344) AJ2(0.452,-11.729) AJ4(1.336,-11.751) AJ6(1.934,-11.573) AJ7(2.531,-11.573) AJ8(3.128,-11.573) AJ10(3.724,-11.573) AJ11(4.321,-11.573) AJ12(4.918,-11.573) AJ14(5.515,-11.469) AJ16(6.328,-11.469) AJ18(7.141,-11.469) AJ20(7.954,-11.469) AJ22(8.766,-11.469) AJ24(9.579,-11.469) AJ26(10.392,-11.469) AJ28(11.205,-11.469) AJ30(12.018,-11.469) AJ32(12.83,-11.469) AJ34(13.707,-11.573) AJ35(14.304,-11.573) AJ36(14.9,-11.573) AJ38(15.497,-11.573) AJ39(16.094,-11.573) AJ40(16.691,-11.573) AJ42(17.289,-11.751) AJ44(18.173,-11.773) AK1(0,-12.157) AK3(0.904,-12.157) AK14(5.515,-12.129) AK16(6.328,-12.129) AK18(7.141,-12.129) AK20(7.954,-12.129) AK22(8.766,-12.129) AK24(9.579,-12.129) AK26(10.392,-12.129) AK28(11.205,-12.129) AK30(12.018,-12.129) AK32(12.83,-12.129) AK43(17.721,-12.157) AK45(18.625,-12.157) AL2(0.472,-12.564) AL6(1.934,-12.551) AL7(2.531,-12.551) AL8(3.128,-12.551) AL10(3.724,-12.551) AL11(4.321,-12.551) AL12(4.918,-12.551) AL34(13.707,-12.551) AL35(14.304,-12.551) AL36(14.9,-12.551) AL38(15.497,-12.551) AL39(16.094,-12.551) AL40(16.691,-12.551) AL44(18.152,-12.564) AM1(0,-12.97) AM3(0.904,-12.97) AM14(5.515,-12.79) AM16(6.328,-12.79) AM18(7.141,-12.79) AM20(7.954,-12.79) AM22(8.766,-12.79) AM24(9.579,-12.79) AM26(10.392,-12.79) AM28(11.205,-12.79) AM30(12.018,-12.79) AM32(12.83,-12.79) AM43(17.721,-12.97) AM45(18.625,-12.97) AN2(0.452,-13.355) AN4(1.336,-13.376) AN6(1.934,-13.529) AN7(2.531,-13.529) AN8(3.128,-13.529) AN10(3.724,-13.529) AN11(4.321,-13.529) AN34(13.656,-13.529) AN35(14.304,-13.529) AN36(14.9,-13.529) AN38(15.497,-13.529) AN39(16.094,-13.529) AN40(16.691,-13.529) AN42(17.289,-13.376) AN44(18.173,-13.398) AP1(0,-13.783) AP3(0.904,-13.783) AP13(5.096,-13.656) AP15(6.074,-13.707) AP17(7.052,-13.707) AP20(8.03,-13.707) AP22(9.008,-13.707) AP24(9.617,-13.707) AP26(10.595,-13.707) AP29(11.573,-13.707) AP31(12.551,-13.707) AP43(17.721,-13.783) AP45(18.625,-13.783) AR2(0.472,-14.189) AR13(5.096,-14.304) AR15(6.074,-14.304) AR17(7.052,-14.304) AR20(8.03,-14.304) AR22(9.008,-14.304) AR24(9.617,-14.304) AR26(10.595,-14.304) AR29(11.573,-14.304) AR31(12.551,-14.304) AR33(13.529,-14.304) AR44(18.152,-14.189) AT1(0,-14.596) AT3(0.904,-14.596) AT6(1.934,-14.507) AT7(2.531,-14.507) AT8(3.128,-14.507) AT10(4.118,-14.9) AT13(5.096,-14.9) AT15(6.074,-14.9) AT17(7.052,-14.9) AT20(8.03,-14.9) AT22(9.008,-14.9) AT24(9.617,-14.9) AT26(10.595,-14.9) AT29(11.573,-14.9) AT31(12.551,-14.9) AT33(13.529,-14.9) AT36(14.9,-14.507) AT38(15.497,-14.507) AT39(16.094,-14.507) AT40(16.691,-14.507) AT43(17.721,-14.596) AT45(18.625,-14.596) AU2(0.452,-14.98) AU4(1.336,-15.002) AU42(17.289,-15.002) AU44(18.173,-15.024) AV1(0,-15.408) AV3(0.904,-15.408) AV6(1.934,-15.485) AV7(2.531,-15.485) AV10(4.118,-15.497) AV13(5.096,-15.497) AV15(6.074,-15.497) AV17(7.052,-15.497) AV20(8.03,-15.497) AV22(9.008,-15.497) AV24(9.617,-15.497) AV26(10.595,-15.497) AV29(11.573,-15.497) AV31(12.551,-15.497) AV33(13.529,-15.497) AV36(14.507,-15.497) AV40(16.691,-15.485) AV43(17.721,-15.408) AV45(18.625,-15.408) AW2(0.472,-15.815) AW8(3.14,-16.094) AW10(4.118,-16.094) AW13(5.096,-16.094) AW15(6.074,-16.094) AW17(7.052,-16.094) AW20(8.03,-16.094) AW22(9.008,-16.094) AW24(9.617,-16.094) AW26(10.595,-16.094) AW29(11.573,-16.094) AW31(12.551,-16.094) AW33(13.529,-16.094) AW36(14.507,-16.094) AW38(15.485,-16.094) AW40(17.123,-16.221) AW44(18.152,-15.815) AY3(0.978,-16.221) AY5(1.743,-16.051) AY7(2.404,-17.123) AY8(3.14,-16.691) AY10(4.118,-16.691) AY13(5.096,-16.691) AY15(6.074,-16.691) AY17(7.052,-16.691) AY20(8.03,-16.691) AY22(9.008,-16.691) AY24(9.617,-16.691) AY26(10.595,-16.691) AY29(11.573,-16.691) AY31(12.551,-16.691) AY33(13.529,-16.691) AY36(14.507,-16.691) AY38(15.485,-16.691) AY43(17.721,-16.221) B5(1.96,-0.586) B7(2.739,-0.552) B9(3.645,-0.452) B11(4.436,-0.472) B13(5.27,-0.452) B15(6.061,-0.472) B17(6.896,-0.452) B19(7.687,-0.472) B21(8.521,-0.452) B23(9.312,-0.472) B25(10.147,-0.452) B27(10.938,-0.472) B29(11.773,-0.452) B31(12.564,-0.472) B33(13.398,-0.452) B35(14.189,-0.472) B37(15.024,-0.452) B39(15.815,-0.472) BA40(16.051,-16.882) BB4(1.391,-17.302) BB9(3.623,-17.289) BB13(5.248,-17.289) BB17(6.874,-17.289) BB21(8.5,-17.289) BB25(10.125,-17.289) BB29(11.751,-17.289) BB33(13.376,-17.289) BB37(15.002,-17.289) BB42(17.302,-17.233) BC6(2.404,-17.721) BC8(3.216,-17.721) BC10(4.029,-17.721) BC12(4.842,-17.721) BC14(5.655,-17.721) BC16(6.468,-17.721) BC18(7.28,-17.721) BC20(8.093,-17.721) BC22(8.906,-17.721) BC24(9.719,-17.721) BC26(10.532,-17.721) BC28(11.344,-17.721) BC30(12.157,-17.721) BC32(12.97,-17.721) BC34(13.783,-17.721) BC36(14.596,-17.721) BC38(15.408,-17.721) BC40(16.221,-17.647) BD7(2.81,-18.152) BD9(3.601,-18.173) BD11(4.436,-18.152) BD13(5.227,-18.173) BD15(6.061,-18.152) BD17(6.852,-18.173) BD19(7.687,-18.152) BD21(8.478,-18.173) BD23(9.312,-18.152) BD25(10.103,-18.173) BD27(10.938,-18.152) BD29(11.729,-18.173) BD31(12.564,-18.152) BD33(13.355,-18.173) BD35(14.189,-18.152) BD37(14.98,-18.173) BD39(15.815,-18.152) BE8(3.216,-18.625) BE10(4.029,-18.625) BE12(4.842,-18.625) BE14(5.655,-18.625) BE16(6.468,-18.625) BE18(7.28,-18.625) BE20(8.093,-18.625) BE22(8.906,-18.625) BE24(9.719,-18.625) BE26(10.532,-18.625) BE28(11.344,-18.625) BE30(12.157,-18.625) BE32(12.97,-18.625) BE34(13.783,-18.625) BE36(14.596,-18.625) BE38(15.408,-18.625) C6(2.37,-1.017) C8(3.216,-0.904) C10(4.029,-0.904) C12(4.842,-0.904) C14(5.655,-0.904) C16(6.468,-0.904) C18(7.28,-0.904) C20(8.093,-0.904) C22(8.906,-0.904) C24(9.719,-0.904) C26(10.532,-0.904) C28(11.344,-0.904) C30(12.157,-0.904) C32(12.97,-0.904) C34(13.783,-0.904) C36(14.596,-0.904) C38(15.408,-0.904) C40(16.221,-0.904) D4(1.323,-1.391) D9(3.623,-1.336) D13(5.248,-1.336) D17(6.874,-1.336) D21(8.5,-1.336) D25(10.125,-1.336) D29(11.751,-1.336) D33(13.376,-1.336) D37(15.002,-1.336) D42(17.233,-1.323) E6(2.574,-1.743) F3(0.978,-2.359) F8(3.14,-1.934) F10(4.118,-1.934) F13(5.096,-1.934) F15(6.074,-1.934) F17(7.052,-1.934) F20(8.03,-1.934) F22(9.008,-1.934) F24(9.617,-1.934) F26(10.595,-1.934) F29(11.573,-1.934) F31(12.551,-1.934) F33(13.529,-1.934) F36(14.507,-1.934) F38(15.485,-1.934) F39(16.221,-1.502) F41(16.882,-2.574) F43(17.647,-2.404) G2(0.532,-2.752) G5(1.562,-2.48) G8(3.14,-2.531) G10(4.118,-2.531) G13(5.096,-2.531) G15(6.074,-2.531) G17(7.052,-2.531) G20(8.03,-2.531) G22(9.008,-2.531) G24(9.617,-2.531) G26(10.595,-2.531) G29(11.573,-2.531) G31(12.551,-2.531) G33(13.529,-2.531) G36(14.507,-2.531) G38(15.485,-2.531) G44(18.152,-2.81) H1(0,-3.216) H3(0.904,-3.216) H6(1.934,-3.14) H7(2.531,-3.14) H10(4.118,-3.128) H13(5.096,-3.128) H15(6.074,-3.128) H17(7.052,-3.128) H20(8.03,-3.128) H22(9.008,-3.128) H24(9.617,-3.128) H26(10.595,-3.128) H29(11.573,-3.128) H31(12.551,-3.128) H33(13.529,-3.128) H36(14.507,-3.128) H39(16.094,-3.14) H40(16.691,-3.14) H43(17.721,-3.216) H45(18.625,-3.216) J2(0.452,-3.601) J4(1.336,-3.623) J42(17.289,-3.623) J44(18.173,-3.645) K1(0,-4.029) K3(0.904,-4.029) K6(1.934,-4.118) K7(2.531,-4.118) K8(3.128,-4.118) K10(3.724,-4.118) K13(5.096,-3.724) K15(6.074,-3.724) K17(7.052,-3.724) K20(8.03,-3.724) K22(9.008,-3.724) K24(9.617,-3.724) K26(10.595,-3.724) K29(11.573,-3.724) K31(12.551,-3.724) K33(13.529,-3.724) K36(14.507,-3.724) K38(15.497,-4.118) K39(16.094,-4.118) K40(16.691,-4.118) K43(17.721,-4.029) K45(18.625,-4.029) L2(0.472,-4.436) L13(5.096,-4.321) L15(6.074,-4.321) L17(7.052,-4.321) L20(8.03,-4.321) L22(9.008,-4.321) L24(9.617,-4.321) L26(10.595,-4.321) L29(11.573,-4.321) L31(12.551,-4.321) L33(13.529,-4.321) L44(18.152,-4.436) M1(0,-4.842) M3(0.904,-4.842) M15(6.074,-4.918) M17(7.052,-4.918) M20(8.03,-4.918) M22(9.008,-4.918) M24(9.617,-4.918) M26(10.595,-4.918) M29(11.573,-4.918) M31(12.551,-4.918) M33(13.529,-4.969) M43(17.721,-4.842) M45(18.625,-4.842) N2(0.452,-5.227) N4(1.336,-5.248) N6(1.934,-5.096) N7(2.531,-5.096) N8(3.128,-5.096) N10(3.724,-5.096) N11(4.321,-5.096) N12(4.969,-5.096) N35(14.304,-5.096) N36(14.9,-5.096) N38(15.497,-5.096) N39(16.094,-5.096) N40(16.691,-5.096) N42(17.289,-5.248) N44(18.173,-5.27) P1(0,-5.655) P3(0.904,-5.655) P14(5.515,-5.525) P16(6.328,-5.525) P18(7.141,-5.525) P20(7.954,-5.525) P22(8.766,-5.525) P24(9.579,-5.525) P26(10.392,-5.525) P28(11.205,-5.525) P30(12.018,-5.525) P32(12.83,-5.525) P43(17.721,-5.655) P45(18.625,-5.655) R2(0.472,-6.061) R6(1.934,-6.074) R7(2.531,-6.074) R8(3.128,-6.074) R10(3.724,-6.074) R11(4.321,-6.074) R12(4.918,-6.074) R14(5.515,-6.186) R16(6.328,-6.186) R18(7.141,-6.186) R20(7.954,-6.186) R22(8.766,-6.186) R24(9.579,-6.186) R26(10.392,-6.186) R28(11.205,-6.186) R30(12.018,-6.186) R32(12.83,-6.186) R34(13.707,-6.074) R35(14.304,-6.074) R36(14.9,-6.074) R38(15.497,-6.074) R39(16.094,-6.074) R40(16.691,-6.074) R44(18.152,-6.061) T1(0,-6.468) T3(0.904,-6.468) T43(17.721,-6.468) T45(18.625,-6.468) U2(0.452,-6.852) U4(1.336,-6.874) U6(1.934,-7.052) U7(2.531,-7.052) U8(3.128,-7.052) U10(3.724,-7.052) U11(4.321,-7.052) U12(4.918,-7.052) U14(5.515,-6.846) U16(6.328,-6.846) U18(7.141,-6.846) U20(7.954,-6.846) U22(8.766,-6.846) U24(9.579,-6.846) U26(10.392,-6.846) U28(11.205,-6.846) U30(12.018,-6.846) U32(12.83,-6.846) U34(13.707,-7.052) U35(14.304,-7.052) U36(14.9,-7.052) U38(15.497,-7.052) U39(16.094,-7.052) U40(16.691,-7.052) U42(17.289,-6.874) U44(18.173,-6.896) V1(0,-7.28) V3(0.904,-7.28) V14(5.515,-7.506) V16(6.328,-7.506) V18(7.141,-7.506) V20(7.954,-7.506) V22(8.766,-7.506) V24(9.579,-7.506) V26(10.392,-7.506) V28(11.205,-7.506) V30(12.018,-7.506) V32(12.83,-7.506) V43(17.721,-7.28) V45(18.625,-7.28) W2(0.472,-7.687) W44(18.152,-7.687) Y1(0,-8.093) Y3(0.904,-8.093) Y6(1.934,-8.03) Y7(2.531,-8.03) Y8(3.128,-8.03) Y10(3.724,-8.03) Y11(4.321,-8.03) Y12(4.918,-8.03) Y14(5.515,-8.167) Y16(6.328,-8.167) Y18(7.141,-8.167) Y20(7.954,-8.167) Y22(8.766,-8.167) Y24(9.579,-8.167) Y26(10.392,-8.167) Y28(11.205,-8.167) Y30(12.018,-8.167) Y32(12.83,-8.167) Y34(13.707,-8.03) Y35(14.304,-8.03) Y36(14.9,-8.03) Y38(15.497,-8.03) Y39(16.094,-8.03) Y40(16.691,-8.03) Y43(17.721,-8.093) Y45(18.625,-8.093)
MALCOLM-EX_QFN56_7X7
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 29(5.2,6.95) 30(4.8,6.95) 31(4.4,6.95) 32(4,6.95) 33(3.6,6.95) 34(3.2,6.95) 35(2.8,6.95) 36(2.4,6.95) 37(2,6.95) 38(1.6,6.95) 39(1.2,6.95) 40(0.8,6.95) 41(0.4,6.95) 42(0,6.95)
  oval 1.041x0.203 smd: 15(6.075,0.875) 16(6.075,1.275) 17(6.075,1.675) 18(6.075,2.075) 19(6.075,2.475) 20(6.075,2.875) 21(6.075,3.275) 22(6.075,3.675) 23(6.075,4.075) 24(6.075,4.475) 25(6.075,4.875) 26(6.075,5.275) 27(6.075,5.675) 28(6.075,6.075) 43(-0.875,6.075) 44(-0.875,5.675) 45(-0.875,5.275) 46(-0.875,4.875) 47(-0.875,4.475) 48(-0.875,4.075) 49(-0.875,3.675) 50(-0.875,3.275) 51(-0.875,2.875) 52(-0.875,2.475) 53(-0.875,2.075) 54(-0.875,1.675) 55(-0.875,1.275) 56(-0.875,0.875)
  rect 5.512x5.512 smd: 57(2.6,3.475)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MDU1511RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG121SN1D_L0402_2P
  rect 0.457x0.711 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM18FN4R7M00D_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
N15E-GX-A2_BGA_1745P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A8(5.6,0) A9(6.4,0) A11(8,0) A12(8.8,0) A14(10.4,0) A15(11.2,0) A17(12.8,0) A18(13.6,0) A20(15.2,0) A21(16,0) A23(17.6,0) A24(18.4,0) A26(20,0) A27(20.8,0) A29(22.4,0) A30(23.2,0) A32(24.8,0) A33(25.6,0) A35(27.2,0) A36(28,0) A38(29.6,0) A39(30.4,0) A41(32,0) A42(32.8,0) A44(34.4,0) A45(35.2,0) A46(36,0) A47(36.8,0) A48(37.6,0) AA1(0,-16) AA2(0.8,-16) AA3(1.6,-16) AA4(2.4,-16) AA5(3.2,-16) AA6(4,-16) AA7(4.8,-16) AA8(5.6,-16) AA9(6.4,-16) AA10(7.2,-16) AA11(8.2,-16) AA39(30.2,-16) AA40(31.2,-16) AA41(32,-16) AA42(32.8,-16) AA43(33.6,-16) AA44(34.4,-16) AA45(35.2,-16) AA46(36,-16) AA47(36.8,-16) AA48(37.6,-16) AA49(38.4,-16) AB2(0.8,-16.8) AB4(2.4,-16.8) AB5(3.2,-16.8) AB8(5.6,-16.8) AB9(6.4,-16.8) AB11(8.2,-16.8) AB39(30.2,-16.8) AB41(32,-16.8) AB42(32.8,-16.8) AB45(35.2,-16.8) AB46(36,-16.8) AB48(37.6,-16.8) AC1(0,-17.6) AC2(0.8,-17.6) AC3(1.6,-17.6) AC4(2.4,-17.6) AC5(3.2,-17.6) AC6(4,-17.6) AC7(4.8,-17.6) AC8(5.6,-17.6) AC9(6.4,-17.6) AC10(7.2,-17.6) AC11(8.2,-17.6) AC39(30.2,-17.6) AC40(31.2,-17.6) AC41(32,-17.6) AC42(32.8,-17.6) AC43(33.6,-17.6) AC44(34.4,-17.6) AC45(35.2,-17.6) AC46(36,-17.6) AC47(36.8,-17.6) AC48(37.6,-17.6) AC49(38.4,-17.6) AD1(0,-18.4) AD2(0.8,-18.4) AD3(1.6,-18.4) AD4(2.4,-18.4) AD5(3.2,-18.4) AD6(4,-18.4) AD7(4.8,-18.4) AD8(5.6,-18.4) AD9(6.4,-18.4) AD10(7.2,-18.4) AD11(8.2,-18.4) AD39(30.2,-18.4) AD40(31.2,-18.4) AD41(32,-18.4) AD42(32.8,-18.4) AD43(33.6,-18.4) AD44(34.4,-18.4) AD45(35.2,-18.4) AD46(36,-18.4) AD47(36.8,-18.4) AD48(37.6,-18.4) AD49(38.4,-18.4) AE2(0.8,-19.2) AE4(2.4,-19.2) AE5(3.2,-19.2) AE8(5.6,-19.2) AE9(6.4,-19.2) AE11(8.2,-19.2) AE39(30.2,-19.2) AE41(32,-19.2) AE42(32.8,-19.2) AE45(35.2,-19.2) AE46(36,-19.2) AE48(37.6,-19.2) AF1(0,-20) AF2(0.8,-20) AF3(1.6,-20) AF4(2.4,-20) AF5(3.2,-20) AF6(4,-20) AF7(4.8,-20) AF8(5.6,-20) AF9(6.4,-20) AF10(7.2,-20) AF11(8.2,-20) AF39(30.2,-20) AF40(31.2,-20) AF41(32,-20) AF42(32.8,-20) AF43(33.6,-20) AF44(34.4,-20) AF45(35.2,-20) AF46(36,-20) AF47(36.8,-20) AF48(37.6,-20) AF49(38.4,-20) AG1(0,-20.8) AG2(0.8,-20.8) AG3(1.6,-20.8) AG4(2.4,-20.8) AG5(3.2,-20.8) AG6(4,-20.8) AG7(4.8,-20.8) AG8(5.6,-20.8) AG9(6.4,-20.8) AG10(7.2,-20.8) AG11(8.2,-20.8) AG39(30.2,-20.8) AG40(31.2,-20.8) AG41(32,-20.8) AG42(32.8,-20.8) AG43(33.6,-20.8) AG44(34.4,-20.8) AG45(35.2,-20.8) AG46(36,-20.8) AG47(36.8,-20.8) AG48(37.6,-20.8) AG49(38.4,-20.8) AH2(0.8,-21.6) AH4(2.4,-21.6) AH5(3.2,-21.6) AH8(5.6,-21.6) AH9(6.4,-21.6) AH11(8.2,-21.6) AH39(30.2,-21.6) AH41(32,-21.6) AH42(32.8,-21.6) AH45(35.2,-21.6) AH46(36,-21.6) AH48(37.6,-21.6) AJ1(0,-22.4) AJ2(0.8,-22.4) AJ3(1.6,-22.4) AJ4(2.4,-22.4) AJ5(3.2,-22.4) AJ6(4,-22.4) AJ7(4.8,-22.4) AJ8(5.6,-22.4) AJ9(6.4,-22.4) AJ10(7.2,-22.4) AJ11(8.2,-22.4) AJ39(30.2,-22.4) AJ40(31.2,-22.4) AJ41(32,-22.4) AJ42(32.8,-22.4) AJ43(33.6,-22.4) AJ44(34.4,-22.4) AJ45(35.2,-22.4) AJ46(36,-22.4) AJ47(36.8,-22.4) AJ48(37.6,-22.4) AJ49(38.4,-22.4) AK1(0,-23.2) AK2(0.8,-23.2) AK3(1.6,-23.2) AK4(2.4,-23.2) AK5(3.2,-23.2) AK6(4,-23.2) AK7(4.8,-23.2) AK8(5.6,-23.2) AK9(6.4,-23.2) AK10(7.2,-23.2) AK11(8.2,-23.2) AK39(30.2,-23.2) AK40(31.2,-23.2) AK41(32,-23.2) AK42(32.8,-23.2) AK43(33.6,-23.2) AK44(34.4,-23.2) AK45(35.2,-23.2) AK46(36,-23.2) AK47(36.8,-23.2) AK48(37.6,-23.2) AK49(38.4,-23.2) AL2(0.8,-24) AL4(2.4,-24) AL5(3.2,-24) AL8(5.6,-24) AL9(6.4,-24) AL11(8.2,-24) AL39(30.2,-24) AL41(32,-24) AL42(32.8,-24) AL45(35.2,-24) AL46(36,-24) AL48(37.6,-24) AM1(0,-24.8) AM2(0.8,-24.8) AM3(1.6,-24.8) AM4(2.4,-24.8) AM5(3.2,-24.8) AM6(4,-24.8) AM7(4.8,-24.8) AM8(5.6,-24.8) AM9(6.4,-24.8) AM10(7.2,-24.8) AM11(8.2,-24.8) AM39(30.2,-24.8) AM40(31.2,-24.8) AM41(32,-24.8) AM42(32.8,-24.8) AM43(33.6,-24.8) AM44(34.4,-24.8) AM45(35.2,-24.8) AM46(36,-24.8) AM47(36.8,-24.8) AM48(37.6,-24.8) AM49(38.4,-24.8) AN1(0,-25.6) AN2(0.8,-25.6) AN3(1.6,-25.6) AN4(2.4,-25.6) AN5(3.2,-25.6) AN6(4,-25.6) AN7(4.8,-25.6) AN8(5.6,-25.6) AN9(6.4,-25.6) AN10(7.2,-25.6) AN11(8.2,-25.6) AN39(30.2,-25.6) AN40(31.2,-25.6) AN41(32,-25.6) AN42(32.8,-25.6) AN43(33.6,-25.6) AN44(34.4,-25.6) AN45(35.2,-25.6) AN46(36,-25.6) AN47(36.8,-25.6) AN48(37.6,-25.6) AN49(38.4,-25.6) AP2(0.8,-26.4) AP4(2.4,-26.4) AP5(3.2,-26.4) AP8(5.6,-26.4) AP9(6.4,-26.4) AP11(8.2,-26.4) AP39(30.2,-26.4) AP41(32,-26.4) AP42(32.8,-26.4) AP45(35.2,-26.4) AP46(36,-26.4) AP48(37.6,-26.4) AR1(0,-27.2) AR2(0.8,-27.2) AR3(1.6,-27.2) AR4(2.4,-27.2) AR5(3.2,-27.2) AR6(4,-27.2) AR7(4.8,-27.2) AR8(5.6,-27.2) AR9(6.4,-27.2) AR10(7.2,-27.2) AR11(8.2,-27.2) AR39(30.2,-27.2) AR40(31.2,-27.2) AR41(32,-27.2) AR42(32.8,-27.2) AR43(33.6,-27.2) AR44(34.4,-27.2) AR45(35.2,-27.2) AR46(36,-27.2) AR47(36.8,-27.2) AR48(37.6,-27.2) AR49(38.4,-27.2) AT1(0,-28) AT2(0.8,-28) AT3(1.6,-28) AT4(2.4,-28) AT5(3.2,-28) AT6(4,-28) AT7(4.8,-28) AT8(5.6,-28) AT9(6.4,-28) AT10(7.2,-28) AT11(8.2,-28) AT39(30.2,-28) AT40(31.2,-28) AT41(32,-28) AT42(32.8,-28) AT43(33.6,-28) AT44(34.4,-28) AT45(35.2,-28) AT46(36,-28) AT47(36.8,-28) AT48(37.6,-28) AT49(38.4,-28) AU2(0.8,-28.8) AU4(2.4,-28.8) AU5(3.2,-28.8) AU8(5.6,-28.8) AU9(6.4,-28.8) AU11(8.2,-28.8) AU39(30.2,-28.8) AU41(32,-28.8) AU42(32.8,-28.8) AU45(35.2,-28.8) AU46(36,-28.8) AU48(37.6,-28.8) AV1(0,-29.6) AV2(0.8,-29.6) AV3(1.6,-29.6) AV4(2.4,-29.6) AV5(3.2,-29.6) AV6(4,-29.6) AV7(4.8,-29.6) AV8(5.6,-29.6) AV9(6.4,-29.6) AV41(32,-29.6) AV42(32.8,-29.6) AV43(33.6,-29.6) AV44(34.4,-29.6) AV45(35.2,-29.6) AV46(36,-29.6) AV47(36.8,-29.6) AV48(37.6,-29.6) AV49(38.4,-29.6) AW1(0,-30.4) AW2(0.8,-30.4) AW3(1.6,-30.4) AW4(2.4,-30.4) AW5(3.2,-30.4) AW6(4,-30.4) AW7(4.8,-30.4) AW8(5.6,-30.4) AW9(6.4,-30.4) AW13(9.6,-30.2) AW14(10.4,-30.2) AW15(11.2,-30.2) AW16(12,-30.2) AW17(12.8,-30.2) AW18(13.6,-30.2) AW19(14.4,-30.2) AW20(15.2,-30.2) AW21(16,-30.2) AW22(16.8,-30.2) AW23(17.6,-30.2) AW24(18.4,-30.2) AW25(19.2,-30.2) AW26(20,-30.2) AW27(20.8,-30.2) AW28(21.6,-30.2) AW29(22.4,-30.2) AW30(23.2,-30.2) AW31(24,-30.2) AW32(24.8,-30.2) AW33(25.6,-30.2) AW34(26.4,-30.2) AW35(27.2,-30.2) AW36(28,-30.2) AW37(28.8,-30.2) AW41(32,-30.4) AW42(32.8,-30.4) AW43(33.6,-30.4) AW44(34.4,-30.4) AW45(35.2,-30.4) AW46(36,-30.4) AW47(36.8,-30.4) AW48(37.6,-30.4) AW49(38.4,-30.4) AY2(0.8,-31.2) AY4(2.4,-31.2) AY5(3.2,-31.2) AY8(5.6,-31.2) AY14(10.4,-31.2) AY15(11.2,-31.2) AY17(12.8,-31.2) AY18(13.6,-31.2) AY20(15.2,-31.2) AY21(16,-31.2) AY23(17.6,-31.2) AY24(18.4,-31.2) AY26(20,-31.2) AY27(20.8,-31.2) AY29(22.4,-31.2) AY30(23.2,-31.2) AY32(24.8,-31.2) AY33(25.6,-31.2) AY35(27.2,-31.2) AY36(28,-31.2) AY42(32.8,-31.2) AY45(35.2,-31.2) AY46(36,-31.2) AY48(37.6,-31.2) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.8,-0.8) B8(5.6,-0.8) B9(6.4,-0.8) B10(7.2,-0.8) B11(8,-0.8) B12(8.8,-0.8) B13(9.6,-0.8) B14(10.4,-0.8) B15(11.2,-0.8) B16(12,-0.8) B17(12.8,-0.8) B18(13.6,-0.8) B19(14.4,-0.8) B20(15.2,-0.8) B21(16,-0.8) B22(16.8,-0.8) B23(17.6,-0.8) B24(18.4,-0.8) B25(19.2,-0.8) B26(20,-0.8) B27(20.8,-0.8) B28(21.6,-0.8) B29(22.4,-0.8) B30(23.2,-0.8) B31(24,-0.8) B32(24.8,-0.8) B33(25.6,-0.8) B34(26.4,-0.8) B35(27.2,-0.8) B36(28,-0.8) B37(28.8,-0.8) B38(29.6,-0.8) B39(30.4,-0.8) B40(31.2,-0.8) B41(32,-0.8) B42(32.8,-0.8) B43(33.6,-0.8) B44(34.4,-0.8) B45(35.2,-0.8) B46(36,-0.8) B47(36.8,-0.8) B48(37.6,-0.8) B49(38.4,-0.8) BA1(0,-32) BA2(0.8,-32) BA3(1.6,-32) BA4(2.4,-32) BA5(3.2,-32) BA6(4,-32) BA7(4.8,-32) BA8(5.6,-32) BA11(8,-32) BA12(8.8,-32) BA13(9.6,-32) BA14(10.4,-32) BA15(11.2,-32) BA16(12,-32) BA17(12.8,-32) BA18(13.6,-32) BA19(14.4,-32) BA20(15.2,-32) BA21(16,-32) BA22(16.8,-32) BA23(17.6,-32) BA24(18.4,-32) BA25(19.2,-32) BA26(20,-32) BA27(20.8,-32) BA28(21.6,-32) BA29(22.4,-32) BA30(23.2,-32) BA31(24,-32) BA32(24.8,-32) BA33(25.6,-32) BA34(26.4,-32) BA35(27.2,-32) BA36(28,-32) BA37(28.8,-32) BA38(29.6,-32) BA39(30.4,-32) BA42(32.8,-32) BA43(33.6,-32) BA44(34.4,-32) BA45(35.2,-32) BA46(36,-32) BA47(36.8,-32) BA48(37.6,-32) BA49(38.4,-32) BB1(0,-32.8) BB2(0.8,-32.8) BB3(1.6,-32.8) BB4(2.4,-32.8) BB5(3.2,-32.8) BB6(4,-32.8) BB7(4.8,-32.8) BB8(5.6,-32.8) BB9(6.4,-32.8) BB10(7.2,-32.8) BB11(8,-32.8) BB12(8.8,-32.8) BB13(9.6,-32.8) BB14(10.4,-32.8) BB15(11.2,-32.8) BB16(12,-32.8) BB17(12.8,-32.8) BB18(13.6,-32.8) BB19(14.4,-32.8) BB20(15.2,-32.8) BB21(16,-32.8) BB22(16.8,-32.8) BB23(17.6,-32.8) BB24(18.4,-32.8) BB25(19.2,-32.8) BB26(20,-32.8) BB27(20.8,-32.8) BB28(21.6,-32.8) BB29(22.4,-32.8) BB30(23.2,-32.8) BB31(24,-32.8) BB32(24.8,-32.8) BB33(25.6,-32.8) BB34(26.4,-32.8) BB35(27.2,-32.8) BB36(28,-32.8) BB37(28.8,-32.8) BB38(29.6,-32.8) BB39(30.4,-32.8) BB40(31.2,-32.8) BB41(32,-32.8) BB42(32.8,-32.8) BB43(33.6,-32.8) BB44(34.4,-32.8) BB45(35.2,-32.8) BB46(36,-32.8) BB47(36.8,-32.8) BB48(37.6,-32.8) BB49(38.4,-32.8) BC2(0.8,-33.6) BC4(2.4,-33.6) BC5(3.2,-33.6) BC8(5.6,-33.6) BC9(6.4,-33.6) BC11(8,-33.6) BC12(8.8,-33.6) BC14(10.4,-33.6) BC15(11.2,-33.6) BC17(12.8,-33.6) BC18(13.6,-33.6) BC20(15.2,-33.6) BC21(16,-33.6) BC23(17.6,-33.6) BC24(18.4,-33.6) BC26(20,-33.6) BC27(20.8,-33.6) BC29(22.4,-33.6) BC30(23.2,-33.6) BC32(24.8,-33.6) BC33(25.6,-33.6) BC35(27.2,-33.6) BC36(28,-33.6) BC38(29.6,-33.6) BC39(30.4,-33.6) BC41(32,-33.6) BC42(32.8,-33.6) BC45(35.2,-33.6) BC46(36,-33.6) BC48(37.6,-33.6) BD1(0,-34.4) BD2(0.8,-34.4) BD3(1.6,-34.4) BD4(2.4,-34.4) BD5(3.2,-34.4) BD6(4,-34.4) BD8(5.6,-34.4) BD9(6.4,-34.4) BD11(8,-34.4) BD12(8.8,-34.4) BD14(10.4,-34.4) BD15(11.2,-34.4) BD17(12.8,-34.4) BD18(13.6,-34.4) BD20(15.2,-34.4) BD21(16,-34.4) BD23(17.6,-34.4) BD24(18.4,-34.4) BD26(20,-34.4) BD27(20.8,-34.4) BD29(22.4,-34.4) BD30(23.2,-34.4) BD32(24.8,-34.4) BD33(25.6,-34.4) BD35(27.2,-34.4) BD36(28,-34.4) BD38(29.6,-34.4) BD39(30.4,-34.4) BD41(32,-34.4) BD42(32.8,-34.4) BD44(34.4,-34.4) BD45(35.2,-34.4) BD46(36,-34.4) BD47(36.8,-34.4) BD48(37.6,-34.4) BD49(38.4,-34.4) BE1(0,-35.2) BE2(0.8,-35.2) BE3(1.6,-35.2) BE4(2.4,-35.2) BE5(3.2,-35.2) BE6(4,-35.2) BE7(4.8,-35.2) BE8(5.6,-35.2) BE9(6.4,-35.2) BE10(7.2,-35.2) BE11(8,-35.2) BE12(8.8,-35.2) BE13(9.6,-35.2) BE14(10.4,-35.2) BE15(11.2,-35.2) BE16(12,-35.2) BE17(12.8,-35.2) BE18(13.6,-35.2) BE19(14.4,-35.2) BE20(15.2,-35.2) BE21(16,-35.2) BE22(16.8,-35.2) BE23(17.6,-35.2) BE24(18.4,-35.2) BE25(19.2,-35.2) BE26(20,-35.2) BE27(20.8,-35.2) BE28(21.6,-35.2) BE29(22.4,-35.2) BE30(23.2,-35.2) BE31(24,-35.2) BE32(24.8,-35.2) BE33(25.6,-35.2) BE34(26.4,-35.2) BE35(27.2,-35.2) BE36(28,-35.2) BE37(28.8,-35.2) BE38(29.6,-35.2) BE39(30.4,-35.2) BE40(31.2,-35.2) BE41(32,-35.2) BE42(32.8,-35.2) BE43(33.6,-35.2) BE44(34.4,-35.2) BE45(35.2,-35.2) BE46(36,-35.2) BE47(36.8,-35.2) BE48(37.6,-35.2) BE49(38.4,-35.2) BF1(0,-36) BF2(0.8,-36) BF3(1.6,-36) BF4(2.4,-36) BF5(3.2,-36) BF6(4,-36) BF7(4.8,-36) BF8(5.6,-36) BF9(6.4,-36) BF10(7.2,-36) BF11(8,-36) BF12(8.8,-36) BF13(9.6,-36) BF14(10.4,-36) BF15(11.2,-36) BF16(12,-36) BF17(12.8,-36) BF18(13.6,-36) BF19(14.4,-36) BF20(15.2,-36) BF21(16,-36) BF22(16.8,-36) BF23(17.6,-36) BF24(18.4,-36) BF25(19.2,-36) BF26(20,-36) BF27(20.8,-36) BF28(21.6,-36) BF29(22.4,-36) BF30(23.2,-36) BF31(24,-36) BF32(24.8,-36) BF33(25.6,-36) BF34(26.4,-36) BF35(27.2,-36) BF36(28,-36) BF37(28.8,-36) BF38(29.6,-36) BF39(30.4,-36) BF40(31.2,-36) BF41(32,-36) BF42(32.8,-36) BF43(33.6,-36) BF44(34.4,-36) BF45(35.2,-36) BF46(36,-36) BF47(36.8,-36) BF48(37.6,-36) BF49(38.4,-36) BG1(0,-36.8) BG2(0.8,-36.8) BG3(1.6,-36.8) BG4(2.4,-36.8) BG5(3.2,-36.8) BG6(4,-36.8) BG8(5.6,-36.8) BG9(6.4,-36.8) BG11(8,-36.8) BG12(8.8,-36.8) BG14(10.4,-36.8) BG15(11.2,-36.8) BG17(12.8,-36.8) BG18(13.6,-36.8) BG20(15.2,-36.8) BG21(16,-36.8) BG23(17.6,-36.8) BG24(18.4,-36.8) BG26(20,-36.8) BG27(20.8,-36.8) BG29(22.4,-36.8) BG30(23.2,-36.8) BG32(24.8,-36.8) BG33(25.6,-36.8) BG35(27.2,-36.8) BG36(28,-36.8) BG38(29.6,-36.8) BG39(30.4,-36.8) BG41(32,-36.8) BG42(32.8,-36.8) BG44(34.4,-36.8) BG45(35.2,-36.8) BG46(36,-36.8) BG47(36.8,-36.8) BG48(37.6,-36.8) BG49(38.4,-36.8) BH1(0,-37.6) BH2(0.8,-37.6) BH3(1.6,-37.6) BH4(2.4,-37.6) BH5(3.2,-37.6) BH6(4,-37.6) BH7(4.8,-37.6) BH8(5.6,-37.6) BH9(6.4,-37.6) BH10(7.2,-37.6) BH11(8,-37.6) BH12(8.8,-37.6) BH13(9.6,-37.6) BH14(10.4,-37.6) BH15(11.2,-37.6) BH16(12,-37.6) BH17(12.8,-37.6) BH18(13.6,-37.6) BH19(14.4,-37.6) BH20(15.2,-37.6) BH21(16,-37.6) BH22(16.8,-37.6) BH23(17.6,-37.6) BH24(18.4,-37.6) BH25(19.2,-37.6) BH26(20,-37.6) BH27(20.8,-37.6) BH28(21.6,-37.6) BH29(22.4,-37.6) BH30(23.2,-37.6) BH31(24,-37.6) BH32(24.8,-37.6) BH33(25.6,-37.6) BH34(26.4,-37.6) BH35(27.2,-37.6) BH36(28,-37.6) BH37(28.8,-37.6) BH38(29.6,-37.6) BH39(30.4,-37.6) BH40(31.2,-37.6) BH41(32,-37.6) BH42(32.8,-37.6) BH43(33.6,-37.6) BH44(34.4,-37.6) BH45(35.2,-37.6) BH46(36,-37.6) BH47(36.8,-37.6) BH48(37.6,-37.6) BH49(38.4,-37.6) BJ2(0.8,-38.4) BJ3(1.6,-38.4) BJ4(2.4,-38.4) BJ5(3.2,-38.4) BJ6(4,-38.4) BJ8(5.6,-38.4) BJ9(6.4,-38.4) BJ11(8,-38.4) BJ12(8.8,-38.4) BJ14(10.4,-38.4) BJ15(11.2,-38.4) BJ17(12.8,-38.4) BJ18(13.6,-38.4) BJ20(15.2,-38.4) BJ21(16,-38.4) BJ23(17.6,-38.4) BJ24(18.4,-38.4) BJ26(20,-38.4) BJ27(20.8,-38.4) BJ29(22.4,-38.4) BJ30(23.2,-38.4) BJ32(24.8,-38.4) BJ33(25.6,-38.4) BJ35(27.2,-38.4) BJ36(28,-38.4) BJ38(29.6,-38.4) BJ39(30.4,-38.4) BJ41(32,-38.4) BJ42(32.8,-38.4) BJ44(34.4,-38.4) BJ45(35.2,-38.4) BJ46(36,-38.4) BJ47(36.8,-38.4) BJ48(37.6,-38.4) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C8(5.6,-1.6) C9(6.4,-1.6) C11(8,-1.6) C12(8.8,-1.6) C14(10.4,-1.6) C15(11.2,-1.6) C17(12.8,-1.6) C18(13.6,-1.6) C20(15.2,-1.6) C21(16,-1.6) C23(17.6,-1.6) C24(18.4,-1.6) C26(20,-1.6) C27(20.8,-1.6) C29(22.4,-1.6) C30(23.2,-1.6) C32(24.8,-1.6) C33(25.6,-1.6) C35(27.2,-1.6) C36(28,-1.6) C38(29.6,-1.6) C39(30.4,-1.6) C41(32,-1.6) C42(32.8,-1.6) C44(34.4,-1.6) C45(35.2,-1.6) C46(36,-1.6) C47(36.8,-1.6) C48(37.6,-1.6) C49(38.4,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.8,-2.4) D8(5.6,-2.4) D9(6.4,-2.4) D10(7.2,-2.4) D11(8,-2.4) D12(8.8,-2.4) D13(9.6,-2.4) D14(10.4,-2.4) D15(11.2,-2.4) D16(12,-2.4) D17(12.8,-2.4) D18(13.6,-2.4) D19(14.4,-2.4) D20(15.2,-2.4) D21(16,-2.4) D22(16.8,-2.4) D23(17.6,-2.4) D24(18.4,-2.4) D25(19.2,-2.4) D26(20,-2.4) D27(20.8,-2.4) D28(21.6,-2.4) D29(22.4,-2.4) D30(23.2,-2.4) D31(24,-2.4) D32(24.8,-2.4) D33(25.6,-2.4) D34(26.4,-2.4) D35(27.2,-2.4) D36(28,-2.4) D37(28.8,-2.4) D38(29.6,-2.4) D39(30.4,-2.4) D40(31.2,-2.4) D41(32,-2.4) D42(32.8,-2.4) D43(33.6,-2.4) D44(34.4,-2.4) D45(35.2,-2.4) D46(36,-2.4) D47(36.8,-2.4) D48(37.6,-2.4) D49(38.4,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.8,-3.2) E8(5.6,-3.2) E9(6.4,-3.2) E10(7.2,-3.2) E11(8,-3.2) E12(8.8,-3.2) E13(9.6,-3.2) E14(10.4,-3.2) E15(11.2,-3.2) E16(12,-3.2) E17(12.8,-3.2) E18(13.6,-3.2) E19(14.4,-3.2) E20(15.2,-3.2) E21(16,-3.2) E22(16.8,-3.2) E23(17.6,-3.2) E24(18.4,-3.2) E25(19.2,-3.2) E26(20,-3.2) E27(20.8,-3.2) E28(21.6,-3.2) E29(22.4,-3.2) E30(23.2,-3.2) E31(24,-3.2) E32(24.8,-3.2) E33(25.6,-3.2) E34(26.4,-3.2) E35(27.2,-3.2) E36(28,-3.2) E37(28.8,-3.2) E38(29.6,-3.2) E39(30.4,-3.2) E40(31.2,-3.2) E41(32,-3.2) E42(32.8,-3.2) E43(33.6,-3.2) E44(34.4,-3.2) E45(35.2,-3.2) E46(36,-3.2) E47(36.8,-3.2) E48(37.6,-3.2) E49(38.4,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F8(5.6,-4) F9(6.4,-4) F11(8,-4) F12(8.8,-4) F14(10.4,-4) F15(11.2,-4) F17(12.8,-4) F18(13.6,-4) F20(15.2,-4) F21(16,-4) F23(17.6,-4) F24(18.4,-4) F26(20,-4) F27(20.8,-4) F29(22.4,-4) F30(23.2,-4) F32(24.8,-4) F33(25.6,-4) F35(27.2,-4) F36(28,-4) F38(29.6,-4) F39(30.4,-4) F41(32,-4) F42(32.8,-4) F44(34.4,-4) F45(35.2,-4) F46(36,-4) F47(36.8,-4) F48(37.6,-4) F49(38.4,-4) G2(0.8,-4.8) G4(2.4,-4.8) G5(3.2,-4.8) G8(5.6,-4.8) G9(6.4,-4.8) G11(8,-4.8) G12(8.8,-4.8) G14(10.4,-4.8) G15(11.2,-4.8) G17(12.8,-4.8) G18(13.6,-4.8) G20(15.2,-4.8) G21(16,-4.8) G23(17.6,-4.8) G24(18.4,-4.8) G26(20,-4.8) G27(20.8,-4.8) G29(22.4,-4.8) G30(23.2,-4.8) G32(24.8,-4.8) G33(25.6,-4.8) G35(27.2,-4.8) G36(28,-4.8) G38(29.6,-4.8) G39(30.4,-4.8) G41(32,-4.8) G42(32.8,-4.8) G45(35.2,-4.8) G46(36,-4.8) G48(37.6,-4.8) H1(0,-5.6) H2(0.8,-5.6) H3(1.6,-5.6) H4(2.4,-5.6) H5(3.2,-5.6) H6(4,-5.6) H7(4.8,-5.6) H8(5.6,-5.6) H9(6.4,-5.6) H10(7.2,-5.6) H11(8,-5.6) H12(8.8,-5.6) H13(9.6,-5.6) H14(10.4,-5.6) H15(11.2,-5.6) H16(12,-5.6) H17(12.8,-5.6) H18(13.6,-5.6) H19(14.4,-5.6) H20(15.2,-5.6) H21(16,-5.6) H22(16.8,-5.6) H23(17.6,-5.6) H24(18.4,-5.6) H25(19.2,-5.6) H26(20,-5.6) H27(20.8,-5.6) H28(21.6,-5.6) H29(22.4,-5.6) H30(23.2,-5.6) H31(24,-5.6) H32(24.8,-5.6) H33(25.6,-5.6) H34(26.4,-5.6) H35(27.2,-5.6) H36(28,-5.6) H37(28.8,-5.6) H38(29.6,-5.6) H39(30.4,-5.6) H40(31.2,-5.6) H41(32,-5.6) H42(32.8,-5.6) H43(33.6,-5.6) H44(34.4,-5.6) H45(35.2,-5.6) H46(36,-5.6) H47(36.8,-5.6) H48(37.6,-5.6) H49(38.4,-5.6) J1(0,-6.4) J2(0.8,-6.4) J3(1.6,-6.4) J4(2.4,-6.4) J5(3.2,-6.4) J6(4,-6.4) J7(4.8,-6.4) J8(5.6,-6.4) J11(8,-6.4) J12(8.8,-6.4) J13(9.6,-6.4) J14(10.4,-6.4) J15(11.2,-6.4) J16(12,-6.4) J17(12.8,-6.4) J18(13.6,-6.4) J19(14.4,-6.4) J20(15.2,-6.4) J21(16,-6.4) J22(16.8,-6.4) J23(17.6,-6.4) J24(18.4,-6.4) J25(19.2,-6.4) J26(20,-6.4) J27(20.8,-6.4) J28(21.6,-6.4) J29(22.4,-6.4) J30(23.2,-6.4) J31(24,-6.4) J32(24.8,-6.4) J33(25.6,-6.4) J34(26.4,-6.4) J35(27.2,-6.4) J36(28,-6.4) J37(28.8,-6.4) J38(29.6,-6.4) J39(30.4,-6.4) J42(32.8,-6.4) J43(33.6,-6.4) J44(34.4,-6.4) J45(35.2,-6.4) J46(36,-6.4) J47(36.8,-6.4) J48(37.6,-6.4) J49(38.4,-6.4) K2(0.8,-7.2) K4(2.4,-7.2) K5(3.2,-7.2) K8(5.6,-7.2) K14(10.4,-7.2) K15(11.2,-7.2) K17(12.8,-7.2) K18(13.6,-7.2) K20(15.2,-7.2) K21(16,-7.2) K23(17.6,-7.2) K24(18.4,-7.2) K26(20,-7.2) K27(20.8,-7.2) K29(22.4,-7.2) K30(23.2,-7.2) K32(24.8,-7.2) K33(25.6,-7.2) K35(27.2,-7.2) K36(28,-7.2) K42(32.8,-7.2) K45(35.2,-7.2) K46(36,-7.2) K48(37.6,-7.2) L1(0,-8) L2(0.8,-8) L3(1.6,-8) L4(2.4,-8) L5(3.2,-8) L6(4,-8) L7(4.8,-8) L8(5.6,-8) L9(6.4,-8) L13(9.6,-8.2) L14(10.4,-8.2) L15(11.2,-8.2) L16(12,-8.2) L17(12.8,-8.2) L18(13.6,-8.2) L19(14.4,-8.2) L20(15.2,-8.2) L21(16,-8.2) L22(16.8,-8.2) L23(17.6,-8.2) L24(18.4,-8.2) L25(19.2,-8.2) L26(20,-8.2) L27(20.8,-8.2) L28(21.6,-8.2) L29(22.4,-8.2) L30(23.2,-8.2) L31(24,-8.2) L32(24.8,-8.2) L33(25.6,-8.2) L34(26.4,-8.2) L35(27.2,-8.2) L36(28,-8.2) L37(28.8,-8.2) L41(32,-8) L42(32.8,-8) L43(33.6,-8) L44(34.4,-8) L45(35.2,-8) L46(36,-8) L47(36.8,-8) L48(37.6,-8) L49(38.4,-8) M1(0,-8.8) M2(0.8,-8.8) M3(1.6,-8.8) M4(2.4,-8.8) M5(3.2,-8.8) M6(4,-8.8) M7(4.8,-8.8) M8(5.6,-8.8) M9(6.4,-8.8) M41(32,-8.8) M42(32.8,-8.8) M43(33.6,-8.8) M44(34.4,-8.8) M45(35.2,-8.8) M46(36,-8.8) M47(36.8,-8.8) M48(37.6,-8.8) M49(38.4,-8.8) N2(0.8,-9.6) N4(2.4,-9.6) N5(3.2,-9.6) N8(5.6,-9.6) N9(6.4,-9.6) N11(8.2,-9.6) N39(30.2,-9.6) N41(32,-9.6) N42(32.8,-9.6) N45(35.2,-9.6) N46(36,-9.6) N48(37.6,-9.6) P1(0,-10.4) P2(0.8,-10.4) P3(1.6,-10.4) P4(2.4,-10.4) P5(3.2,-10.4) P6(4,-10.4) P7(4.8,-10.4) P8(5.6,-10.4) P9(6.4,-10.4) P10(7.2,-10.4) P11(8.2,-10.4) P39(30.2,-10.4) P40(31.2,-10.4) P41(32,-10.4) P42(32.8,-10.4) P43(33.6,-10.4) P44(34.4,-10.4) P45(35.2,-10.4) P46(36,-10.4) P47(36.8,-10.4) P48(37.6,-10.4) P49(38.4,-10.4) R1(0,-11.2) R2(0.8,-11.2) R3(1.6,-11.2) R4(2.4,-11.2) R5(3.2,-11.2) R6(4,-11.2) R7(4.8,-11.2) R8(5.6,-11.2) R9(6.4,-11.2) R10(7.2,-11.2) R11(8.2,-11.2) R39(30.2,-11.2) R40(31.2,-11.2) R41(32,-11.2) R42(32.8,-11.2) R43(33.6,-11.2) R44(34.4,-11.2) R45(35.2,-11.2) R46(36,-11.2) R47(36.8,-11.2) R48(37.6,-11.2) R49(38.4,-11.2) T2(0.8,-12) T4(2.4,-12) T5(3.2,-12) T8(5.6,-12) T9(6.4,-12) T11(8.2,-12) T39(30.2,-12) T41(32,-12) T42(32.8,-12) T45(35.2,-12) T46(36,-12) T48(37.6,-12) U1(0,-12.8) U2(0.8,-12.8) U3(1.6,-12.8) U4(2.4,-12.8) U5(3.2,-12.8) U6(4,-12.8) U7(4.8,-12.8) U8(5.6,-12.8) U9(6.4,-12.8) U10(7.2,-12.8) U11(8.2,-12.8) U39(30.2,-12.8) U40(31.2,-12.8) U41(32,-12.8) U42(32.8,-12.8) U43(33.6,-12.8) U44(34.4,-12.8) U45(35.2,-12.8) U46(36,-12.8) U47(36.8,-12.8) U48(37.6,-12.8) U49(38.4,-12.8) V1(0,-13.6) V2(0.8,-13.6) V3(1.6,-13.6) V4(2.4,-13.6) V5(3.2,-13.6) V6(4,-13.6) V7(4.8,-13.6) V8(5.6,-13.6) V9(6.4,-13.6) V10(7.2,-13.6) V11(8.2,-13.6) V39(30.2,-13.6) V40(31.2,-13.6) V41(32,-13.6) V42(32.8,-13.6) V43(33.6,-13.6) V44(34.4,-13.6) V45(35.2,-13.6) V46(36,-13.6) V47(36.8,-13.6) V48(37.6,-13.6) V49(38.4,-13.6) W2(0.8,-14.4) W4(2.4,-14.4) W5(3.2,-14.4) W8(5.6,-14.4) W9(6.4,-14.4) W11(8.2,-14.4) W39(30.2,-14.4) W41(32,-14.4) W42(32.8,-14.4) W45(35.2,-14.4) W46(36,-14.4) W48(37.6,-14.4) Y1(0,-15.2) Y2(0.8,-15.2) Y3(1.6,-15.2) Y4(2.4,-15.2) Y5(3.2,-15.2) Y6(4,-15.2) Y7(4.8,-15.2) Y8(5.6,-15.2) Y9(6.4,-15.2) Y10(7.2,-15.2) Y11(8.2,-15.2) Y39(30.2,-15.2) Y40(31.2,-15.2) Y41(32,-15.2) Y42(32.8,-15.2) Y43(33.6,-15.2) Y44(34.4,-15.2) Y45(35.2,-15.2) Y46(36,-15.2) Y47(36.8,-15.2) Y48(37.6,-15.2) Y49(38.4,-15.2)
  round 0.457 smd: AA14(10.2,-17.2) AA15(11.2,-17.2) AA16(12.2,-17.2) AA17(13.2,-17.2) AA18(14.2,-17.2) AA19(15.2,-17.2) AA20(16.2,-17.2) AA21(17.2,-17.2) AA22(18.2,-17.2) AA23(19.2,-17.2) AA24(20.2,-17.2) AA25(21.2,-17.2) AA26(22.2,-17.2) AA27(23.2,-17.2) AA28(24.2,-17.2) AA29(25.2,-17.2) AA30(26.2,-17.2) AA31(27.2,-17.2) AA32(28.2,-17.2) AB14(10.2,-18.2) AB15(11.2,-18.2) AB16(12.2,-18.2) AB17(13.2,-18.2) AB18(14.2,-18.2) AB19(15.2,-18.2) AB20(16.2,-18.2) AB21(17.2,-18.2) AB22(18.2,-18.2) AB23(19.2,-18.2) AB24(20.2,-18.2) AB25(21.2,-18.2) AB26(22.2,-18.2) AB27(23.2,-18.2) AB28(24.2,-18.2) AB29(25.2,-18.2) AB30(26.2,-18.2) AB31(27.2,-18.2) AB32(28.2,-18.2) AC14(10.2,-19.2) AC15(11.2,-19.2) AC16(12.2,-19.2) AC17(13.2,-19.2) AC18(14.2,-19.2) AC19(15.2,-19.2) AC20(16.2,-19.2) AC21(17.2,-19.2) AC22(18.2,-19.2) AC23(19.2,-19.2) AC24(20.2,-19.2) AC25(21.2,-19.2) AC26(22.2,-19.2) AC27(23.2,-19.2) AC28(24.2,-19.2) AC29(25.2,-19.2) AC30(26.2,-19.2) AC31(27.2,-19.2) AC32(28.2,-19.2) AD14(10.2,-20.2) AD15(11.2,-20.2) AD16(12.2,-20.2) AD17(13.2,-20.2) AD18(14.2,-20.2) AD19(15.2,-20.2) AD20(16.2,-20.2) AD21(17.2,-20.2) AD22(18.2,-20.2) AD23(19.2,-20.2) AD24(20.2,-20.2) AD25(21.2,-20.2) AD26(22.2,-20.2) AD27(23.2,-20.2) AD28(24.2,-20.2) AD29(25.2,-20.2) AD30(26.2,-20.2) AD31(27.2,-20.2) AD32(28.2,-20.2) AE14(10.2,-21.2) AE15(11.2,-21.2) AE16(12.2,-21.2) AE17(13.2,-21.2) AE18(14.2,-21.2) AE19(15.2,-21.2) AE20(16.2,-21.2) AE21(17.2,-21.2) AE22(18.2,-21.2) AE23(19.2,-21.2) AE24(20.2,-21.2) AE25(21.2,-21.2) AE26(22.2,-21.2) AE27(23.2,-21.2) AE28(24.2,-21.2) AE29(25.2,-21.2) AE30(26.2,-21.2) AE31(27.2,-21.2) AE32(28.2,-21.2) AF14(10.2,-22.2) AF15(11.2,-22.2) AF16(12.2,-22.2) AF17(13.2,-22.2) AF18(14.2,-22.2) AF19(15.2,-22.2) AF20(16.2,-22.2) AF21(17.2,-22.2) AF22(18.2,-22.2) AF23(19.2,-22.2) AF24(20.2,-22.2) AF25(21.2,-22.2) AF26(22.2,-22.2) AF27(23.2,-22.2) AF28(24.2,-22.2) AF29(25.2,-22.2) AF30(26.2,-22.2) AF31(27.2,-22.2) AF32(28.2,-22.2) AG14(10.2,-23.2) AG15(11.2,-23.2) AG16(12.2,-23.2) AG17(13.2,-23.2) AG18(14.2,-23.2) AG19(15.2,-23.2) AG20(16.2,-23.2) AG21(17.2,-23.2) AG22(18.2,-23.2) AG23(19.2,-23.2) AG24(20.2,-23.2) AG25(21.2,-23.2) AG26(22.2,-23.2) AG27(23.2,-23.2) AG28(24.2,-23.2) AG29(25.2,-23.2) AG30(26.2,-23.2) AG31(27.2,-23.2) AG32(28.2,-23.2) AH14(10.2,-24.2) AH15(11.2,-24.2) AH16(12.2,-24.2) AH17(13.2,-24.2) AH18(14.2,-24.2) AH19(15.2,-24.2) AH20(16.2,-24.2) AH21(17.2,-24.2) AH22(18.2,-24.2) AH23(19.2,-24.2) AH24(20.2,-24.2) AH25(21.2,-24.2) AH26(22.2,-24.2) AH27(23.2,-24.2) AH28(24.2,-24.2) AH29(25.2,-24.2) AH30(26.2,-24.2) AH31(27.2,-24.2) AH32(28.2,-24.2) AJ14(10.2,-25.2) AJ15(11.2,-25.2) AJ16(12.2,-25.2) AJ17(13.2,-25.2) AJ18(14.2,-25.2) AJ19(15.2,-25.2) AJ20(16.2,-25.2) AJ21(17.2,-25.2) AJ22(18.2,-25.2) AJ23(19.2,-25.2) AJ24(20.2,-25.2) AJ25(21.2,-25.2) AJ26(22.2,-25.2) AJ27(23.2,-25.2) AJ28(24.2,-25.2) AJ29(25.2,-25.2) AJ30(26.2,-25.2) AJ31(27.2,-25.2) AJ32(28.2,-25.2) AK14(10.2,-26.2) AK15(11.2,-26.2) AK16(12.2,-26.2) AK17(13.2,-26.2) AK18(14.2,-26.2) AK19(15.2,-26.2) AK20(16.2,-26.2) AK21(17.2,-26.2) AK22(18.2,-26.2) AK23(19.2,-26.2) AK24(20.2,-26.2) AK25(21.2,-26.2) AK26(22.2,-26.2) AK27(23.2,-26.2) AK28(24.2,-26.2) AK29(25.2,-26.2) AK30(26.2,-26.2) AK31(27.2,-26.2) AK32(28.2,-26.2) AL14(10.2,-27.2) AL15(11.2,-27.2) AL16(12.2,-27.2) AL17(13.2,-27.2) AL18(14.2,-27.2) AL19(15.2,-27.2) AL20(16.2,-27.2) AL21(17.2,-27.2) AL22(18.2,-27.2) AL23(19.2,-27.2) AL24(20.2,-27.2) AL25(21.2,-27.2) AL26(22.2,-27.2) AL27(23.2,-27.2) AL28(24.2,-27.2) AL29(25.2,-27.2) AL30(26.2,-27.2) AL31(27.2,-27.2) AL32(28.2,-27.2) AM14(10.2,-28.2) AM15(11.2,-28.2) AM16(12.2,-28.2) AM17(13.2,-28.2) AM18(14.2,-28.2) AM19(15.2,-28.2) AM20(16.2,-28.2) AM21(17.2,-28.2) AM22(18.2,-28.2) AM23(19.2,-28.2) AM24(20.2,-28.2) AM25(21.2,-28.2) AM26(22.2,-28.2) AM27(23.2,-28.2) AM28(24.2,-28.2) AM29(25.2,-28.2) AM30(26.2,-28.2) AM31(27.2,-28.2) AM32(28.2,-28.2) P14(10.2,-10.2) P15(11.2,-10.2) P16(12.2,-10.2) P17(13.2,-10.2) P18(14.2,-10.2) P19(15.2,-10.2) P20(16.2,-10.2) P21(17.2,-10.2) P22(18.2,-10.2) P23(19.2,-10.2) P24(20.2,-10.2) P25(21.2,-10.2) P26(22.2,-10.2) P27(23.2,-10.2) P28(24.2,-10.2) P29(25.2,-10.2) P30(26.2,-10.2) P31(27.2,-10.2) P32(28.2,-10.2) R14(10.2,-11.2) R15(11.2,-11.2) R16(12.2,-11.2) R17(13.2,-11.2) R18(14.2,-11.2) R19(15.2,-11.2) R20(16.2,-11.2) R21(17.2,-11.2) R22(18.2,-11.2) R23(19.2,-11.2) R24(20.2,-11.2) R25(21.2,-11.2) R26(22.2,-11.2) R27(23.2,-11.2) R28(24.2,-11.2) R29(25.2,-11.2) R30(26.2,-11.2) R31(27.2,-11.2) R32(28.2,-11.2) T14(10.2,-12.2) T15(11.2,-12.2) T16(12.2,-12.2) T17(13.2,-12.2) T18(14.2,-12.2) T19(15.2,-12.2) T20(16.2,-12.2) T21(17.2,-12.2) T22(18.2,-12.2) T23(19.2,-12.2) T24(20.2,-12.2) T25(21.2,-12.2) T26(22.2,-12.2) T27(23.2,-12.2) T28(24.2,-12.2) T29(25.2,-12.2) T30(26.2,-12.2) T31(27.2,-12.2) T32(28.2,-12.2) U14(10.2,-13.2) U15(11.2,-13.2) U16(12.2,-13.2) U17(13.2,-13.2) U18(14.2,-13.2) U19(15.2,-13.2) U20(16.2,-13.2) U21(17.2,-13.2) U22(18.2,-13.2) U23(19.2,-13.2) U24(20.2,-13.2) U25(21.2,-13.2) U26(22.2,-13.2) U27(23.2,-13.2) U28(24.2,-13.2) U29(25.2,-13.2) U30(26.2,-13.2) U31(27.2,-13.2) U32(28.2,-13.2) V14(10.2,-14.2) V15(11.2,-14.2) V16(12.2,-14.2) V17(13.2,-14.2) V18(14.2,-14.2) V19(15.2,-14.2) V20(16.2,-14.2) V21(17.2,-14.2) V22(18.2,-14.2) V23(19.2,-14.2) V24(20.2,-14.2) V25(21.2,-14.2) V26(22.2,-14.2) V27(23.2,-14.2) V28(24.2,-14.2) V29(25.2,-14.2) V30(26.2,-14.2) V31(27.2,-14.2) V32(28.2,-14.2) W14(10.2,-15.2) W15(11.2,-15.2) W16(12.2,-15.2) W17(13.2,-15.2) W18(14.2,-15.2) W19(15.2,-15.2) W20(16.2,-15.2) W21(17.2,-15.2) W22(18.2,-15.2) W23(19.2,-15.2) W24(20.2,-15.2) W25(21.2,-15.2) W26(22.2,-15.2) W27(23.2,-15.2) W28(24.2,-15.2) W29(25.2,-15.2) W30(26.2,-15.2) W31(27.2,-15.2) W32(28.2,-15.2) Y14(10.2,-16.2) Y15(11.2,-16.2) Y16(12.2,-16.2) Y17(13.2,-16.2) Y18(14.2,-16.2) Y19(15.2,-16.2) Y20(16.2,-16.2) Y21(17.2,-16.2) Y22(18.2,-16.2) Y23(19.2,-16.2) Y24(20.2,-16.2) Y25(21.2,-16.2) Y26(22.2,-16.2) Y27(23.2,-16.2) Y28(24.2,-16.2) Y29(25.2,-16.2) Y30(26.2,-16.2) Y31(27.2,-16.2) Y32(28.2,-16.2)
PANAS_ETQP4LR15AFM_4P
  custom 0.686x0.686 smd: 1(0,0) 4(8.357,0)
  rect 2.21x0.508 smd: 2(1.448,0) 3(6.909,0)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI6CEQ20200LIEX_TSSOP20
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(5.85,5.8) 12(5.2,5.8) 13(4.55,5.8) 14(3.9,5.8) 15(3.25,5.8) 16(2.6,5.8) 17(1.95,5.8) 18(1.3,5.8) 19(0.65,5.8) 20(0,5.8)
PS0612FKM070R005Z_1206-LE
  rect 0.991x2.311 smd: 1(0,0) 4(1.75,0)
  rect 0.991x0.787 smd: 2(0,1.94) 3(1.75,1.94)
PS8407ATQFN40GTR2A0_TQFN40_5X5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,5.1) 22(3.2,5.1) 23(2.8,5.1) 24(2.4,5.1) 25(2,5.1) 26(1.6,5.1) 27(1.2,5.1) 28(0.8,5.1) 29(0.4,5.1) 30(0,5.1)
  oval 0.889x0.203 smd: 11(4.35,0.75) 12(4.35,1.15) 13(4.35,1.55) 14(4.35,1.95) 15(4.35,2.35) 16(4.35,2.75) 17(4.35,3.15) 18(4.35,3.55) 19(4.35,3.95) 20(4.35,4.35) 31(-0.75,4.35) 32(-0.75,3.95) 33(-0.75,3.55) 34(-0.75,3.15) 35(-0.75,2.75) 36(-0.75,2.35) 37(-0.75,1.95) 38(-0.75,1.55) 39(-0.75,1.15) 40(-0.75,0.75)
  rect 3.607x3.607 smd: 41(1.8,2.55)
PS8520BTQFN20GTR2_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
