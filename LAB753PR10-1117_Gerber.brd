# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCOUT1_PH: length 8.6
  TOP w0.127: RE85.2 296.9,14.87 v2(296.29,15.48) 295.77,16 RE82.2 294.64,16.37 291.7,16.37 291.17,15.85 UE5.103
VGA_EN: length 6.3
  BOTTOM w0.127: UM8.26 151.07,133.87 150.83,134.11 150.83,134.63 150.69,134.77 150.69,135.93 151.17,136.41 RM87.1 150.28,137.7 RM14.2 150.28,138.19 v1(150.81,138.72)
VGA_SMB_CK2: length 26.5
  TOP w0.127: QV13.4 165.31,51.9 165.4,51.81 RV191.1 165.88,52.73 v1(166.02,52.87) 166.02,53.91 v3(165.9,54.02)
  IN5 w0.099: v3(165.9,54.02) 165.71,54.21 164.83,54.21 163.73,55.31 160.97,55.31 158.36,57.92 158.36,61.18 163.25,66.07 163.25,68.03 163.09,68.2 163.09,68.5 v3(162.81,68.78)
  BOTTOM w0.089: 163.09,69.06 163.2,69.17 UV1.BF3
  BOTTOM w0.1: 163.09,69.06 v3(162.81,68.78)
VGA_SMB_DA2: length 26.2
  TOP w0.127: v3(165.91,54.63) 165.55,54.27 RV192.1 164.02,53.63 163.86,53.63 163.43,53.2 QV13.1
  IN5 w0.099: v3(163.6,68.78) 163.31,68.49 163.31,68.29 163.48,68.12 163.48,65.98 158.59,61.09 158.59,58.02 161.07,55.54 163.82,55.54 164.92,54.44 165.71,54.44 165.9,54.63 v3(165.91,54.63)
  BOTTOM w0.1: v3(163.6,68.78) UV1.BE3
VID_PLLVDD: length 56.8
  TOP w0.254: CV76.1 170.58,88.2 v3(170,88.78) ; CV80.1 170.52,89.06 v3(170,89.58)
  IN1 w0.508: v3(152.69,95.66) 152.78,95.66 v3(153.27,96.16) 155.53,98.41 166.17,98.41 170.06,94.53 170.06,92.98 170.72,92.32 170.72,90.29 v3(170,89.58) v3(170,88.78)
  IN6 w0.508: v3(170,88.78) v3(170,89.58) 170.72,90.29 170.72,92.32 169.41,93.63 169.41,94.4 165.38,98.43 155.54,98.43 v3(153.27,96.16) 152.78,95.66 v3(152.69,95.66)
  BOTTOM w0.305: UV1.AW28 169.4,89.58 v3(170,89.58) ; v3(170,88.78) 169.4,88.78 UV1.AW27
  vias: v1(153.21,95.63)
VIDALERT_N: length 60.9
  TOP w0.127: RC48.1 RC47.2 89.28,109.6 v2(89.93,110.25) 99.43,119.75 99.43,120.45 99.93,120.95 v3(99.97,120.95)
  IN1 w0.099: v3(134.81,132.04) 132.92,132.04 131.16,130.28 129.25,130.28 127.3,132.23 109.23,132.23 101.95,124.94 101.95,122.27 100.63,120.95 v3(99.97,120.95)
  BOTTOM w0.127: PR506.1 135.11,132.04 v3(134.81,132.04)
VIDSCLK: length 83.4
  TOP w0.127: v3(87.12,106.91) 87.12,109.31 v2(97.63,119.82) 98.11,120.3 v3(98.9,120.3) ; PR508.1 138.18,132.22 v3(138.39,132.44)
  IN1 w0.099: v3(138.39,132.44) 137.97,132.02 136.17,132.02 135.57,132.62 132.68,132.62 130.9,130.84 129.48,130.84 127.53,132.79 109,132.79 101.39,125.18 101.39,122.5 100.58,121.69 99.91,121.69 98.9,120.68 v3(98.9,120.3)
  IN6 w0.089: 90.81,96.93 91.76,95.98 92.93,95.98 v3(93.42,96.47)
  IN6 w0.099: 90.81,96.93 88.23,99.51 88.23,105.81 v3(87.12,106.91)
  BOTTOM w0.089: CPU1.J52 v3(93.42,96.47)
VIDSOUT: length 77
  TOP w0.127: v3(132.91,130.65) 133.74,130.65 134.69,131.6 134.94,131.6 135,131.66 PR505.1 ; RC49.1 v3(90.36,109.44) 90.36,109.86 v2(99.52,119.01) 100.01,119.51 v3(100.01,120.21)
  IN1 w0.099: v3(100.01,120.21) 100.67,120.21 102.51,122.04 102.51,124.71 109.47,131.67 127.07,131.67 129.02,129.72 131.99,129.72 v3(132.91,130.65)
  IN6 w0.089: 90.81,97.94 91.53,97.22 92.42,97.22 92.78,96.86 94.43,96.86 v3(94.81,96.49)
  IN6 w0.099: v3(90.36,109.44) 88.84,107.91 88.84,99.91 90.81,97.94
  BOTTOM w0.089: CPU1.J50 v3(94.81,96.49)
VL:
  vias: v1(26.76,29.2)
VR_HOT#: length 254.4
  TOP w0.127: RE78.2 296.93,22.51 v3(296.94,22.52) v1(296.94,23.07)
  IN1 w0.099: v3(144.58,128.65) 145.09,128.15 154.04,128.15 155.12,127.07 v3(156.14,127.07)
  IN4 w0.089: 231.02,34.66 230.52,34.66 230.18,35 230.18,36.84 229.55,37.47 228.09,37.47 227.7,37.07 225.52,37.07 224.83,37.76 218.24,37.76 217.43,38.57 213.83,38.57 213.05,37.79 209.04,37.79
  IN4 w0.091: 209.04,37.79 208.53,37.79 208.12,37.38 203.6,37.38 202.58,38.39 202.58,46.69 205.13,49.23 v3(205.13,53.89) ; v3(161.98,77.56) 161.98,78.08 162.64,78.74 162.64,81.08 163.16,81.61 163.16,82.86 162.78,83.25 162.78,85.82 163.16,86.2 163.16,86.84 162.71,87.29 162.71,88.13 163.19,88.6 163.19,89.04 162.77,89.47 162.77,90.58 163.19,91 163.19,91.55 162.87,91.87 162.87,93.1 163.19,93.42 163.19,93.89 162.63,94.45 162.63,96.2 162.26,96.57 161.36,96.57 160.39,97.54 160.39,98.45 159.86,98.99 159.86,101.39 159.67,101.58 159.67,112.57 159.31,112.93 159.31,124.77 157.02,127.07 v3(156.14,127.07) ; v3(296.94,22.52) 296.04,23.42 291.73,23.42 289.6,21.29 285.98,21.29 283.5,23.76 282.95,23.76 282.87,23.69 281.73,23.69 280.12,22.07 274.16,22.07 273.74,22.5 271.34,22.5 271.14,22.3 264.81,22.3 264.14,22.97 263.83,22.97 260.73,26.08 258.31,26.08 253.83,30.56 245.33,30.56 242.23,33.66 242.23,34.01 241.56,34.69 235.96,34.69 235.57,34.3 232.08,34.3 231.73,34.66 231.02,34.66
  IN6 w0.089: 177.05,66.34 175.85,67.54 172.23,67.54 168.92,70.84 165.91,70.84 163.37,73.38 163.37,74.4 161.98,75.79 v3(161.98,77.56)
  IN6 w0.099: 177.05,66.34 179.68,63.72 180.75,63.72 183.19,61.28 186.16,61.28 188.49,58.95 195.17,58.95 201.12,53 204.24,53 v3(205.13,53.89)
  BOTTOM w0.127: PR527.2 141.73,129.94 141.73,129.32 141.8,129.25 PC510.1 141.17,128.23 ; 141.17,128.23 PR524.1 ; 141.17,128.23 141.29,128.11 144.03,128.11 v3(144.58,128.65)
VR_HOT#1: length 2
  BOTTOM w0.127: PU500.5 139.76,128.45 v3(139.89,128.45) 140.1,128.45 PR524.2
VR_ON: length 3.6
  BOTTOM w0.127: v1(138.19,131.8) 138.19,131.15 PR511.2
  BOTTOM w0.203: PR511.2 138.65,129.03 PU500.2
VSB_N_001: length 6.3
  TOP w0.127: v1(66.95,20.57) 67.34,20.18 PR13.2
  TOP w0.254: PQ3.3 66.48,16.55 66.14,16.88 PC10.2 66.14,18.02 PR12.2 PR13.2
VSB_N_002: length 4.7
  TOP w0.127: PQ4.2 71.4,16.5 v1(72.13,17.22)
  TOP w0.254: PR17.2 69.02,14.98 PC12.1 69.93,16.13 70.3,16.5 PQ4.2
VSB_N_003: length 4.5
  TOP w0.127: v1(68.72,20.61) 68.25,20.14 PR13.1
  TOP w0.254: PR13.1 67.95,18.85 67.95,17.6 68.4,17.15 PQ4.1
VTTREF_1.35V: length 2.7
  TOP w0.203: PU200.4 148.16,28.58 147.95,28.79 147.14,28.79 PC210.1
WAKE#: length 20.1
  TOP w0.127: RH48.1 222.82,19.27 v3(222.57,19.27) 222.39,19.09 RH36.2 ; v1(226.23,26.74) v3(226.23,27.83)
  IN2 w0.099: v3(226.23,27.83) 226.23,27.16 228.28,25.1 228.92,25.1 229.5,24.51 229.5,23.41 226.36,20.27 225.17,20.27 224.61,19.71 223.01,19.71 v3(222.57,19.27)
  BOTTOM w0.089: v3(226.23,27.83) 225.84,28.21 225.84,28.66 226.04,28.86 226.04,29.2 226.25,29.41 226.25,29.88 UH1.K3
WAKE_PCH#: length 81.6
  TOP w0.127: RH156.1 232.44,16.69 232.44,16.83 v1(233.43,17.82) v3(234.05,17.82) ; UE5.74 279.6,12.92 280.57,13.9 280.57,15.66 280.91,16 v3(280.91,17.08)
  IN1 w0.099: v3(224.78,33.15) 224.79,33.15 225.3,32.63 225.3,29.61 225.77,29.15 225.77,25.92 226.15,25.54 227.69,25.54 229.3,23.93 229.3,22.43 228.58,21.71 228.58,19.61 230.23,17.96 230.88,17.96 231.14,17.69 232.15,17.69 232.36,17.91 233.96,17.91 v3(234.05,17.82) 234.48,17.39 239.67,17.39 240.99,16.07 258.07,16.07 260.28,18.29 268.38,18.29 269.31,17.36 278.76,17.36 279.25,17.85 280.15,17.85 v3(280.91,17.08)
  BOTTOM w0.089: UH1.R11 224.53,33.4 v3(224.78,33.15)
WL_OFF#: length 81.9
  TOP w0.127: QN2.3 176.81,19.6 177.12,19.29 177.12,17.26 176.68,16.83 176.68,15.35 v1(178.67,13.36) v3(180.6,11.43)
  IN6 w0.099: v3(233.43,31.42) 233.29,31.28 233.29,29.22 230.2,26.14 230.2,23.52 227.51,20.83 222.52,20.83 221.68,19.99 221.68,18.87 219.52,16.72 218.12,16.72 215.06,13.66 207.49,13.66 206.47,14.68 203.88,14.68 203.39,15.16 195.76,15.16 191.33,10.73 181.3,10.73 v3(180.6,11.43)
  BOTTOM w0.089: UH1.A10 230.47,33.01 231.17,33.01 231.42,33.26 231.55,33.26 231.57,33.24 231.59,33.24
  BOTTOM w0.127: 231.59,33.24 231.76,33.24 233.43,31.57 v3(233.43,31.42) 234.05,30.8 RH61.2
WL_OFF#_R: length 6.7
  TOP w0.127: QN2.1 173.93,18.95 173.59,19.29 RN5.2 173.59,20.1 v1(171.88,21.81) 171.88,22.2 v3(172.09,22.41)
  BOTTOM w0.127: JWLAN1.48 172.22,22.28 v3(172.09,22.41)
WLAN_LED#: length 8.6
  TOP w0.127: QN5.3 168.34,29.64 RN26.2 v1(170.92,29.64) v3(171.78,30.51)
  BOTTOM w0.127: v3(171.78,30.51) 171.78,32.04 172.24,32.5 172.89,32.5 173.11,32.28 JWLAN1.16
WLAN_WAKE#: length 170.3
  TOP w0.127: v3(175.77,7.66) 175.77,9.87 v2(175.17,10.47) 173.35,10.47 169.48,14.34 169.48,16.45 v3(167.87,18.06) ; v3(289.57,29.19) 289.35,29.19 288.7,29.85 RE92.1 288.47,29.24 288.76,28.95 288.76,28.59 288.4,28.22 UE5.1
  IN5 w0.099: v3(292.24,7.24) 290.64,5.64 208.43,5.64 202.61,11.47 197.94,11.47 192.92,6.44 176.43,6.44 175.77,7.1 v3(175.77,7.66)
  BOTTOM w0.127: JWLAN1.47 167.25,22.53 167.87,21.91 v3(167.87,18.06) ; v3(289.57,29.19) 292.69,26.08 292.69,7.69 v3(292.24,7.24)
WLANCLK_REQ#: length 96.5
  TOP w0.089: v1(223.8,28.96) v3(224.17,28.59)
  TOP w0.127: v3(227.36,16.02) 227.16,15.83 RH78.2
  IN1 w0.099: v3(224.17,28.59) 224.55,28.21 224.55,27.71 224.42,27.58 224.42,26.05 224.86,25.61 224.86,24.76 225.95,23.67 225.95,18.68 226.43,18.2 226.43,16.95 v3(227.36,16.02)
  IN6 w0.099: v3(224.17,28.59) 223.71,29.05 222.16,29.05 219.47,26.35 217.11,26.35 215.03,24.27 215.03,22.33 213.22,20.53 212.35,20.53 211.1,19.27 206.42,19.27 206.11,18.96 200.82,18.96 199.94,18.08 194.56,18.08 193.37,16.89 192.9,16.89 190.36,14.35 183.47,14.35 182.84,14.98 179.91,14.98 179.78,15.1 169.63,15.1 169.28,14.76 166.22,14.76 v3(165.81,14.35)
  BOTTOM w0.089: UH1.T3 223.91,29.52 224.22,29.21 224.22,28.64 v3(224.17,28.59)
  BOTTOM w0.127: v3(165.81,14.35) 166.25,14.78 168.89,14.78 169.18,15.08 169.18,15.57 168.7,16.05 168.7,17.1 168.29,17.5 168.29,21.97 167.23,23.03 JWLAN1.45
WLES ON/OFF LED#: length 173.4
  TOP w0.127: JPWR1.29 187.15,146.81 187.38,146.59 187.38,141.71 188.15,140.93 188.15,134.48 v3(187.28,133.61) ; v3(168.47,36.16) v1(167.88,36.16) 165.62,33.9 QN4.1 165.62,31.7 RN27.2 164.76,30.18 QN5.1
  IN4 w0.089: 159.49,66.34 159.49,77.4 160.29,78.2 160.29,81.87 160.57,82.15 160.57,95.82 159.33,97.06
  IN4 w0.091: 159.33,97.06 159.06,97.33 159.06,97.86 158.49,98.42 158.49,100.12 155.75,102.86 155.75,114.7 150.33,120.12 150.33,123.74 152.06,125.47 152.06,127.56 152.38,127.89 ; 159.49,66.34 159.49,64.2 157.31,62.03 157.31,56.08 160.75,52.64 161.84,52.64 163.55,50.93 164.64,50.93 166.6,48.97 166.6,43.84 168.47,41.98 v3(168.47,36.16) ; v3(187.28,133.61) 185.24,133.61 184.83,133.19 179.72,133.19 179.28,132.74 175.74,132.74 175.16,133.33 170.23,133.33 170.03,133.52 170.03,134.55 169.39,135.19 168.53,135.19 168.34,135.38 168.34,136.06 167,137.4 159.89,137.4 158.34,135.85 155.23,135.85 153.66,134.28 153.66,129.16
  IN4 w0.112: 152.38,127.89 153.66,129.16
XDP_BPM#0_R: length 1.2
  TOP w0.089: v3(94.07,92.47) 93.9,92.29 T127.1
  BOTTOM w0.089: v3(94.07,92.47) 94.47,92.07 CPU1.R51
XDP_BPM#1_R: length 3.5
  TOP w0.089: T128.1 92.59,92.86 94.37,92.86 v3(94.77,92.46)
  BOTTOM w0.089: CPU1.R50 95.17,92.07 v3(94.77,92.46)
XDP_BPM#2: length 1.9
  TOP w0.089: T4.1 96.47,93.22 95.52,93.22 v3(95.51,93.24)
  BOTTOM w0.089: CPU1.P49 v3(95.51,93.24)
XDP_BPM#3: length 1.3
  TOP w0.089: v3(94.81,94.05) 94.81,94.83 T5.1
  BOTTOM w0.089: CPU1.N50 v3(94.81,94.05)
XDP_BPM#4: length 1.1
  TOP w0.089: T6.1 95.13,92.81 v3(95.49,92.44)
  BOTTOM w0.089: CPU1.R49 v3(95.49,92.44)
XDP_BPM#5: length 4.8
  BOTTOM w0.127: T7.1 89.75,93.75 90.77,92.74 91.82,92.74 92.08,92.48 92.68,92.48 CPU1.P53
XDP_BPM#6: length 7.9
  TOP w0.089: v3(94.09,91.65) 93.71,91.28 93.22,91.28 92.71,91.78 91.63,91.78 91.16,92.25 90.81,92.25
  TOP w0.127: T8.1 89.03,93.25 90.02,92.25 90.81,92.25
  BOTTOM w0.089: CPU1.U51 94.47,91.28 v3(94.09,91.65)
XDP_BPM#7: length 1.2
  TOP w0.089: T9.1 93.79,93.65 v3(94.16,93.28)
  BOTTOM w0.089: v3(94.16,93.28) 94.47,92.97 CPU1.P51
XDP_DBRESET#: length 241.4
  TOP w0.127: v3(213.54,25.06) 213.76,25.28 213.76,26.35 RH32.1 ; v3(87.31,100.29) v2(87.31,100.99)
  IN1 w0.099: v3(87.31,100.29) 87.31,94.44 74.93,82.06 74.93,64.87 71.33,61.27 71.33,55.25 74.86,51.72 v3(75,51.72)
  IN6 w0.099: v3(213.54,25.06) 212.18,23.7 212.18,22.7 210.5,21.02 207.19,21.02 206.67,20.5 206.05,20.5 205.68,20.13 200.07,20.13 199.38,19.44 193.58,19.44 192.38,18.24 191.71,18.24 190.6,17.13 189.56,17.13 189.02,16.59 180.32,16.59 180.26,16.66 178.15,16.66 177.99,16.82 177.19,16.82 177.04,16.67 175.1,16.67 174.05,15.62 169.78,15.62 169.36,16.04 166.52,16.04 165.69,15.21 160.16,15.21 159.58,15.78 155.78,15.78 154.29,17.27 152.88,17.27 152.17,17.99 142.34,17.99 141.11,16.76 81.05,16.76 80.79,17.02 79.61,18.21 79.61,23.63 79.01,24.22 77.53,24.22 74.93,26.82 73.53,26.82 71.34,29.01 71.34,36.05 73.3,38.01 73.3,50.02 v3(75,51.72)
  BOTTOM w0.127: RC17.2 v3(87.31,100.29)
XDP_DBRESET#_R: length 7.3
  BOTTOM w0.089: 91.66,98.1 91.97,98.1 92.03,98.16 92.72,98.16 CPU1.F53
  BOTTOM w0.102: 91.66,98.1 90.81,98.1
  BOTTOM w0.127: RC27.2 88.04,98.59 v1(88.04,98.26) ; RC27.2 90.15,98.1 90.81,98.1 ; RC27.2 RC17.1
XDP_PRDY#: length 4.8
  TOP w0.127: v3(92.71,93.25) 92.3,93.66 91.73,93.66 91.19,94.2 89.03,94.2 T93.1
  BOTTOM w0.089: CPU1.N53 93.07,93.6 v3(92.71,93.25)
XDP_PREQ#: length 4.5
  TOP w0.127: T94.1 90.74,95.02 92.52,95.02 v3(93.41,94.13)
  BOTTOM w0.089: CPU1.N52 93.77,93.78 v3(93.41,94.13)
XDP_TCLK: length 5.3
  BOTTOM w0.127: T124.1 89.47,94.64 90.42,93.69 91.82,93.69 91.82,93.69 CPU1.N54
XDP_TDI_R: length 1.1
  TOP w0.089: v3(95.51,94.05) 95.61,93.94 T125.1
  BOTTOM w0.089: v3(95.51,94.05) CPU1.N49
XDP_TDO_R: length 1.2
  TOP w0.089: T126.1 96.3,95.02 v3(96.2,94.93)
  BOTTOM w0.089: v3(96.2,94.93) 95.87,94.6 CPU1.M49
XDP_TMS: length 3.3
  TOP w0.127: T2.1 91.89,95.47 93.54,95.47 v3(94.11,94.9)
  BOTTOM w0.089: CPU1.M51 94.47,94.54 v3(94.11,94.9)
XDP_TRST#: length 5.4
  TOP w0.127: T3.1 89.47,94.64 92.19,94.64 v3(92.72,94.11)
  BOTTOM w0.089: CPU1.M53 93.07,94.46 v3(92.72,94.11)
XTAL25_IN: length 6.3
  BOTTOM w0.089: 218.59,48.48 217.93,47.82 217.93,47.54 217.82,47.42 UH1.AL44
  BOTTOM w0.127: 218.59,48.48 218.82,48.71 v1(218.82,49.51) 218.82,50.08 218.52,50.38 RH84.2 CH9.2 218.52,52.19 YH2.1
XTAL25_OUT: length 11.1
  BOTTOM w0.089: UH1.AM43 217.41,47.28 217.74,47.61 217.74,47.91 217.93,48.1 217.93,48.45 217.96,48.48
  BOTTOM w0.127: 217.96,48.48 218.11,48.63 218.11,49.94 RH84.1 216.38,50.45 CH8.2 216.05,51.89 216.65,51.89 216.88,52.12 216.88,53.23 YH2.3
XTAL_OUT: length 8.3
  BOTTOM w0.127: YV1.3 169.1,62.34 169.1,63.81 CV73.2 169.6,65.21 RV52.2 169.29,65.52 169.29,66.09 168.65,66.74 168.04,66.74 167.2,67.57 UV1.BA1
XTALIN: length 7.3
  BOTTOM w0.127: UV1.BB2 166.78,68 166.78,67.31 166.78,67.31 166.78,66.61 167.23,66.16 168.4,66.16 168.65,65.91 RV52.1 168.65,64.33 CV74.2 168.68,63.73 YV1.1
XTALOUT: length 11.1
  TOP w0.127: RV51.1 157.34,65.88 157.74,66.27 v2(161.29,66.27) 161.5,66.07 165.21,66.07 v3(166.17,67.02)
  BOTTOM w0.089: v3(166.17,67.02) 166.4,67.26 UV1.BB1
XTALSSIN: length 11.8
  TOP w0.127: v3(166.77,68.8) v2(166.2,68.23) 165.26,68.23 164.59,67.57 161.57,67.57 161.11,67.11 156.61,67.11 RV49.1
  BOTTOM w0.089: UV1.BB3 166.4,69.16 v3(166.77,68.8)
XTLI: length 4.7
  TOP w0.127: UL1.8 319.45,31.02 320.37,30.1 v1(320.45,30.1) 320.47,30.08 320.47,29.3 CL8.2 320.79,28.36 YL1.1
XTLO: length 6.6
  TOP w0.127: YL1.3 320.23,27.06 320.23,28.62 CL9.2 320.22,29.34 320.22,29.84 319.05,31.01 UL1.7
N3691692: length 2.5
  BOTTOM w0.127: v1(247.27,23.45) PR302.2
  BOTTOM w0.254: PR302.2 247.27,25.49 PC305.1
N3691782: length 2.8
  BOTTOM w0.127: v1(258.97,25.63) 257.08,27.52 PR305.2
N4123408: length 2.5
  TOP w0.127: PR108.1 25.59,24.22 v1(25.92,23.89)
  TOP w0.254: PC105.2 24.63,24.21 PR108.1
N4123550: length 1.7
  TOP w0.127: v1(34.84,17.55) 34.55,17.85 PR110.2
N4123582: length 1.3
  TOP w0.508: PC110.1 PR111.2
N14137547: length 4.3
  TOP w0.127: v1(22.05,34.25) 21.81,34.01 21.81,32.63 PR107.1
  TOP w0.203: PU100.19 23.04,31.03 22.66,31.41 22.66,31.78 PR107.1
N16767833: length 8.4
  TOP w0.127: v1(25.87,34.52) 25.47,34.93 25.47,36.02 25.93,36.49
  TOP w0.254: PR114.2 25.93,36.49 PR100.2 PR112.2 23.17,36.49 PC112.1 22.62,37.04 PR116.1 22.62,38.08 22.86,38.32 PR113.2 PR115.2
N16767857: length 3.1
  TOP w0.127: PR115.1 21.97,40.16 v1(21.64,40.49)
  TOP w0.254: PR115.1 21.74,39.24 PD101.1
N16768121: length 3.5
  TOP w0.127: PR113.1 22.86,39.8 v1(23.5,40.44)
  TOP w0.254: PD100.1 24.2,39.14 23.87,39.47 PR113.1
N16788038: length 55.9
  TOP w0.254: PR705.1 35.15,39.31 v3(34.43,39.31) 34.07,39.31 PC701.2
  IN2 w0.254: 37.16,17.93 v3(37.14,17.91) ; 37.16,17.93 37.92,18.7 42.93,18.7 v3(44.52,20.28) ; 37.16,17.93 34.76,17.93 32.23,20.46 29.02,20.46 27.23,22.25 24.18,22.25 23.43,22.99 23.43,24.49 21.91,26.01 21.91,27.13 20.64,28.4 20.64,32.6 21.44,33.4 21.44,34.8 22.67,36.03 33.96,36.03 34.91,36.98 34.91,38.83 v3(34.43,39.31)
  vias: v2(44.52,20.96)
N16788064: length 5.6
  TOP w0.254: PQ700.2 28.15,39.09 v1(30.19,39.09) 31.58,39.09 31.97,39.49 PR700.2 31.97,40.59 PR701.1
N17238594: length 33.9
  TOP w0.127: PD2.2 71.67,30.13 72.32,30.77 v2(72.32,31.19)
  TOP w0.254: v3(45.72,33.25) 45.35,32.88 PR18.1 ; PD2.2 70.96,30.7 70.7,30.95 69.74,30.95 PR19.2 69.97,30.44 v3(70.31,30.44)
  IN2 w0.254: v3(70.31,30.44) 70.21,30.44 69.55,29.78 67.34,29.78 61.94,35.18 47.65,35.18 v3(45.72,33.25)
N17244731: length 6.9
  TOP w0.127: v1(281.37,37.35) 280.64,37.35 PL2.1
  TOP w0.254: PQ7.1 283.01,35.87 282.66,35.52 PR6.2 281.61,35.12 PD1.2 280.28,36.99 PL2.1
N17272701: length 2.9
  TOP w0.127: PR642.2 190.84,27.14 v1(190.84,26.77)
  TOP w0.254: PU601.5 191.57,28.68 191.71,28.54 191.71,28 PR642.2
N17272705: length 7.3
  TOP w0.127: v1(186.65,22.6) 186.41,22.6 185.51,21.71 PR627.2
  TOP w0.254: PR627.2 PC635.2 184.58,22.56 PR629.2 183.95,23.27 181.87,23.27 181.5,23.64 PU600.11
N17272706: length 6.5
  TOP w0.254: PR622.2 184.6,20.8 PC635.1 184.15,20.79 PR624.2 183,22.67 v1(182.81,22.86) 182.79,22.87 181.68,22.87 181,23.55 PU600.10
N17407779: length 2.5
  TOP w0.127: v1(286.95,31.74) 286.65,31.74 CE36.1 RE89.1
N17434554: length 3.7
  TOP w0.127: UE5.107 291.53,17.45 v1(291.57,17.5) 292.01,17.93 292.01,18.47 RE74.2
N18016661: length 4.6
  TOP w0.127: v1(219.34,110.25) 218.98,110.62 RE25.2 218.98,112.45 219.68,113.16 UE3.24
N18017204: length 5.4
  TOP w0.127: v1(224.61,115.53) 224.61,116.14 224.21,116.55 222.77,116.55 RE31.1 221.58,117.74 UE3.30
N18168284: length 5.6
  TOP w0.127: v2(156.61,30.52) 155.7,29.62 PC207.2
  TOP w0.203: PR204.2 153.32,28.22 152.95,28.58 PU200.12
  TOP w0.254: PC207.2 154.94,29.11 PR204.2
N18410136: length 1.4
  BOTTOM w0.127: PC315.1 136.64,105.67 v1(136.45,105.48)
N18410161: length 45.3
  TOP w0.127: v3(131.07,112.22) 130.49,112.22 v2(130.18,111.9)
  IN1 w0.254: v3(157.11,117.81) 156.45,117.81 152.66,114.01 152.66,107.03 150.94,105.31 142.06,105.31 141.7,105.68 139.42,105.68 139.07,105.33 133.05,105.33 131.07,107.32 v3(131.07,112.22)
  BOTTOM w0.254: v3(157.11,117.81) 157.19,117.88 PR317.1 ; v3(131.07,112.22) 130.71,111.86 PR319.2 PR316.2
N18410178: length 3.2
  TOP w0.127: PC317.1 144.82,106.26 v1(144.59,106.03)
  TOP w0.508: PC317.1 145.79,107.84 PR314.2
N18456729: length 2.8
  TOP w0.203: PU700.20 45.38,38.19 45.53,38.34 46.23,38.34
  TOP w0.254: 46.23,38.34 47.42,38.34 PR722.1
N18456733: length 3
  TOP w0.203: PU700.19 45.54,37.79 45.68,37.94
  TOP w0.254: 45.68,37.94 v1(46.37,37.94) 46.93,37.94 PR723.1
N18456739: length 3.7
  TOP w0.203: PR709.1 45.77,39.09 v3(45.6,38.92) 45.27,38.59 PU700.21
  TOP w0.254: PR709.1 PR711.1 45.92,40.3 PQ705.3
N18456772: length 12.7
  TOP w0.203: PU700.28 41.67,39.78 41.49,39.96 v3(41.14,39.96) 40.9,40.2 PC711.2
  TOP w0.254: PR707.2 35.12,35.59 v3(34.29,35.59)
  BOTTOM w0.254: v3(34.29,35.59) 35.88,37.17 35.88,38.57 36.58,39.27 v2(37.61,39.27) 40.45,39.27 v3(41.14,39.96)
N18456789: length 2.2
  TOP w0.254: PD700.1 33.88,38.13 v3(34.32,38.56) 34.81,38.56 PR707.1
N18456799: length 1.7
  TOP w0.203: PR724.2 v3(42.21,34.4) 42.47,34.66 PU700.10
N18456859: length 1.3
  TOP w0.508: PR708.1 42.94,42.52 PC702.2
N18456884: length 5.5
  TOP w0.127: 40.41,33.82 v1(39.49,32.9)
  TOP w0.203: PR717.2 40.15,34.75 40.15,35.9 40.44,36.19 PU700.7
  TOP w0.254: PC718.2 39.51,33.82 PR717.2
N18456888: length 1.7
  TOP w0.203: PC720.2 41.67,34.2 PU700.8
N18456944: length 3.4
  TOP w0.127: v1(48.34,40.96) 47.81,41.48 PQ705.1
  TOP w0.254: PR710.2 47.37,40.7 47.37,41.56 47.63,41.81 PQ705.1
N18456952: length 1.7
  TOP w0.203: PU700.11 42.87,34.01 PR720.2
N18456954: length 1.8
  TOP w0.203: PR721.2 43.99,34.2 v3(43.74,34.44) 43.27,34.91 PU700.12
N18473450: length 4.9
  TOP w0.127: v1(174.98,31.43) 175.66,32.11 177.28,32.11 177.71,31.68 PR601.2
  TOP w0.254: PC612.1 178.92,31.18 PR601.2
N18474067: length 2.5
  TOP w0.127: PC619.1 183.59,32.1 v1(183.83,32.35)
  TOP w0.254: PC619.1 184.17,31.21 184.19,31.18 PR617.2
N18474286: length 1.4
  TOP w0.254: PC625.1 186.64,27.64 PR633.2
N18854923: length 5.8
  TOP w0.127: v1(142.38,28.79) RD15.2 143.28,27.78 v3(143.34,27.84)
  BOTTOM w0.127: JDIMM2.201 141.05,26.84 142.05,27.84 v3(143.34,27.84)
N18898834: length 32.7
  TOP w0.127: v2(46.29,33.11) v3(45.73,32.55)
  TOP w0.254: PR21.2 69.8,29.26 70.82,29.26 PD2.3 70.6,28.78 v3(70.28,28.78) ; PR20.1 44.76,31.57 v3(45.73,32.55)
  IN2 w0.254: v3(70.28,28.78) 69.67,29.39 67.19,29.39 61.78,34.8 47.98,34.8 v3(45.73,32.55)
N18903973: length 4.2
  TOP w0.127: PR22.2 68.66,27.31 v2(68.39,27.04)
  TOP w0.254: PR22.2 69.66,27.37 70.59,27.37 PR15.1 71.09,26.39 70.97,26.27 PD3.2
N19248975: length 2.2
  BOTTOM w0.127: v1(82.76,41.4) 82.09,41.4 RD10.1
  BOTTOM w0.508: C9.2 RD10.1
N19249013: length 2.6
  BOTTOM w0.127: CD21.2 v1(127.59,48.68)
  BOTTOM w0.508: RD4.1 CD21.2
N20194225: length 4
  TOP w0.127: PR606.2 180.28,20.45 v1(179.78,19.95)
  TOP w0.254: PR606.2 PR613.1 PC617.1 PR611.2
N20340292: length 2.2
  TOP w0.127: v1(175.44,20.7) 175.44,21.05 PR616.1
  TOP w0.254: PR618.1 PR616.1
N20620737: length 2.3
  TOP w0.127: 181.74,30.1 v1(181.74,32.41)
N21560268: length 2.8
  TOP w0.127: v2(75.68,19.15) 74.78,20.06 RD14.1
  TOP w0.508: CD38.2 RD14.1
N23562769: length 3.1
  TOP w0.127: QV2.1 81.36,113.4 v1(80.44,114.31)
  TOP w0.254: RV12.2 81.69,114.24 QV2.1
N23567023: length 7.6
  TOP w0.127: v3(128.83,137.1) 128.83,139.33 128.39,139.78 126.1,139.78 JHDMI1.13
  BOTTOM w0.127: RV20.2 129.31,136.62 v3(128.83,137.1)
N26316553: length 1.5
  TOP w0.127: v1(103.99,120.92) 103.63,120.56 PC502.1
N26987587: length 7.5
  TOP w0.127: UL1.5 318.25,31.03 318.15,30.93 318.15,30.22 317.48,29.54 316.8,29.54 316.6,29.34 316.6,27.75 316.17,27.32 RL2.2 316.74,26.2 v1(317.43,26.2)
N26987818: length 5.5
  TOP w0.127: RL13.2 RL14.2 322.53,75.52 v1(321.25,74.23) QL3.1
N26987825: length 43.3
  TOP w0.127: CL31.1 325.27,74.46 325.3,74.43 LL1.2 325.82,74.87 326.1,75.15 326.1,76.76 325.41,77.45 324.46,77.45 324.23,77.68 324.23,81.02 325.27,82.06 v2(326.99,82.06) 336.95,82.06 338.36,83.47 338.36,88.33 337.35,89.33 332.32,89.33 329.06,92.6 329.06,94.08 JLAN.12
N27543768:
  vias: v1(265.11,34.53)
N27591408: length 5
  BOTTOM w0.127: v1(150.73,13.63) 151.41,14.31 QN3.1 151.93,15.13 152.33,14.73 153.18,14.73 153.51,15.06 153.51,15.51 DN1.1
N27863565: length 3.4
  TOP w0.127: UN1.18 161.55,13.88 v1(161.22,13.55) 161.22,12.82 RN16.2 RN15.2
N27863791: length 2.5
  TOP w0.127: UN1.7 162.05,19.56 v1(162.33,19.85) 162.93,20.45 RN12.2
N27863843:
  vias: v1(158.76,19.84)
N27864293: length 6.6
  BOTTOM w0.127: UE2.3 255.08,34.08 v3(255.49,34.48) RE14.2
N27864303: length 3.9
  BOTTOM w0.127: UE2.6 255.08,41.26 255.39,41.57 CE20.1 RE11.1 v1(254.55,43.28)
N27864309: length 4.6
  BOTTOM w0.127: UE2.5 253.81,41.19 253.63,41.37 253.04,41.37 RE9.1 251.68,40.72 v1(250.65,40.72)
N27864330: length 4.5
  BOTTOM w0.127: RE13.2 v3(258.35,38.29) 257.39,38.29 256.35,39.33 UE2.7
N27864389: length 4
  BOTTOM w0.127: CE8.1 272,23.91 271.66,23.56 v1(271.11,23.56) 270.32,23.56 269.5,24.38
N27864390: length 3.8
  BOTTOM w0.127: CE9.1 v1(272.04,24.54) 270.47,24.54 UE1.19
N27864395: length 2.3
  BOTTOM w0.127: CE18.1 268.96,32.75 v3(268.96,32.2) 268.96,31.67 UE1.11
N27864397: length 3.6
  BOTTOM w0.127: v3(267.96,29.53) 268.93,30.5 UE1.12 269.83,31.41 CE17.1
N27864399: length 2.2
  BOTTOM w0.127: CE16.1 v3(270.46,30.91) 269.5,29.94
N27864402: length 7.4
  BOTTOM w0.127: CE15.1 270.23,27.21 v3(269.38,28.06) 269.22,28.22 269.22,28.51 270.06,29.36 UE1.14
N27864404: length 4.5
  BOTTOM w0.127: CE14.1 272.71,28.98 v1(272.65,29.05) 272.32,29.38 271.2,29.38 UE1.15
N27864406: length 4.1
  BOTTOM w0.127: CE13.1 v1(273.61,28.09) 272.79,28.09 272.04,28.84 271.8,28.84 UE1.16
N27864434: length 2.9
  BOTTOM w0.127: UE2.2 256.35,31.73 RE10.1 256.15,31.02 v1(256.63,30.53)
N27869543: length 25.3
  TOP w0.127: v2(67.64,54.61) 66.84,55.41 v3(66.79,55.41)
  IN1 w0.099: v3(66.79,55.41) 66.79,55.93 66.4,56.33 66.4,62.47 v3(66.78,62.85)
  BOTTOM w0.127: v3(66.79,55.41) 66.6,55.22 66.6,54.38 66.97,54.02 66.97,53.04 65.19,51.26 60.13,51.26 JFAN1.3 ; RF3.1 v3(66.78,62.85) 66.78,62.99 67.1,63.32 DF1.1
N27869598: length 15.5
  TOP w0.127: v2(245.41,47.49) 245.41,46.52 v3(245.18,46.28)
  BOTTOM w0.127: RF6.1 238.3,51.88 238.3,50.66 239.27,49.7 239.27,48.27 JFAN2.3 241.82,45.72 244.61,45.72 v3(245.18,46.28) 246.92,46.28 DF2.1
N28433555: length 8.8
  BOTTOM w0.089: 126.41,70.72 126.41,71.87 CPU1.BE4
  BOTTOM w0.127: T12.1 132.95,70.21 126.93,70.21 126.41,70.72
N28433558: length 9.2
  BOTTOM w0.089: 127.24,71.03 127.09,71.19 127.09,71.72 127.15,71.78 127.15,72.52 CPU1.BD3
  BOTTOM w0.127: 127.24,71.03 134.23,71.03 T14.1
N28433585: length 7
  TOP w0.089: v3(124.71,98.26) 124.73,98.24 126.88,98.24 126.95,98.16 129.52,98.16 129.8,97.88
  TOP w0.127: T16.1 129.8,97.88
  BOTTOM w0.089: CPU1.F6 124.4,98.57 v3(124.71,98.26)
N28433588: length 3.5
  TOP w0.089: v3(125.08,97.06) 125.59,96.55 T17.1
  BOTTOM w0.089: CPU1.G6 124.74,97.4 v3(125.08,97.06)
N28433591: length 1.2
  TOP w0.089: v3(114.13,98.3) 114.49,97.94 T18.1
  BOTTOM w0.089: v3(114.13,98.3) 114.28,98.16 CPU1.G21
N28433594: length 1.2
  TOP w0.089: v3(112.51,98.29) 112.7,98.1 T19.1
  BOTTOM w0.089: CPU1.G24 112.7,98.1 v3(112.51,98.29)
N28433839: length 7.5
  BOTTOM w0.089: 91.36,95 92.56,95 92.71,95.15 92.71,95.47 92.97,95.72 93.35,95.72 93.75,95.31 CPU1.L52
  BOTTOM w0.127: 91.36,95 90.14,95 88.79,96.36 T25.1
N28433842: length 5
  BOTTOM w0.089: CPU1.L53 93.07,95 92.88,94.81 91.73,94.81 91.59,94.68 90.81,94.68
  BOTTOM w0.127: T27.1 89.02,95.71 90.04,94.68 90.81,94.68
N28433845: length 1.7
  TOP w0.089: T30.1 93.75,96.04 v3(94.12,95.67)
  BOTTOM w0.089: CPU1.L51 94.47,95.32 v3(94.12,95.67)
N28433848: length 3.4
  TOP w0.089: v3(113.29,98.95) 113.71,99.36 113.71,101.08 T32.1
  BOTTOM w0.089: CPU1.F24 v3(113.29,98.95)
N28433851: length 5.2
  TOP w0.089: v3(112.48,98.95) 112.12,99.31 112.12,103.47
  TOP w0.127: 112.12,103.47 112.12,103.48 T33.1
  BOTTOM w0.089: v3(112.48,98.95) CPU1.F25
N28434861: length 1.1
  TOP w0.089: v3(94.81,95.67) 94.43,96.06 T37.1
  BOTTOM w0.089: CPU1.L50 v3(94.81,95.67)
N28434864: length 1.1
  TOP w0.089: T39.1 95.89,96.04 v3(95.52,95.67)
  BOTTOM w0.089: v3(95.52,95.67) CPU1.L49
N28434867: length 4.8
  TOP w0.089: v3(124.75,98.92) 124.91,99.07 128.51,99.07 T40.1
  BOTTOM w0.089: v3(124.75,98.92) 125.1,99.27 CPU1.E5
N28434944: length 2.1
  BOTTOM w0.127: CPU1.F1 129.06,98.36 T10.1
N28434947: length 2.6
  BOTTOM w0.127: CPU1.E1 130.29,99.23 T11.1
N28434950: length 6.1
  BOTTOM w0.127: CPU1.A5 125.92,102.68 127.55,102.68 128.46,103.6 128.46,105.67 T13.1
N28434953: length 5.4
  BOTTOM w0.127: T15.1 127.28,104.7 127.28,103.23 126.99,102.94 125.52,102.94 125.22,102.64 125.02,102.64 CPU1.A6
N28435099: length 4.5
  BOTTOM w0.127: T20.1 95.05,103.73 95.05,101.81 CPU1.B50
N28435102: length 1.2
  TOP w0.089: T21.1 96.57,83.91 v3(96.15,84.32)
  BOTTOM w0.089: CPU1.AH49 95.87,84.04 v3(96.15,84.32)
N28435105: length 1.2
  TOP w0.089: T22.1 95.9,80.84 v3(96.2,81.14)
  BOTTOM w0.089: v3(96.2,81.14) 96.36,81.3 CPU1.AM48
N28435108: length 1.1
  TOP w0.089: T23.1 109.49,78.5 v3(109.87,78.12)
  BOTTOM w0.089: CPU1.AU27 110.21,77.78 v3(109.87,78.12)
N28435111: length 1.7
  TOP w0.089: v3(110.78,78.71) 110.83,78.76 T24.1
  BOTTOM w0.089: CPU1.AU26 111.24,78.05 110.78,78.5 v3(110.78,78.71)
N28435114: length 1.4
  TOP w0.089: T26.1 126.04,72.98 v3(125.74,73.27)
  BOTTOM w0.089: CPU1.BD4 126.09,72.92 v3(125.74,73.27)
N28435129: length 1.2
  TOP w0.089: T28.1 126,73.77 v3(126.44,73.33)
  BOTTOM w0.089: v3(126.44,73.33) 126.1,73.66 CPU1.BC4
N28435132: length 2.4
  TOP w0.089: v3(125.07,81.55) 124.93,81.69 T29.1
  BOTTOM w0.089: CPU1.AL6 124.72,81.9 v3(125.07,81.55)
N28435135: length 1.8
  TOP w0.089: v3(123.84,98.9) 123.78,98.84 T31.1
  BOTTOM w0.089: CPU1.F8 123.51,98.57 v3(123.84,98.9)
N28435138: length 1.2
  TOP w0.089: T34.1 117.84,98.59 v3(118.19,98.95)
  BOTTOM w0.089: v3(118.19,98.95) 117.81,98.57 CPU1.F16
N28435141: length 3.2
  TOP w0.254: T35.1 119.74,95.51 v3(119.72,95.52)
  BOTTOM w0.089: CPU1.G12 120.45,97.7 120.1,97.35 120.1,96.66 119.62,96.18 119.62,95.62 v3(119.72,95.52)
N28435144: length 1.3
  TOP w0.089: T36.1 122.37,98.13 v3(122.26,98.23)
  BOTTOM w0.089: v3(122.26,98.23) 122.26,98.18 CPU1.G10
N28435213: length 1.7
  TOP w0.089: v3(94.81,97.3) 94.35,97.75 T38.1
  BOTTOM w0.089: v3(94.81,97.3) CPU1.H50
N28435361: length 9.3
  BOTTOM w0.127: T42.1 91.82,69.81 92.64,69 93.5,69 94.43,69.94 CPU1.BF51
N28435397: length 3.5
  BOTTOM w0.127: T44.1 130.94,99.94 CPU1.D1
N28435400: length 2.4
  BOTTOM w0.089: 90.81,99.52 91.09,99.8 91.31,99.8
  BOTTOM w0.102: 91.31,99.8 91.42,99.91 CPU1.D54
  BOTTOM w0.127: 90.81,99.52 T45.1
N28435463: length 5.3
  BOTTOM w0.127: CPU1.A4 126.47,102.43 127.93,102.43 129.61,104.1 T41.1
N28435472: length 5.6
  BOTTOM w0.127: T43.1 93.04,103.96 94.59,102.41 CPU1.A51
N28435499: length 5.7
  BOTTOM w0.089: 129.8,73.57 128.27,73.57 CPU1.BC1
  BOTTOM w0.127: 129.8,73.57 132.98,73.57 T46.1
N28435502: length 4.8
  BOTTOM w0.127: T47.1 89.03,73.5 92.36,73.5 CPU1.BC54
N28435508: length 7.3
  BOTTOM w0.127: T48.1 131.28,69.8 126.71,69.8 126.05,70.46 CPU1.BF4
N28443132: length 1.5
  TOP w0.254: T49.1 116.85,95.7 v3(116.85,95.7)
  BOTTOM w0.089: CPU1.J17 117.4,96.24 v3(116.85,95.7)
N28443135: length 1.4
  TOP w0.254: T50.1 113.74,95.79 v3(113.73,95.78)
  BOTTOM w0.089: v3(113.73,95.78) 114.28,96.32 CPU1.J21
N28443138: length 1.5
  TOP w0.254: T51.1 110.7,95.63 v3(110.7,95.63)
  BOTTOM w0.089: v3(110.7,95.63) 111.13,96.06 CPU1.J26
N28443141: length 1.5
  TOP w0.203: v3(107.71,95.57) T52.1
  BOTTOM w0.089: v3(107.71,95.57) 108.08,95.94 CPU1.J31
N28445068: length 1.3
  TOP w0.089: T53.1 108.3,81.04 v3(108.44,81.18)
  BOTTOM w0.089: CPU1.AN31 108.24,80.98 v3(108.44,81.18)
N28446375: length 1.2
  TOP w0.254: v3(113.9,81.16) 113.73,80.99 T54.1
  BOTTOM w0.089: v3(113.9,81.16) 113.79,81.05 CPU1.AN22
N28446378: length 1.2
  TOP w0.254: v3(116.61,81.18) 116.43,81 T55.1
  BOTTOM w0.089: CPU1.AN18 v3(116.61,81.18)
N28446558: length 2.5
  TOP w0.089: v3(121.45,82.41) 121.14,82.11 T56.1
  BOTTOM w0.089: CPU1.AH9 122.08,83.5 121.45,82.87 v3(121.45,82.41)
N28450396: length 1.4
  TOP w0.089: v3(107.12,81.25) 107.12,81.24 T57.1
  BOTTOM w0.089: CPU1.AN33 106.89,81.01 v3(107.12,81.25)
N28450399: length 1.4
  TOP w0.203: v3(121.63,89.95) 121.61,89.93 T58.1
  BOTTOM w0.089: v3(121.63,89.95) CPU1.W9
N28450402: length 1.1
  TOP w0.089: T59.1 96.14,79.38 v3(96.33,79.57)
  BOTTOM w0.089: v3(96.33,79.57) 96,79.24 CPU1.AR49
N28453832: length 1.7
  TOP w0.089: T60.1 95.09,91.21 v3(95.49,90.82)
  BOTTOM w0.089: v3(95.49,90.82) CPU1.V49
N28453835: length 1.1
  TOP w0.089: v3(95.49,91.63) 95.65,91.78 T61.1
  BOTTOM w0.089: v3(95.49,91.63) CPU1.U49
N28733040: length 6.3
  BOTTOM w0.127: RD7.2 137.64,42.78 137.92,42.78 v3(139.8,40.9) 139.85,40.85 JDIMM1.197
N28733045: length 6
  BOTTOM w0.127: RD8.2 140.48,43.7 141.24,42.94 v3(141.24,42.18) 141.04,41.99 JDIMM1.201
N28734882: length 4.3
  TOP w0.127: RD16.2 140.49,25.74 139.85,25.74 v1(139.75,25.85) 139.73,25.87 139.73,27.24 v3(139.83,27.35)
  BOTTOM w0.127: v3(139.83,27.35) 139.85,27.33 JDIMM2.197
N28780624: length 9.4
  BOTTOM w0.089: 221.42,27.65 221.16,27.9 221.16,28.76 UH1.AB1
  BOTTOM w0.127: RH73.2 223.94,22.3 223.94,23.03 224.02,23.1 224.02,25.41 223.85,25.58 222.44,25.58 221.66,26.36 221.66,27.4 221.42,27.65
N28780661: length 8.6
  BOTTOM w0.089: 220.06,27.38 220.06,28.64 219.85,28.85 UH1.AF1
  BOTTOM w0.127: RH75.2 220.25,21.52 220.25,24.75 220.42,24.93 220.42,26.19 220.07,26.54 220.07,27.37 220.06,27.38
N29026996: length 24.2
  TOP w0.127: JLAN.9 324.09,108.04 320.49,104.43 v2(320.49,102.67) 320.49,89.26 RL8.1
N29187218: length 4.9
  BOTTOM w0.127: UV17.3 83.91,120.43 RV45.1 81.42,122.92 v2(81.42,123.22)
N29355924: length 4.2
  BOTTOM w0.127: RM34.2 156.92,14.95 157.24,14.63 159.83,14.63 UM1.3
N29359451: length 8.8
  TOP w0.127: CU27.1 15.4,37.52 15.18,37.75 13.65,37.75 13.34,38.06 v1(13.34,38.51) v3(13.78,38.95) 14.3,38.95 14.37,38.89 15.33,38.89
  BOTTOM w0.127: v3(13.78,38.95) 14.29,38.44 DU8.2 15.24,38.44 15.74,38.94 RU5.2
N29389682: length 2.7
  TOP w0.127: v1(151.75,13.31) RE32.2 151.74,14.52 UE4.24
N29389707: length 1.4
  TOP w0.127: RE37.1 153.9,19.26 UE4.30
N29566756: length 4
  BOTTOM w0.127: R181.2 141.03,11.5 v1(142.24,12.71) 142.71,13.17 U2407.7
N29973818: length 12.5
  TOP w0.127: RV66.1 155.48,72.8 157.81,72.8 158.59,72.02 v2(161.2,72.02) 161.67,71.54 164.77,71.54 v3(165.6,72.38)
  BOTTOM w0.1: UV1.BB7 v3(165.6,72.38)
N29977942: length 2.7
  BOTTOM w0.127: UE8.24 183.2,139.8 RE45.2
N29977967: length 1.7
  BOTTOM w0.127: RE41.1 182.88,136.18 182.56,136.5 UE8.30
N30011846: length 3.7
  BOTTOM w0.089: UV9.J1 182.51,121.08
  BOTTOM w0.127: 182.51,121.08 182.36,121.08 181.86,120.58 v1(181.5,120.58) 180.86,120.58 RV131.1
N30011856: length 4.8
  BOTTOM w0.089: 195.21,120.73 193.77,120.73 193.45,121.05 UV9.J13
  BOTTOM w0.127: RV135.1 197.61,121.03 197.31,120.73 v1(196.41,120.73) 195.21,120.73
N30011880: length 13.2
  IN4 w0.091: v3(188.23,130.7) 189.31,129.62 189.31,124.06 188.66,123.41 188.66,122.71 189.23,122.14 189.23,121.31 189.8,120.74 v3(190.09,120.74)
  BOTTOM w0.102: v3(190.09,120.74) 190.43,121.08 UV9.J10
  BOTTOM w0.127: RV133.1 188.29,130.63 v3(188.23,130.7)
N30012034: length 3.6
  TOP w0.089: UV8.J1 183.37,121.08 182.98,120.69 182.51,120.69
  TOP w0.127: 182.51,120.69 v1(181.51,120.69) 180.79,120.69 RV132.1
N30012053: length 9.4
  TOP w0.089: UV8.J13 193.82,120.7 194.92,120.7 195.21,120.99
  TOP w0.127: 195.21,120.99 195.45,120.99 v1(196.44,121.98) 198.45,123.99 198.45,126.43 RV136.1
N30012101: length 10.5
  TOP w0.089: UV8.J10 190.41,121.08 189.8,121.68 189.8,128.32
  TOP w0.127: RV134.1 189.8,130.63 v1(189.8,129.67) 189.8,128.32
N30014501: length 4.9
  TOP w0.127: QV24.1 198.6,132.39 198.6,131.57 v1(199.46,130.72) RV199.1 200.36,128.66 RV200.1
N30019834: length 3.9
  BOTTOM w0.102: UV13.J1 219.91,86.33
  BOTTOM w0.127: RV161.1 218.65,84.97 v1(219.01,85.33) 219.91,86.23 219.91,86.33
N30019838: length 4.8
  BOTTOM w0.089: 220.23,98.92 220.23,97.48 UV13.J13
  BOTTOM w0.127: RV156.1 219.6,101.22 219.6,99.91 220.23,99.29 220.23,98.92
N30050086: length 3.1
  BOTTOM w0.127: v1(145.94,78.2) RV56.1 144.36,78.2 144.06,78.5 QV12.2
N30057546: length 1.6
  TOP w0.127: UV11.12 152.93,60.49 CV368.1
N30057549: length 2.8
  TOP w0.127: v1(155.34,61.27) 154.59,61.27 CV369.1 154.27,60.61 153.73,60.07 UV11.10
N30064270: length 3.6
  BOTTOM w0.089: 164.22,120.94 164.36,121.08 UV7.J1
  BOTTOM w0.127: 164.22,120.94 164.1,120.82 v1(163.71,120.82) 163.64,120.88 162.78,120.88 RV117.1
N30064272: length 4.4
  BOTTOM w0.089: UV7.J13 175.76,120.73 176.82,120.73 176.92,120.83
  BOTTOM w0.127: 176.92,120.83 v1(178.35,120.83) 178.65,120.83 178.79,120.96 RV121.1
N30064285: length 11.7
  IN1 w0.089: v3(172.61,121.48) 172.61,121.92 170.58,123.95 170.58,127.51 169.9,128.19 169.9,128.7
  IN1 w0.099: 169.9,128.7 v3(169.9,129.82)
  BOTTOM w0.089: UV7.J10 v3(172.61,121.48)
  BOTTOM w0.127: v1(170.58,129.82) v3(169.9,129.82) 169.9,130.12 RV119.1
N30064415: length 3.9
  TOP w0.127: UV6.J1 176.56,120.74 178.38,120.74 v1(178.39,120.74) 178.6,120.96 179.07,120.96 179.59,120.44 RV116.1
N30064432: length 5
  TOP w0.089: UV6.J13 166.24,120.7 165.44,120.7 164.22,119.48
  TOP w0.127: 164.22,119.48 164.12,119.38 v1(163.4,119.38) 162.51,119.38 RV120.1
N30064451: length 13.3
  TOP w0.102: v3(169.81,121.08) UV6.J10
  TOP w0.127: RV118.1 171.19,130.81 v3(170.75,131.24)
  IN1 w0.089: v3(169.81,121.08) 170.02,121.29 170.02,127.55 169.38,128.18 169.38,128.7
  IN1 w0.099: 169.38,128.7 169.38,129.88 170.74,131.24 v3(170.75,131.24)
  BOTTOM w0.127: v1(170.54,131.74) 170.75,131.52 v3(170.75,131.24)
N30064642: length 6.5
  TOP w0.127: v1(155.37,127.32) 155.75,127.7 156.69,127.7 QV23.1
  TOP w0.508: QV23.1 157.04,128.74 158.26,129.96 RV194.1 159.27,129.96 RV193.1
N30070817: length 6.4
  TOP w0.089: 220.33,86.22 219.91,86.64 UV12.J1
  TOP w0.127: RV165.1 223.36,83.3 v1(221.81,84.85) 220.44,86.22 220.33,86.22
N30070819: length 4.8
  TOP w0.089: UV12.J13 220.3,97.55 220.3,98.92
  TOP w0.127: 220.3,98.92 220.3,99.72 v1(219.9,100.12) 219.9,101.06 RV160.1
N30070830: length 11.3
  TOP w0.089: v3(220.28,94.31) 219.91,94.69 UV12.J10
  BOTTOM w0.127: RV140.1 228.94,92.61 v1(228.34,92.61) 220.85,92.61 220.28,93.18 v3(220.28,94.31)
N30070921: length 12
  BOTTOM w0.127: RV159.1 228.35,91.2 v1(228.32,91.23) 227.29,92.25 220.79,92.25 219.9,93.14 219.9,94.75 UV13.J10
N30071304: length 4.8
  BOTTOM w0.127: QV21.1 211.46,104 v1(211.2,104.26)
  BOTTOM w0.508: QV21.1 213.89,103.41 RV144.1 213.9,102.51 RV164.1
N30074378: length 3.7
  BOTTOM w0.089: 220.37,68.18 220.37,68.49 219.91,68.95 UV16.J1
  BOTTOM w0.127: RV172.1 220.34,66.72 v1(220.34,67.27) 220.34,67.67 220.37,67.71 220.37,68.18
N30074380: length 5
  BOTTOM w0.127: UV16.J13 220.23,79.45 220.23,80.6 218.94,81.89 v1(218.94,82.3) 218.94,83.01 RV166.1
N30074391: length 11.1
  BOTTOM w0.127: UV16.J10 219.91,76.22 221.41,74.72 227.41,74.72 228.11,75.41 v1(228.36,75.41) 229.01,75.41 RV188.1
N30074450: length 6
  TOP w0.127: UV15.J1 219.91,67.28 RV204.1 221.52,65.67 v1(221.52,64.2)
N30074452: length 4.8
  TOP w0.089: UV15.J13 219.92,79.12 220.28,79.49 220.28,80.86 220.26,80.88
  TOP w0.127: RV171.1 v1(219.03,82.22) 219.03,82.12 220.26,80.88
N30074465: length 11.3
  TOP w0.089: v3(219.88,75.7) 219.88,76.7 UV15.J10
  BOTTOM w0.127: v3(219.88,75.7) 221.16,74.42 228,74.42 v1(228.39,74.03) RV185.1
N30074953: length 5.2
  BOTTOM w0.127: v2(212.99,65.41) QV25.1
  BOTTOM w0.508: QV25.1 217.21,65.41 RV206.1 RV205.1
N30306722: length 2.1
  BOTTOM w0.127: RM28.1 RM29.1 218.89,124.32 CM99.1
N30306724: length 2.1
  BOTTOM w0.127: CM98.1 221.21,124.73 221.21,124.49 RM38.1 RM27.1
N30306755: length 4.5
  BOTTOM w0.127: UM4.20 224.94,121.62 225.48,122.16 v1(225.48,122.23) 225.48,122.98 CM16.1 CM17.1 RM18.2
N30306794: length 2.7
  BOTTOM w0.127: UM4.18 223.64,121.67 223.86,121.9 v1(223.86,122.19) 223.86,122.76 RM25.2
N30306802: length 3.5
  BOTTOM w0.127: RM21.2 RM19.2 v1(225.19,113.55) 225.19,113.58 224.94,113.83 UM4.1
N30306843: length 2.7
  BOTTOM w0.127: UM4.13 220.39,121.71 219.78,122.32 RM28.2
N30306845: length 2.7
  BOTTOM w0.127: UM4.14 221.04,121.91 v1(220.66,122.28) 220.52,122.42 220.52,122.75 220.66,122.89 RM27.2
N30449531: length 41.4
  TOP w0.254: PH500.1 123.71,119.78 124.4,119.09 v2(133.19,119.09) 135.79,116.49 v3(136.84,116.49)
  IN4 w0.254: v3(142.88,129.44) 143.11,129.44 146.37,126.18 146.37,122.58 143.66,119.88 141.79,119.88 139.8,117.88 138.24,117.88 v3(136.84,116.49)
  BOTTOM w0.254: v3(142.88,129.44) 143.44,130 143.44,131.13 143.09,131.47 PR525.1 143.09,132.48 PR528.1
N30468201: length 0.7
  TOP w0.127: v2(30.79,17.21) 31.35,17.21 v3(31.43,17.12)
  vias: v3(31.83,16.69) v3(39.51,18.16) v3(39.51,17.46)
N30670626: length 3
  TOP w0.127: v1(188.08,32.31) 188.76,31.62 PR641.1
  TOP w0.254: PU601.1 188.61,30.18 188.39,30.39 188.39,30.93 PR641.1
N30712936: length 4.5
  TOP w0.127: v1(47.68,33.82) 47.27,33.82 PR727.2
  TOP w0.203: 45.28,35.04 45.21,35.1 45.21,35.71 45.38,35.88 45.38,36.07 45.26,36.19 PU700.15
  TOP w0.254: PR727.2 45.56,34.76 45.28,35.04
N30751575: length 2.8
  TOP w0.127: PR732.2 61.36,47.47 v1(61.53,47.47)
  TOP w0.254: PR732.2 60.97,48.51 PQ710.3
N30751577: length 4.9
  TOP w0.127: PR729.1 65.13,48.16 v1(64.89,47.92)
  TOP w0.254: PR729.1 PR730.2 64.65,49.98 64.48,49.81 PQ710.6 63.62,49.81 63.46,49.66 63.46,49.35 63.66,49.16 PQ710.5
N30751626: length 4
  TOP w0.127: v1(59.76,51.3) 59.73,51.27 PR731.2
  TOP w0.254: PR731.2 60.64,49.16 PC724.1 60.67,49.16 PQ710.2
N30812755: length 4.1
  BOTTOM w0.127: PC660.1 137.57,86.07 v1(137.38,85.88)
  BOTTOM w0.254: PC660.1 138.85,86.39 138.85,87.58 139.32,88.05 PU602.7
N30972760: length 0.9
  BOTTOM w0.127: RT16.1 CT8.1
N31013912: length 18.8
  TOP w0.127: v3(141.96,121.21) 142.15,121.4 v1(142.15,122.09)
  TOP w0.254: PR551.1 140.87,121.88 141.54,121.21 v3(141.96,121.21)
  IN6 w0.254: v3(132.97,113.88) 133.12,114.04 133.57,114.04 137.73,118.2 137.73,119.47 139,120.74 141.16,120.74 141.63,121.21 v3(141.96,121.21)
  BOTTOM w0.254: v3(132.97,113.88) 132.84,114.01 129.87,114.01 PH501.2
N31910445: length 28
  TOP w0.127: v3(165.85,8.47) 165.85,7.08 RN35.2 RN33.1 v1(164.52,6.06)
  BOTTOM w0.127: v3(165.85,8.47) 166.36,8.98 172.53,8.98 173.22,9.67 185.87,9.67 187.4,8.15 JSSD3.30
N31911348: length 4.3
  TOP w0.127: v3(213.55,7.64) 213.41,7.78 RN29.1 RN30.2 212.63,9.36 v1(212.22,8.96)
  BOTTOM w0.127: v3(213.55,7.64) 213.4,7.48 JSSD2.30
N31911952: length 4.8
  TOP w0.127: v3(236.07,7.94) 236.4,8.27 RN28.1 RN31.2 235.09,9.07 v1(235.09,9.63)
  BOTTOM w0.127: JSSD1.30 236.9,7.43 236.39,7.94 v3(236.07,7.94)
N32451492: length 29.2
  TOP w0.127: v3(182.76,7.67) 182.76,8.02 v1(180.09,10.68) 180.09,11.1 RN34.2 179.03,12.13 178.46,11.56 178.46,10.91 RN32.1
  BOTTOM w0.127: JSSD4.30 163.9,7.33 164.06,7.5 166.41,7.5 167.48,8.57 172.63,8.57 173.48,9.42 181,9.42 v3(182.76,7.67)
N33138349: length 3.7
  TOP w0.127: v1(157.49,40.95) RV241.2 157.49,39.08 158.36,38.21 UV20.5
N33139824: length 5.3
  TOP w0.127: UV20.8 158.49,36.26 158.36,36.14 158.36,35.85 v3(158.63,35.59) 158.37,35.33 RV242.2 156.68,36.08 v1(156.68,36.31)
  BOTTOM w0.127: RV554.1 159.5,35.87 159.22,35.59 v3(158.63,35.59)
N33139840: length 6.9
  TOP w0.127: UV20.9 159.94,34.74 159.8,34.6 158.97,34.6 v3(158.63,34.95) 157.94,34.95 RV243.2
  BOTTOM w0.127: RV553.1 160.39,35.84 159.5,34.95 v3(158.63,34.95) 158.46,34.95 v1(157.96,35.45)
N33792732: length 3.3
  TOP w0.127: UL2.3 327.79,32.73 328.09,32.43 RL5.1 v1(328.09,29.95)
N33792861: length 2.6
  TOP w0.127: v1(251.77,45.8) 252.4,45.16 RE20.1 252.15,44.47 UE9.3
N34043429: length 3.5
  BOTTOM w0.127: UM8.27 151.2,134.37 151.08,134.48 151.08,134.79 150.94,134.93 150.94,135.82 151.49,136.36 151.64,136.36 RM72.2
N34067329: length 3.5
  TOP w0.127: v1(87.96,14.98) R148.2 88.11,13.65 89.42,13.65 89.73,13.96 Q2411.5
N34067344: length 3.2
  TOP w0.127: v1(80.46,15.38) 80.46,14.06 80.14,13.74 R152.2
N34067359: length 6.2
  TOP w0.127: R172.2 84.51,16.41 84.25,16.66 83.75,16.66 v1(82.87,15.79) Q2413.5
N34596334: length 1.6
  BOTTOM w0.127: UT1.2 194.06,133.82 CT2.1
N35007428: length 5.2
  BOTTOM w0.127: UM4.4 222.99,114.16 222.35,113.53 222.35,113.13 221.38,112.16 RM20.2 220.91,111.58 v1(220.91,110.72)
N35128238: length 3.2
  TOP w0.127: v3(105.09,138.11) v1(106.14,138.11) 106.32,138.3 UV4.18
  BOTTOM w0.127: RV293.2 105.03,138.18 v3(105.09,138.11)
N35755395: length 8.9
  TOP w0.127: RH1.2 236.32,30.38 235.84,30.86 235.16,30.86 v1(235.08,30.94) 234.94,31.08 234.94,31.5 RH2.2 234.24,31.94 234,32.18 234,32.6 v3(234,32.6)
  BOTTOM w0.127: v3(234,32.6) 234,32.78 233.76,33.02 233.31,33.02 232.82,33.51 232.68,33.51 231.6,34.59 230.52,34.59 UH1.A14
N35913798: length 6.7
  TOP w0.127: UC1.1 83.82,64.69 RC24.2 83.05,65.46 82.25,65.46 RC57.2 80.81,64.02 v2(79.58,64.02)
N35913809: length 4.1
  TOP w0.127: RC56.2 CC31.1 83.62,63.97 v1(83.67,63.97) 83.73,64.04 UC1.2
N36090962: length 8.9
  BOTTOM w0.127: v3(166.01,70.39) UV1.BB5 166.01,71.17 159.25,71.17 RV512.1
N36090964: length 6.8
  BOTTOM w0.089: 165.75,66.34 165.75,67.16 166.05,67.46 166.05,69.63 UV1.BB4
  BOTTOM w0.127: v1(164.39,64.66) 165.48,64.66 RV513.1 165.75,65.03 165.75,66.34
N36090966: length 10
  TOP w0.127: v3(157.4,67.72) 160.34,67.72 160.97,68.35 163.98,68.35 v3(164.4,68.78)
  BOTTOM w0.089: UV1.BD3 v3(164.4,68.78)
  BOTTOM w0.127: v2(156.2,68.47) 156.34,68.33 RV511.1 157.46,67.77 v3(157.4,67.72)
N36090968: length 7.6
  BOTTOM w0.127: RV510.1 159.95,69.59 164.41,69.59 UV1.BD4 164.8,69.98 v3(164.41,70.37)
N36096883: length 15.3
  TOP w0.127: v3(168.4,74.38) 167.99,74.79 167.45,74.79 166.96,75.29 165.85,75.29 163.87,77.27 163.87,77.79 163.2,78.46 v2(158.6,78.46) 155.89,78.46 RV68.2
  BOTTOM w0.089: UV1.AW9 v3(168.4,74.38)
N36100380: length 2.5
  TOP w0.089: v1(166.92,85.69) 167.6,85.01 v3(167.6,84.78) 167.81,84.57 RV67.1
  BOTTOM w0.1: UV1.BA23 v3(167.6,84.78)
N36106148: length 2.2
  TOP w0.089: v3(189.17,99.15) 189.06,99.04 RV77.2 188.6,98.03 v1(188.61,98.02)
  BOTTOM w0.1: UV1.P40 v3(189.17,99.15)
N36106150: length 4.9
  BOTTOM w0.089: 188,104.41 187.65,104.76 187.65,105.39 187.16,105.88 187.16,106.43
  BOTTOM w0.127: 187.16,106.43 187,106.59 187,108.47 RV79.2
  BOTTOM w0.157: UV1.R47 188,104.41
N36106154: length 4.2
  BOTTOM w0.089: 187.42,106.61 187.42,105.94 188,105.36 UV1.R48
  BOTTOM w0.157: RV78.2 187.28,107.86 187.28,106.76 187.42,106.61
N36126643: length 16.8
  TOP w0.127: v3(166.8,104.78) 166.39,105.18 164.59,105.18 164.19,104.78 164.19,100.21 163.82,99.84 v1(160.82,99.84) 159.03,99.84 158.22,100.65 157.55,100.65 156.68,101.51 RV153.1
  BOTTOM w0.1: UV1.BB48 v3(166.8,104.78)
N36139218: length 5.2
  TOP w0.127: v1(242.28,48.78) 242.28,47.7 243.02,46.97 243.02,46.56 RE98.2 243.5,45.77 UE6.10
N36226998: length 2.3
  BOTTOM w0.127: RR9.1 CR9.1 298.67,19.45 v1(298.16,18.94)
N36227015: length 2.3
  BOTTOM w0.127: v1(300.5,35.87) 300.03,35.4 CR14.1 RR10.1
N36403695: length 9.2
  TOP w0.127: QM2.3 294.22,29.53 RM94.2 295.18,30.48 295.18,32.73 295.76,33.31 296.23,33.31 QM3.2 v1(297.13,36.46)
N36665397: length 2.2
  BOTTOM w0.127: v1(82.26,126.14) RV13.2 CV374.1
N36871069: length 6.1
  TOP w0.127: UE7.2 293.35,14.71 293.63,14.43 295.53,14.43 CE52.1 RE85.1 296.9,12.17 v1(296.62,11.89)
N37505012: length 3
  TOP w0.203: UA1.40 21.33,11.14 21.5,10.96 v1(21.5,10.56) 21.5,9.76 CA18.2
  TOP w0.508: CA18.2 21.26,9.65 v3(20.94,9.33)
N37505062: length 3.8
  TOP w0.127: UA1.36 19.73,10.68 v4(19.21,10.16) 18.8,9.75 18.8,8.84 RA42.2
N37505130: length 3.8
  TOP w0.127: RA64.2 19.05,8.79 19.05,9.65 20.02,10.61 20.02,11.14 20.13,11.25 UA1.37
N37505138: length 0.9
  BOTTOM w0.127: CA67.2 RA81.1
N37505139: length 3.3
  BOTTOM w0.127: RA84.1 224.03,15.19 CA68.2 223.98,15.18 223.53,15.62 222,15.62 v1(221.86,15.48)
N37505216: length 1.9
  TOP w0.127: v1(23,22.07) 23.79,22.07 CA30.1 RA96.2
N37505235: length 1.4
  TOP w0.203: CA19.2 26.71,10.13 26.48,9.91 UA6.13
N37505311: length 9.2
  IN1 w0.254: v3(7.7,29.13) 7.7,30.89 v3(9.07,32.26)
  BOTTOM w0.127: v1(9.12,36.01) RA111.2
  BOTTOM w0.254: UA4.3 7.7,29.11 v3(7.7,29.13) ; RA111.2 8.89,33.95 RA91.2 8.89,33.17 9.07,33 v3(9.07,32.26)
N37505354: length 1.9
  BOTTOM w0.254: CA101.2 8.61,28.51 8.27,28.17 8.18,28.17 UA4.5
N37505355: length 3.2
  BOTTOM w0.254: CA102.2 5.5,31.57 v1(5.5,31.04) 5.5,30.11 5.06,29.67 5.06,29.45 UA4.32
N37505357: length 2.5
  BOTTOM w0.127: v1(11.23,30.74) RA117.2
  BOTTOM w0.254: CA101.1 9.57,29.97 9.97,30.37 RA117.2
N37505359: length 0.9
  BOTTOM w0.254: RA116.1 CA102.1
N37505361: length 1.8
  TOP w0.508: RA120.2 CA103.1 13.57,9.12 RA118.2
N37505362: length 2.8
  TOP w0.127: v1(7.56,7.47) RA122.2
  TOP w0.508: RA122.2 RA119.2 CA104.1
N37505403: length 5.1
  TOP w0.127: v1(3.75,6.39) 4.71,6.39 RA123.2
  TOP w0.254: QA7.5 2.57,8.47 2.48,8.38 2.48,7.93 2.58,7.82 QA7.6 3.78,7.82 4.26,7.34 4.52,7.34 4.87,7 RA123.2
N37505479: length 0.9
  BOTTOM w0.508: RA130.2 CA83.2
N37505480: length 0.9
  BOTTOM w0.508: RA131.2 CA84.2
N37505481: length 0.9
  BOTTOM w0.508: CA85.2 RA132.2
N37505482: length 0.9
  BOTTOM w0.508: CA86.2 RA133.2
N37505517: length 3.7
  TOP w0.254: v3(27.93,9.25) 28.41,8.77 RA102.1
  BOTTOM w0.254: CA75.1 28.84,9.86 28.63,9.86 28.02,9.25 v3(27.93,9.25) 27.28,9.25 QA11.1
N37505593: length 14.9
  IN4 w0.254: v3(15.12,10.52) 15.63,11.04 18.79,11.04 20.07,9.75 20.07,9.1 21.57,7.59 22.12,7.59 22.4,7.88 v3(22.4,8.17)
  BOTTOM w0.127: v3(15.12,10.52) v1(14.52,10.52)
  BOTTOM w0.254: RA100.1 15.56,10.52 v3(15.12,10.52) ; CA73.1 22.01,9.91 22.8,9.91 23.1,9.6 QA13.1 22.4,8.23 v3(22.4,8.17)
N37505594: length 17.5
  IN4 w0.254: v3(3.79,12.71) 3.8,12.7 7.01,12.7 7.23,12.92 8.3,12.92 8.97,12.24 v3(8.97,11.79)
  BOTTOM w0.254: RA126.1 3.05,12.71 v3(3.79,12.71) ; QA12.1 16.87,11.41 16.41,11.86 CA74.1 15.98,11.86 15.38,11.27 14.43,11.27 13.54,12.16 10.71,12.16 9.9,11.34 v1(9.7,11.34) 9.41,11.34 v3(8.97,11.79)
N37551658: length 1.7
  BOTTOM w0.127: UM8.52 162.18,131.37 162.88,130.67 RM61.2
N37905289: length 2.1
  TOP w0.254: QA7.2 5.07,8.47 5.27,8.27 RA93.2 5.73,9.16 RA94.2
N38491094: length 2.5
  BOTTOM w0.127: RA114.2 9.69,12.61 QA14.6 9.69,13.78 9.9,13.98 10.17,13.98 10.34,13.82 QA14.5
N61580896: length 5.1
  TOP w0.127: R177.2 143.64,23.89 Q41.1 144.73,24.98 144.73,26.34 v1(143.77,27.31)
N72585933: length 2.8
  TOP w0.127: v2(155.6,33.29) 155.51,33.38 PC211.1
  TOP w0.508: PR202.2 154.89,34.69 PC211.1
N198445017: length 3.3
  BOTTOM w0.127: T66.1 231.96,40.27 230.73,40.27 230.38,39.91 230.25,39.91 229.95,39.61 UH1.C26
N198445717: length 1.1
  TOP w0.089: v3(213.41,30.05) 213.16,29.8 T64.1
  BOTTOM w0.089: UH1.BA2 213.71,29.75 v3(213.41,30.05)
N198445911: length 1.9
  TOP w0.089: T65.1 212.1,30.06 v3(212.77,30.06)
  BOTTOM w0.089: UH1.BB2 213.07,29.76 v3(212.77,30.06)
N198468312: length 7.3
  BOTTOM w0.089: UH1.AU42 215.38,46.82 214.54,47.65 214.54,47.72 214.19,48.07 213.97,48.07 213.56,48.48
  BOTTOM w0.127: T69.1 210.63,50.99 211.77,49.85 212.19,49.85 213.56,48.48
N198468386: length 8.3
  BOTTOM w0.089: 213.92,48.48 214.05,48.34 214.42,48.34 214.57,48.19 215.02,48.19 215.36,47.86 UH1.AU44
  BOTTOM w0.127: T71.1 210.63,52.95 210.63,52.22 211.03,51.83 211.03,51.04 211.94,50.13 212.27,50.13 213.92,48.48
N198469522: length 4.2
  TOP w0.089: T70.1 214.12,38.01 213.74,38.01 213.5,37.77 213.5,36.46 213.74,36.22 214.09,36.22 214.44,35.87 v3(214.44,35.63)
  BOTTOM w0.089: v3(214.44,35.63) 214.28,35.78 UH1.AW17
N198469532: length 1.3
  TOP w0.089: T72.1 215.52,35.16 v3(215.05,35.63)
  BOTTOM w0.089: UH1.AV17 214.88,35.79 v3(215.05,35.63)
N198469635: length 1.3
  TOP w0.089: v3(221.9,33.12) 221.67,33.35 T79.1
  BOTTOM w0.089: UH1.AB10 221.57,32.8 v3(221.9,33.12)
