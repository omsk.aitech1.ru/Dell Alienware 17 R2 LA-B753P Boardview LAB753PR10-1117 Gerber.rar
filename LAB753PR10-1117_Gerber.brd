# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RV303  4.7K_0402_5%  [R_0402]  107.29 141.66 270 bottom
RV305  4.7K_0402_5%  [R_0402]  109.3 142.25 270 bottom
RV306  4.7K_0402_5%  [R_0402]  108.4 141.51 90 bottom
RV510  1.8K_0402_5%  [R_0402]  158.51 71.02 180 bottom
RV511  1.8K_0402_5%  [R_0402]  157.46 68.33 90 bottom
RV512  1.8K_0402_5%  [R_0402]  158.51 71.91 180 bottom
RV513  1.8K_0402_5%  [R_0402]  165.8 64.98 270 bottom
RV526  10K_0402_5%  [R_0402]  153.49 74.59 180 top
RV527  10K_0402_5%  [R_0402]  153.49 75.91 180 top
RV528  2.2K_0402_5%~D  [R_0402]  228.97 52.87 180 bottom
RV529  2.2K_0402_5%~D  [R_0402]  228.97 51.98 180 bottom
RV530  10K_0402_5%~D  [R_0402]  155.77 76.99 0 bottom
RV531  10K_0402_5%~D  [R_0402]  139.18 76.04 0 bottom
RV532  100_0402_1%  [R_0402]  169.98 84.44 0 top
RV533  100_0402_1%  [R_0402]  170.9 85.33 180 top
RV538  10K_0402_5%  [R_0402]  152.34 56.21 0 top
RV540  10_0402_1%  [R_0402]  158.49 32.54 0 top
RV541  10K_0402_5%  [R_0402]  155.53 57.18 270 top
RV542  10_0402_1%  [R_0402]  158.49 33.43 0 top
RV543  10_0402_1%  [R_0402]  166.45 38.06 180 top
RV544  10_0402_1%  [R_0402]  166.45 36.67 180 top
RV545  10K_0402_5%  [R_0402]  111.88 135.96 0 bottom
RV546  15K_0402_1%  [R_0402]  112.79 135.02 180 bottom
RV547  1.8K_0402_1%  [R_0402]  158.69 55.23 270 bottom
RV548  1.8K_0402_1%  [R_0402]  162.28 52.73 270 bottom
RV551  1.8K_0402_1%  [R_0402]  162.29 54.56 270 bottom
RV552  1.8K_0402_1%  [R_0402]  158.74 52.26 270 bottom
RV553  0_0402_5%  [R_0402]  160.39 36.26 90 bottom
RV554  0_0402_5%  [R_0402]  159.5 36.26 90 bottom
SW1  SMT1-05-A_4P  [SW_SMT1-05-A_4P]  160.54 146.37 180 bottom
SW2  SMT1-05-A_4P  [SW_SMT1-05-A_4P]  150.17 133.23 0 top
T1  PAD  [TPC12]  95.48 97.82 0 top
T2  PAD  [TPC12]  91.7 95.66 0 top
T3  PAD  [TPC12]  88.46 95.66 0 top
T4  PAD  [TPC12]  96.78 92.92 0 top
T5  PAD  [TPC12]  94.81 94.83 0 top
T6  PAD  [TPC12]  95.13 92.86 0 top
T7  PAD  [TPC12]  88.97 93.75 180 bottom
T8  PAD  [TPC12]  87.7 93.25 0 top
T9  PAD  [TPC12]  93.79 93.75 0 top
T10  PAD  [TPC12]  129.95 97.47 180 bottom
T11  PAD  [TPC12]  130.69 98.83 180 bottom
T12  PAD  [TPC12]  133.29 69.86 180 bottom
T13  PAD  [TPC12]  128.27 105.86 180 bottom
T14  PAD  [TPC12]  134.3 71.11 180 bottom
T15  PAD  [TPC12]  126.82 105.16 90 bottom
T16  PAD  [TPC12]  130.62 97.06 0 top
T17  PAD  [TPC12]  127.88 96.55 0 top
T18  PAD  [TPC12]  114.49 97.79 0 top
T19  PAD  [TPC12]  112.7 97.78 0 top
T20  PAD  [TPC12]  93.66 105.12 90 bottom
T21  PAD  [TPC12]  96.71 83.91 0 top
T22  PAD  [TPC12]  95.9 80.67 0 top
T23  PAD  [TPC12]  109.49 78.5 0 top
T24  PAD  [TPC12]  110.83 79.25 270 top
T25  PAD  [TPC12]  87.51 96.36 180 bottom
T26  PAD  [TPC12]  126.04 72.48 0 top
T27  PAD  [TPC12]  88.95 95.71 180 bottom
T28  PAD  [TPC12]  126 73.81 0 top
T29  PAD  [TPC12]  123.26 81.69 0 top
T30  PAD  [TPC12]  93.03 96.04 0 top
T31  PAD  [TPC12]  123.78 97.63 0 top
T32  PAD  [TPC12]  114.09 101.46 0 top
T33  PAD  [TPC12]  112.13 103.49 0 top
T34  PAD  [TPC12]  117.71 98.59 0 top
T35  PAD  [TPC12]  120.28 95.51 0 top
T36  PAD  [TPC12]  122.37 97.56 0 top
T37  PAD  [TPC12]  94.43 96.1 0 top
T38  PAD  [TPC12]  93.86 97.75 0 top
T39  PAD  [TPC12]  95.89 96.1 0 top
T40  PAD  [TPC12]  128.82 98.77 0 top
T41  PAD  [TPC12]  129.61 105.12 180 bottom
T42  PAD  [TPC12]  87.39 69.81 180 bottom
T43  PAD  [TPC12]  93.04 107.04 180 bottom
T44  PAD  [TPC12]  131.51 100.51 180 bottom
T45  PAD  [TPC12]  90.35 99.06 180 bottom
T46  PAD  [TPC12]  133.61 72.95 180 bottom
T47  PAD  [TPC12]  88 74.53 180 bottom
T48  PAD  [TPC12]  131.85 69.23 180 bottom
T49  PAD  [TPC12]  117.38 95.7 270 top
T50  PAD  [TPC12]  114.24 95.79 270 top
T51  PAD  [TPC12]  111.25 95.63 270 top
T52  PAD  [TPC12]  108.08 95.2 270 top
T53  PAD  [TPC12]  107.9 81.04 270 top
T54  PAD  [TPC12]  113.41 80.99 270 top
T55  PAD  [TPC12]  116.04 81 270 top
T56  PAD  [TPC12]  120.89 82.11 270 top
T57  PAD  [TPC12]  106.49 81.24 270 top
T58  PAD  [TPC12]  120.84 89.93 270 top
T59  PAD  [TPC12]  96.14 79.08 0 top
T60  PAD  [TPC12]  94.49 91.21 0 top
T61  PAD  [TPC12]  96.01 91.78 0 top
T62  PAD  [TPC12]  95.89 82.26 0 top
T63  PAD  [TPC12]  96.01 90.39 0 top
T64  PAD~D  [TPC12]  213.16 29.59 90 top
T65  PAD~D  [TPC12]  211.63 29.59 90 top
T66  PAD~D  [TPC12]  232.37 40.68 270 bottom
T67  PAD~D  [TPC12]  221.39 30.14 90 top
T68  PAD~D  [TPC12]  220.73 32.08 0 top
T69  PAD~D  [TPC12]  210.63 51.34 270 bottom
T70  PAD~D  [TPC12]  214.24 37.9 90 top
T71  PAD~D  [TPC12]  210.64 52.96 270 bottom
T72  PAD~D  [TPC12]  215.55 35.16 90 top
T73  PAD~D  [TPC12]  223.67 30.25 90 top
T74  PAD~D  [TPC12]  222.29 31.54 0 top
T75  PAD~D  [TPC12]  234.56 23.27 270 bottom
T76  PAD~D  [TPC12]  231 22.71 270 bottom
T77  PAD~D  [TPC12]  228.67 27.15 90 top
T78  PAD~D  [TPC12]  208.29 27.38 180 bottom
T79  PAD~D  [TPC12]  221.36 33.35 0 top
T80  PAD~D  [TPC12]  233.54 47.25 270 bottom
T81  PAD  [TPC12]  206.85 27.17 0 bottom
T82  PAD~D  [TPC12]  220.78 45.82 90 top
T83  PAD~D  [TPC12]  233.52 45.82 270 bottom
T84  PAD~D  [TPC12]  220.77 44.54 90 top
T85  PAD~D  [TPC12]  208.73 52.22 270 bottom
T86  PAD~D  [TPC12]  208.76 50.37 270 bottom
T87  PAD~D  [TPC12]  208.02 48.07 270 bottom
T88  PAD~D  [TPC12]  207.27 49.33 270 bottom
T89  PAD~D  [TPC12]  225.26 44.19 90 top
T90  PAD~D  [TPC12]  226.44 43.6 90 top
T91  PAD~D  [TPC12]  212.7 42.76 270 top
T92  PAD~D  [TPC12]  212.8 41.18 270 top
T93  PAD  [TPC12]  88.97 94.13 270 top
T94  PAD  [TPC12]  90.11 95.66 270 top
T95  PAD~D  [TPC12]  227.03 46.65 90 top
T96  PAD~D  [TPC12]  229.81 46.38 90 top
T97  PAD~D  [TPC12]  162.75 81.75 0 top
T98  PAD~D  [TPC12]  161.23 80.93 0 top
T99  PAD~D  [TPC12]  164.4 81.28 0 top
T100  PAD~D  [TPC12]  159.32 81.12 0 top
T102  PAD  [TPC12]  95.06 83.85 0 top
T103  PAD  [TPC12]  96.65 85.5 0 top
T104  PAD  [TPC12]  88.9 84.86 0 top
T105  PAD  [TPC12]  95.13 85.56 0 top
T106  PAD  [TPC12]  88.9 87.34 0 top
T107  PAD  [TPC12]  89.03 89.24 0 top
T108  PAD  [TPC12]  87.63 86.32 0 top
T109  PAD  [TPC12]  87.57 88.42 0 top
T110  PAD  [TPC12]  87.19 87.97 180 bottom
T111  PAD  [TPC12]  94.43 87.97 0 top
T112  PAD  [TPC12]  88.9 88.86 180 bottom
T113  PAD  [TPC12]  88.84 86.9 180 bottom
T114  PAD  [TPC12]  87.7 92.42 180 bottom
T115  PAD  [TPC12]  86.36 93.31 180 bottom
T116  PAD  [TPC12]  90.87 91.34 0 top
T117  PAD  [TPC12]  86.93 89.44 180 bottom
T119  PAD  [TPC12]  94.62 89.94 0 top
T120  PAD  [TPC12]  92.33 89.63 0 top
T121  PAD  [TPC12]  96.01 88.99 0 top
T122  PAD  [TPC12]  89.09 92.61 0 top
T124  PAD  [TPC12]  87.44 94.64 180 bottom
T125  PAD  [TPC12]  96.01 93.94 0 top
T126  PAD  [TPC12]  96.78 95.02 0 top
T127  PAD  [TPC12]  93.54 92.29 0 top
T128  PAD  [TPC12]  92.2 92.48 0 top
TL1  350UH_GST5009-CLF  [BOTH_GST5009-CLF_24P]  335.45 79.49 180 bottom
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  53.59 14.82 270 top
U18  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  217.35 13.8 270 top
U2407  F75303M_MSOP10  [EMC1403-2-AIZL-TR_MSOP10]  148.05 14.67 270 bottom
U2410  ADM1032ARMZ-REEL_MSOP8  [ADM1032ARMZ-2REEL_MSOP8]  202.46 129.13 180 bottom
UA1  MALCOLM-EX_QFN56_7X7~D  [MALCOLM-EX_QFN56_7X7]  22.13 18.68 180 top
UA3  -  [TS3A225ERTER_PWQFN16_3X3]  5.16 10.18 270 bottom
UA4  -  [TPA3131D2DAPR_QFN32_5X5]  6.41 29.23 315 bottom
UA5  -  [RT9041E-15GQW_WDFN8_2X2]  26.11 13.96 90 bottom
UA6  -  [ISL54405IRUZ-T_UTQFN16_2P6X1P8]  24.99 8.62 270 top
UC1  -  [74AHC1G09GW_TSSOP5]  85.4 64.69 270 top
UE1  C8051F383-GQ_LQFP32_7X7  [C8051F347-GQ_LQFP32_7X7]  261.11 28.24 45 bottom
UE2  EN25Q80A-100HIP_SO8  [EN25F80-75HCP_SO8]  257.62 33.11 180 bottom
UE3  -  [TLC59116FIRHBR_VQFN32_5X5]  219.68 119.54 180 top
UE4  -  [TLC59116FIRHBR_VQFN32_5X5]  151.74 21.06 180 top
UE5  KB9012QF-A4_LQFP128_14X14  [KB9012QF-A2_LQFP128_14X14]  288.4 27.48 180 top
UE6  -  [KC3810_QFN24_4X4]  238.7 43.55 0 top
UE7  -  [SN74LVC1G06DCKR_SC70-5]  292.7 15.3 0 top
UE8  -  [TLC59116FIRHBR_VQFN32_5X5]  181.18 134.7 180 bottom
UE9  -  [SY6288C20AAC_SOT23-5]  251.26 42.58 90 top
UH1  LYNXPOINT_BGA695  [LYNXPOINT_BGA_695P-T]  230.38 29.07 90 bottom
UH2  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  214.31 20.4 90 top
UH3  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  219.59 21.82 270 top
UH4  -  [W25Q64FVSSIQ_SO8]  204.34 15.9 90 bottom
UH5  AH1806-W-7 SC59 3P OMNIPOLAR SW  [S-5711ACDL-M3T1S_SOT23-3]  340.67 35.78 90 top
UI2  -  [SY6288D20AAC_SOT23-5]  320.61 57.49 270 bottom
UI3  -  [SY6288D20AAC_SOT23-5]  319.84 44.47 270 bottom
UL1  S IC E2201-BL3A-R QFN 40P E-LAN CTRL  [E2201-BL3A-R_QFN40_5X5]  316.65 31.51 0 top
UL2  -  [SY6288D20AAC_SOT23-5]  327.41 34.63 270 top
UM1  -  [SY6288C20AAC_SOT23-5]  160.33 17.03 270 bottom
UM3  -  [TC7SH08FU_SSOP5]  196.29 139.13 270 bottom
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  224.94 115.03 180 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  159.89 140.44 270 bottom
UM8  -  [DS80PCI402SQNOPB_WQFN54_10X5P5]  160.85 129.57 180 bottom
UN1  -  [PS8520BTQFN20GTR2_TQFN20_4X4]  163.45 15.73 90 top
UN2  LNG3DMTR_LGA16_3X3~D  [LNG3DMTR_LGA16_3X3]  267.8 8.74 90 top
UR1  -  [RTS5227-GR_QFN32_4X4]  325.88 16.96 0 top
UT1  -  [SY6288C20AAC_SOT23-5]  194.4 132.87 90 bottom
UT2  AT97SC3205_TSSOP28~D  [AT97SC3205_TSSOP28]  248.46 40.7 270 bottom
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  15.33 39.54 270 top
UV1  N16x GB3B-256  [N15E-GX-A2_BGA_1745P]  199.2 67.58 90 bottom
UV2  -  [SY6288C20AAC_SOT23-5]  91.1 128.94 315 bottom
UV3  -  [SN74CBT3257CPWR_TSSOP16]  155.12 140.27 180 bottom
UV4  PS8407ATQFN40GTR2A1_TQFN40_5X5  [PS8407ATQFN40GTR2A0_TQFN40_5X5]  111.87 141.85 180 top
UV5  -  [AP2330W-7_SC59-3]  138.83 135.22 90 bottom
UV6  H5GQ1H24BFR-T2C_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  176.21 114.68 180 top
UV7  H5GQ1H24BFR-T2C_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  165.81 114.68 0 bottom
UV8  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  183.85 127.48 0 top
UV9  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  183.85 114.68 0 bottom
UV10  W25X20CLSNIG SOIC 8P  [AT25F512B-SSH-T_SO8]  151.58 75.25 180 bottom
UV11  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  152.13 57.5 0 top
UV12  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  213.51 87.56 90 top
UV13  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  226.31 87.56 90 bottom
UV14  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  155.31 74.95 0 bottom
UV15  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  213.51 69.52 90 top
UV16  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  226.31 69.52 90 bottom
UV17  -  [SY6288C20AAC_SOT23-5]  83.62 121.77 315 bottom
UV18  AP2337SA-7_SC59-3  [AP2330W-7_SC59-3]  144.66 132.5 0 bottom
UV19  -  [MC74VHC1G09DFT2G_SC70-5]  140.96 82.33 270 bottom
UV20  -  [INA3221AIRGVR_VQFN16_4X4]  161.89 39.21 180 top
UV22  -  [TPS22969DNYR_SON8-7_3X3]  147.66 96.51 90 bottom
YH1  32.768KHZ_12.5PF_9H03220008  [Y_9H03220008_2P]  232.79 20.69 90 top
YH2  25MHZ_10PF_Q22FA2380049900  [Y_Q22FA2380049900_4P]  217.95 52.76 180 bottom
YL1  25MHZ_10PF_7V25000014  [Y_FSX3M-25PM20FDO_4P]  321.46 27.69 180 top
YV1  27MHZ 16PF +-30PPM 7M27070004F50Q5  [Y_5YEA27000163IF50Q5_4P]  167.94 63 0 bottom

## Library data of the parts
C1 C2 C9-C14 C16 C17 C27 C29 C258 C2498 C2500 C2502 C2504-C2507 C2509 CA1 CA3 CA4 CA7-CA11 CA14-CA16 CA18 CA19 CA24 CA29-CA33 CA65-CA68 CA72-CA75 CA83-CA86 CA101-CA104 CA112 CC1-CC24 CC27-CC31 CC45 CD2-CD6 CD15-CD19 CD21 CD23 CD25 CD34-CD38 CD41-CD44 CE2-CE4 CE7-CE10 CE13-CE20 CE23-CE38 CE40-CE46 CE50-CE53 CE55-CE60 CF2 CF3 CF6 CH1-CH17 CH19-CH22 CH24 CH25 CH27 CH28 CH32-CH35 CH37-CH46 CH48-CH58 CH60-CH69 CH71 CH72 CH100 CH101 CI2 CI4 CI5 CI27-CI41 CL1-CL9 CL11-CL13 CL16-CL21 CL23-CL25 CL27-CL29 CL31-CL39 CL41 CL42 CM9 CM11 CM13 CM15-CM18 CM20 CM21 CM23-CM28 CM32 CM34-CM36 CM62-CM70 CN1-CN4 CN6-CN17 CN20-CN22 CN24-CN36 CN38 CN40-CN50 CR2-CR4 CR7-CR11 CR13 CR14 CT2-CT8 CU26 CU28 CU29 CV1-CV4 CV6-CV9 CV11-CV13 CV15-CV17 CV19 CV23-CV33 CV35 CV37-CV39 CV41-CV45 CV47 CV54 CV57-CV76 CV80 CV96 CV100-CV107 CV109 CV112-CV114 CV117 CV118 CV122 CV123 CV126-CV128 CV131 CV132 CV135 CV136 CV141 CV142 CV147 CV149 CV153-CV156 CV160-CV175 CV178-CV182 CV184-CV195 CV198-CV216 CV219-CV223 CV226-CV230 CV233-CV237 CV240-CV250 CV252 CV254-CV256 CV258-CV267 CV270-CV284 CV287-CV291 CV294-CV315 CV364-CV369 CV372-CV377 CV379 CV380 CV394 CV396 CV408 CV422-CV429 CZ6 PC1-PC4 PC6-PC9 PC11-PC13 PC15 PC16 PC100 PC103 PC105 PC106 PC200 PC201 PC210 PC211 PC213 PC214 PC300-PC302 PC309 PC312 PC314 PC316 PC317 PC408 PC409 PC500 PC504 PC507 PC510 PC515 PC516 PC520 PC521 PC525-PC528 PC536 PC537 PC539-PC541 PC544-PC547 PC613 PC614 PC616-PC618 PC626 PC627 PC634 PC635 PC659-PC662 PC701-PC704 PC708 PC709 PC715-PC724 PC927-PC934 PC979-PC1008 = C_0402
C3-C8 CA17 CA98 CC46-CC51 CE1 CE6 CE48 CF4 CF5 CH26 CI1 CI10 CI24 CI26 CL40 CM29 CM31 CN18 CN19 CN23 CN37 CN39 CV5 CV10 CV18 CV21 CV85-CV88 CV97 CV108 CV115 CV116 CV120 CV125 CV130 CV134 CV137 CV138 CV148 CV338 CV339 CV398 PC102 PC104 PC113 PC114 PC202 PC203 PC205 PC206 PC303 PC304 PC307 PC310 PC503 PC505 PC506 PC512-PC514 PC533-PC535 PC600-PC608 PC652 PC655-PC658 PC666 PC705 PC706 PC712-PC714 PC917-PC926 PC935-PC945 PC971-PC978 PC1009-PC1017 = C_0805
C15 C256 C257 C260-C270 C2508 CA5 CA6 CA13 CA69-CA71 CA76 CA77 CA81 CA94-CA97 CA99 CA100 CA105-CA110 CA113 CC32-CC42 CD1 CD7-CD14 CD20 CD22 CD24 CD26-CD33 CD39 CE22 CH18 CH23 CH29-CH31 CH36 CH47 CH59 CH70 CI11 CI25 CL14 CL15 CL22 CM12 CM14 CM19 CM30 CM33 CM98 CM99 CN51 CN52 CR1 CR5 CR6 CR12 CU27 CV14 CV34 CV81-CV84 CV89-CV95 CV98 CV99 CV110 CV111 CV119 CV121 CV124 CV129 CV133 CV139 CV140 CV143-CV146 CV150-CV152 CV157-CV159 CV217 CV218 CV224 CV225 CV231 CV232 CV238 CV239 CV253 CV257 CV268 CV269 CV285 CV286 CV292 CV293 CV317-CV335 CV397 CV409-CV415 PC10 PC14 PC101 PC109-PC112 PC204 PC207 PC212 PC305 PC308 PC313 PC315 PC405 PC406 PC501 PC502 PC508 PC509 PC511 PC518 PC522 PC524 PC529 PC538 PC542 PC543 PC612 PC615 PC619 PC621 PC622 PC625 PC628 PC629 PC707 PC710 PC711 PC900-PC904 PC907-PC909 PC946-PC965 = C_0603
CA89 CA90 PC209 PC306 PC311 PC318 = C_B2
CC43 CC44 CV1025 PC208 PC905 PC906 PC966-PC970 = C_D2
CD40 = C_MP2VLPS330MC4R2
CL30 = C_1808
CM10 = C_1206
CMOS1 = SHORTPADS: User Part Number: PART#
CPU1 = HASWELL_BGA_1364P-T
DA15 = BAT54AW_SOT323-3
DE1 DE3 DF1 DF2 DU8 DU9 = SDMK0340L-7-F_SOD323-2
DE2 = L03ESDL5V0CG3-2_SOT-523-3
DH1 DV1 = RB751V-40_SOD323-2
DI2 DI4 = L30ESDL5V0C3-2_SOT23-3
DI3 DI5 = TVWDF1004AD0_DFN9
DN1 = SDM10U45-7_SOD523-2
DV2 = PESD5V0U2BT_SOT23-3
DV4 = DAN202UT106_SC70-3
DV8 = BAT54A-7-F_SOT23-3
DV9 = RB751S40T1G_SOD523-2
FD1-FD4 = FIDUCIAL_C40M80
H1 H2 = H_3P5X4P1
H3-H6 H8-H14 = H_2P8
H15 = H_3P5
H16-H23 = H_3P8
H24 = H_3P2
H25 = H_2P0N
H26 = H_2P0X2P3N
J2 JP1 JP2 PJP100 PJP102 PJP200 PJP300 PJP302 PJP600 PJP901 = JUMP_43X118
J4-J6 PJP902 = JUMP_43X79
JCDRA = TE_2260531-1_46P-T
JCR = T-SOL_143-2300302602_22P_RV
JDIMM1 = FOX_AS0A621-H2R6-7H_204P
JDIMM2 = FOX_AS0A621-HARN-7H_204P
JDP1 = FOX_3V111T1-R240KKA-7H_20P-T
JEDP1 = ACES_50473-0400M-002_40P-T
JELC1 = AMPHE_G846A06201EU_6P-T
JFAN1 JFAN2 = ACES_50273-00401-001_4P
JHDD1 = STARC_111H20-100000-G2-R_20P
JHDMI1 = FUTUR_061-HA18-0001_19P-T
JIO = I-PEX_20455-040E-12_40P
JKB1 = ACES_50552-03001-001_30P-T
JKB2 = ACES_50611-0100N-001_10P
JKB3 = ACES_87153-06411_6P
JKBBL1 = ACES_50552-02001-001_20P-T
JLAN = SANTA_130456-511_13P-T
JLOGO1 JTRONF = ACES_50208-01201-P01_12P
JPWR1 = STARC_107K30-000001-G2_30P
JRTC1 = ACES_50271-00201-001_2P
JSPK = ACES_50278-00401-001_4P
JSSD1-JSSD4 = FOX_AS0BC21-S85BB-7H_67P-T
JUSB1 JUSB2 = JESSL_TNBNRAC70013009_9P-T
JWLAN1 = LOTES_APCI0019-P009A_67P
LA2 = MURAT_BLM15BB221SN1D_2P
LA3-LA7 PR108 PR109 PR200 PR203 PR204 PR302 PR309 PR502 PR510 PR514 PR530 PR534 PR536 PR538 PR550 PR552 PR553 PR601 PR617 PR625 PR633 PR643 PR705 PR706 PR708 R177 RA109 RC51 RC54 RE5 RE18 RH17 RT4 = R_0603
LA9 LA10 LL1 = MURAT_BLM15AG121SN1D_L0402_2P
LE1 LE2 = KC_FBMA-L11-160808-800LMT_2P
LH1 = MURAT_LQM18FN4R7M00D_2P
LI1 LI7 LI10 = MURAT_DLW21SN900SQ2L_0805_4P
LI2-LI6 LI8 LI9 LI11-LI14 = MURAT_DLW21SN900HQ2L_0805_4P
LM1 LV2-LV6 = KC_WCM-2012HS-900T_4P
LM2 = MURAT_DLW21SN670HQ2L_4P
LR1 = TDK_MMZ1608R301AT_2P
LV8 = KC_FBMA-L11-201209-221LMA30_2P
LV9 LV14 LV15 = CHILI_PBY160808T-300Y-N_2P
PBATT1 = ACES_51481-01371-P01_13P
PC107 PC108 = C_APXK6R3ARA221MF451
PC530 PC531 PC609 = C_ECST250ADA101MF611
PD1 = TP0610K-T1-E3_SOT23-3
PD2 PD3 = TVNST52302AB0_SOT523-3
PD5 PD100 = BAS40CW_SOT323-3
PD101 = LL4148_LL34-2
PD700 = BAT54CW_SOT323-3
PH1 PH500 PH501 PR2-PR4 PR6 PR8 PR9 PR12-PR26 PR28 PR100-PR107 PR112-PR116 PR201 PR205-PR210 PR300 PR301 PR303 PR304 PR306-PR308 PR310-PR313 PR315-PR319 PR403 PR405-PR407 PR500 PR501 PR503-PR509 PR511 PR512 PR515 PR516 PR518-PR529 PR533 PR535 PR537 PR539 PR543-PR549 PR551 PR555-PR558 PR600 PR602 PR606 PR607 PR610 PR611 PR613-PR616 PR618-PR624 PR627 PR629 PR631 PR638 PR639 PR641 PR642 PR646 PR648-PR650 PR677 PR681 PR685 PR700 PR701 PR703 PR704 PR709-PR711 PR714-PR727 PR729-PR732 R2 R3 R144-R176 R179-R181 RA40-RA44 RA46-RA50 RA53 RA54 RA64 RA80 RA81 RA84-RA87 RA91 RA93 RA94 RA96 RA100 RA102 RA105-RA108 RA111-RA120 RA122 RA123 RA126-RA133 RA137-RA140 RC1 RC11 RC12 RC18 RC21-RC24 RC26 RC27 RC30 RC32-RC44 RC47-RC50 RC52 RC53 RC55-RC57 RD1-RD16 RE1 RE2 RE7-RE17 RE19-RE21 RE23 RE25-RE47 RE63 RE64 RE66 RE68 RE70 RE72 RE74-RE77 RE79-RE83 RE85 RE89 RE91-RE94 RE98-RE102 RF1-RF6 RH2-RH8 RH10-RH16 RH18-RH21 RH23 RH25-RH31 RH33-RH39 RH41-RH44 RH46 RH48 RH51 RH54 RH57-RH85 RH87 RH89 RH92-RH94 RH97-RH109 RH111-RH115 RH117-RH124 RH126 RH127 RH130-RH140 RH142 RH145 RH151 RH152 RH154-RH158 RH161 RI1 RI4 RI5 RI8 RI11 RI13 RI56 RI58-RI78 RL1-RL5 RL8-RL15 RM5 RM6 RM14 RM17-RM21 RM23 RM25-RM31 RM34 RM35 RM38-RM42 RM45 RM46 RM61-RM79 RM81-RM94 RN5-RN35 RR1-RR3 RR5-RR10 RT11-RT16 RU4-RU6 RV1 RV2 RV6-RV9 RV12-RV22 RV24 RV26 RV28-RV32 RV35 RV37-RV42 RV45 RV49-RV59 RV61-RV64 RV66-RV69 RV77-RV79 RV93 RV107-RV121 RV123 RV125 RV131-RV136 RV138 RV140-RV153 RV156 RV158-RV161 RV164-RV172 RV175 RV178 RV179 RV182 RV185 RV187-RV209 RV212-RV219 RV221 RV223 RV224 RV226 RV228-RV233 RV241-RV243 RV293-RV303 RV305 RV306 RV510-RV513 RV526-RV533 RV538 RV540-RV548 RV551-RV554 = R_0402
PJP202 PJP203 PJP301 PJP303-PJP305 PJP403 = JUMP_43X39
PJPDC1 = ACES_50293-0117N-001_11P
PL1 PL3-PL5 = CHENG_SMB3025500YA_2P
PL2 = MURAT_BLM15HG601SN1D_2P
PL100 PL300 PL701 = L_5X5X3_M_2P
PL101 PL102 = CYNTE_PCMC063T-3R3MN_2P
PL201 = L_7X7X3_M_2P
PL301 = L_10X10X4_M_2P
PL501-PL503 = PANAS_ETQP4LR15AFM_4P
PL504 = L_1812-1806
PL601-PL603 = CYNTE_PCME064T-R22MS0R985_2P
PL605 = TOKO_1239AS-H-1R0M-P2_2P
PL700 = CYNTE_PCMB104T-5R6MS_2P
PQ2 = RHU002N06_SOT323-3
PQ3 QV1 = SI3457CDV-T1-GE3_TSOP6
PQ4 PQ8 PQ610 PQ700 PQ705 Q2410 QA2 QA3 QH1 QN2 QN3 = SSM3K7002FU_SC70-3
PQ7 = FDV301N_NL_SOT23-3
PQ100 PQ102 PQ706 = SI7326DN-T1-E3_PAK1212-8
PQ101 PQ103 = SI7170DP-T1-GE3_POWERPAK8-5
PQ200 PQ201 PQ300 PQ301 = AON7520_DFN8-5
PQ302 = MDU1511RH_POWERDFN56-8-5
PQ303 PQ701-PQ704 PQ707 = MDU1516URH_POWERDFN56-8-5
PQ501-PQ506 PQ605-PQ609 PQ611 = AON6970_DFN5X6D-8-7
PQ710 = 2N7002DW-7-F_SOT363-6
PR110 PR111 PR202 PR305 PR314 PR513 PR541 PR554 PR608 PR626 PR640 PR674 PR707 PR713 = R_1206
PR603 PR604 = PS0612FKM070R005Z_1206-LE
PR702 PR712 = R_1206_4P-D
PU100 = TPS51285BRUKR_QFN20_3X3
PU200 = RT8207MZQW_WQFN20_3X3
PU300 PU301 = TPS51212DSCR_SON10_3X3
PU401 UA5 = RT9041E-15GQW_WDFN8_2X2
PU500 = ISL95812HRZ-T_QFN32_4X4
PU501 PU601 = ISL6208BCRZ-T_QFN8_2X2
PU600 = RT8813AGQW_WQFN24_4X4
PU602 = SY8036DBC_DFN10_3X3
PU700 = BQ24780RUYR_WQFN28_4X4
Q28-Q39 Q2411-Q2413 QA7 QA14 QE12 QE13 QE16 QH3 QH4 QM2 = DMN66D0LDW-7_SOT363-6
Q40 Q41 QN4 QN5 = 2N7002K_SOT23-3
Q2407 Q2408 = MMST3904-7-F_SOT323-3
Q2409 = SI3456DDV-T1-GE3_TSOP6
QA11-QA13 = AO3413_SOT23-3
QC1 = LBSS138LT1G_SOT23-3
QE1 QE3 QE4 QE6 QE7 QE9 QE10 QE14 = SSM3K7002F_SC59-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QF2 = MMBT3904WT1G_SC70-3
QL3 QV12 = 2N7002_SOT23-3
QV2 = 2N7002KW_SOT323-3
QV13 QV89 QV91 = 2N7002DW-T-R7_SOT363-6
QV21 QV23-QV25 = 2N7002W-T-R7_SOT323-3
R1 R178 R182 RA51 RA92 RC17 RC31 RC45 RC46 RE62 RE78 RH1 RH9 RH22 RH24 RH32 RH40 RH45 RH47 RH49 RH50 RH52 RH53 RH55 RH56 RH91 RH95 RH96 RH110 RH141 RH144 RH153 RM22 RM24 RM32 RM33 RM36 RM37 RV3 RV36 RV46 RV81 = R0402_0OHM
RA55 RA57 RH143 = R_0805
RA95 RE3 RE4 RE6 RH150 RT5 RT6 RV47 = R0603_0OHM
RA101 RE90 RP2 RPH1-RPH7 RR4 = RP_0804_8P4R
RH146-RH149 = R0805_0OHM
SW1 SW2 = SW_SMT1-05-A_4P
T1-T100 T102-T117 T119-T122 T124-T128 = TPC12
TL1 = BOTH_GST5009-CLF_24P
U17 U18 UV11 = TPS22966DPUR_SON14_2X3
U2407 = EMC1403-2-AIZL-TR_MSOP10
U2410 = ADM1032ARMZ-2REEL_MSOP8
UA1 = MALCOLM-EX_QFN56_7X7
UA3 = TS3A225ERTER_PWQFN16_3X3
UA4 = TPA3131D2DAPR_QFN32_5X5
UA6 = ISL54405IRUZ-T_UTQFN16_2P6X1P8
UC1 = 74AHC1G09GW_TSSOP5
UE1 = C8051F347-GQ_LQFP32_7X7
UE2 = EN25F80-75HCP_SO8
UE3 UE4 UE8 = TLC59116FIRHBR_VQFN32_5X5
UE5 = KB9012QF-A2_LQFP128_14X14
UE6 = KC3810_QFN24_4X4
UE7 = SN74LVC1G06DCKR_SC70-5
UE9 UM1 UT1 UV2 UV17 = SY6288C20AAC_SOT23-5
UH1 = LYNXPOINT_BGA_695P-T
UH2 UH3 UM3 UM7 UV14 = TC7SH08FU_SSOP5
UH4 = W25Q64FVSSIQ_SO8
UH5 = S-5711ACDL-M3T1S_SOT23-3
UI2 UI3 UL2 = SY6288D20AAC_SOT23-5
UL1 = E2201-BL3A-R_QFN40_5X5
UM4 = PI6CEQ20200LIEX_TSSOP20
UM8 = DS80PCI402SQNOPB_WQFN54_10X5P5
UN1 = PS8520BTQFN20GTR2_TQFN20_4X4
UN2 = LNG3DMTR_LGA16_3X3
UR1 = RTS5227-GR_QFN32_4X4
UT2 = AT97SC3205_TSSOP28
UU5 = TC7SZ14FU_SSOP5
UV1 = N15E-GX-A2_BGA_1745P
UV3 = SN74CBT3257CPWR_TSSOP16
UV4 = PS8407ATQFN40GTR2A0_TQFN40_5X5
UV5 UV18 = AP2330W-7_SC59-3
UV6-UV9 UV12 UV13 UV15 UV16 = H5GQ1H24AFR-T2L_BGA_170P
UV10 = AT25F512B-SSH-T_SO8
UV19 = MC74VHC1G09DFT2G_SC70-5
UV20 = INA3221AIRGVR_VQFN16_4X4
UV22 = TPS22969DNYR_SON8-7_3X3
YH1 = Y_9H03220008_2P
YH2 = Y_Q22FA2380049900_4P
YL1 = Y_FSX3M-25PM20FDO_4P
YV1 = Y_5YEA27000163IF50Q5_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002DW-T-R7_SOT363-6
  oval 0.381x1.397 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.725) 5(0.65,1.725) 6(0,1.725)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002KW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-01201-P01_12P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0)
  rect 1.194x1.702 smd: 13(10.1,-1.95) 14(-1.3,-1.95)
ACES_50271-00201-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50273-00401-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 2.108x2.997 smd: 5(-2.55,-2.9) 6(6.3,-2.9)
ACES_50278-00401-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50293-0117N-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_50473-0400M-002_40P-T
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.559x1.092 smd: 41(-0.9,0) 42(20.4,0)
  rect 1.397x1.905 smd: 43(22.6,-2.92) 44(-3.1,-2.92)
ACES_50552-02001-001_20P-T
  oval 0.406x1.803 smd: 1(0,0) 2(0.5,-2.6) 3(1,0) 4(1.5,-2.6) 5(2,0) 6(2.5,-2.6) 7(3,0) 8(3.5,-2.6) 9(4,0) 10(4.5,-2.6) 11(5,0) 12(5.5,-2.6) 13(6,0) 14(6.5,-2.6) 15(7,0) 16(7.5,-2.6) 17(8,0) 18(8.5,-2.6) 19(9,0) 20(9.5,-2.6)
  rect 1.397x2.896 smd: 21(-1.7,-1.3) 22(11.2,-1.3)
ACES_50552-03001-001_30P-T
  oval 0.406x1.803 smd: 1(0,0) 2(0.5,-2.6) 3(1,0) 4(1.5,-2.6) 5(2,0) 6(2.5,-2.6) 7(3,0) 8(3.5,-2.6) 9(4,0) 10(4.5,-2.6) 11(5,0) 12(5.5,-2.6) 13(6,0) 14(6.5,-2.6) 15(7,0) 16(7.5,-2.6) 17(8,0) 18(8.5,-2.6) 19(9,0) 20(9.5,-2.6) 21(10,0) 22(10.5,-2.6) 23(11,0) 24(11.5,-2.6) 25(12,0) 26(12.5,-2.6) 27(13,0) 28(13.5,-2.6) 29(14,0) 30(14.5,-2.6)
  rect 1.397x2.896 smd: 31(-1.7,-1.3) 32(16.2,-1.3)
ACES_50611-0100N-001_10P
  oval 0.61x1.651 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0) 13(6,0) 15(7,0) 17(8,0) 19(9,0)
  oval 0.61x1.854 smd: 2(0,3.75) 4(1,3.75) 6(2,3.75) 8(3,3.75) 10(4,3.75) 12(5,3.75) 14(6,3.75) 16(7,3.75) 18(8,3.75) 20(9,3.75)
ACES_51481-01371-P01_13P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0) 13(18,0)
ACES_87153-06411_6P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3)
  rect 0.787x1.499 smd: 7(3.5,3) 8(3.5,0) 9(-1,0) 10(-1,3)
ADM1032ARMZ-2REEL_MSOP8
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.3) 6(1.3,4.3) 7(0.65,4.3) 8(0,4.3)
AMPHE_G846A06201EU_6P-T
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,1.45) 8(5.3,1.45)
AO3413_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON6970_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7520_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AT25F512B-SSH-T_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.16) 6(2.54,5.16) 7(1.27,5.16) 8(0,5.16)
AT97SC3205_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
BAS40CW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54A-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54AW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54CW_SOT323-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BOTH_GST5009-CLF_24P
  oval 0.61x1.346 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(11,9.35) 14(10,9.35) 15(9,9.35) 16(8,9.35) 17(7,9.35) 18(6,9.35) 19(5,9.35) 20(4,9.35) 21(3,9.35) 22(2,9.35) 23(1,9.35) 24(0,9.35)
BQ24780RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C8051F347-GQ_LQFP32_7X7
  oval 0.457x1.753 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 17(5.6,8.654) 18(4.8,8.654) 19(4,8.654) 20(3.2,8.654) 21(2.4,8.654) 22(1.6,8.654) 23(0.8,8.654) 24(0,8.654)
  oval 1.753x0.457 smd: 9(7.127,1.527) 10(7.127,2.327) 11(7.127,3.127) 12(7.127,3.927) 13(7.127,4.727) 14(7.127,5.527) 15(7.127,6.327) 16(7.127,7.127) 25(-1.527,7.127) 26(-1.527,6.327) 27(-1.527,5.527) 28(-1.527,4.727) 29(-1.527,3.927) 30(-1.527,3.127) 31(-1.527,2.327) 32(-1.527,1.527)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_APXK6R3ARA221MF451
  oval 3.15x1.6 smd: 1(0,0) 2(5.05,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_ECST250ADA101MF611
  oval 3.505x1.6 smd: 1(0,0) 2(-5.4,0)
C_MP2VLPS330MC4R2
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
CHENG_SMB3025500YA_2P
  rect 2.997x1.803 smd: 1(0,0) 2(4,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CYNTE_PCMB104T-5R6MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYNTE_PCMC063T-3R3MN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCME064T-R22MS0R985_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
DAN202UT106_SC70-3
  oval 0.787x0.889 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DS80PCI402SQNOPB_WQFN54_10X5P5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 28(8.5,5.6) 29(8,5.6) 30(7.5,5.6) 31(7,5.6) 32(6.5,5.6) 33(6,5.6) 34(5.5,5.6) 35(5,5.6) 36(4.5,5.6) 37(4,5.6) 38(3.5,5.6) 39(3,5.6) 40(2.5,5.6) 41(2,5.6) 42(1.5,5.6) 43(1,5.6) 44(0.5,5.6) 45(0,5.6)
  oval 0.889x0.254 smd: 19(9.3,0.8) 20(9.3,1.3) 21(9.3,1.8) 22(9.3,2.3) 23(9.3,2.8) 24(9.3,3.3) 25(9.3,3.8) 26(9.3,4.3) 27(9.3,4.8) 46(-0.8,4.8) 47(-0.8,4.3) 48(-0.8,3.8) 49(-0.8,3.3) 50(-0.8,2.8) 51(-0.8,2.3) 52(-0.8,1.8) 53(-0.8,1.3) 54(-0.8,0.8)
  rect 7.493x3.505 smd: 55(4.25,2.8)
E2201-BL3A-R_QFN40_5X5
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.302x3.302 smd: 41(1.8,2.488)
EMC1403-2-AIZL-TR_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
EN25F80-75HCP_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_3V111T1-R240KKA-7H_20P-T
  round 0.991 hole 0.991 unplated: (-0.2,1.05) (5.6,1.05)
  round 0.762 hole 0.508: 1(0,0) 3(0.4,-1) 5(1.4,-1) 7(1.8,0) 9(2.2,1) 11(3.2,1) 13(3.6,0) 15(4,-1) 17(5,-1) 19(5.4,0)
  oval 0.356x1.803 smd: 2(0,2.9) 4(0.6,2.9) 6(1.2,2.9) 8(1.8,2.9) 10(2.4,2.9) 12(3,2.9) 14(3.6,2.9) 16(4.2,2.9) 18(4.8,2.9) 20(5.4,2.9)
  oval 1.194x2.21 hole 0.711x1.397: 21(8.3,2.3) 22(8.3,-1.2) 23(-2.9,-1.2) 24(-2.9,2.3)
FOX_AS0A621-H2R6-7H_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
FOX_AS0A621-HARN-7H_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 4.496x4.597 smd: 205(5.8,7.9) 206(-69.1,7.9)
FOX_AS0BC21-S85BB-7H_67P-T
  round 1.092 hole 1.092 unplated: (-0.75,-4.725)
  round 1.6 hole 1.6 unplated: (19.25,-4.725)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-6.45) 3(0.5,0) 4(0.75,-6.45) 5(1,0) 6(1.25,-6.45) 7(1.5,0) 8(1.75,-6.45) 9(2,0) 10(2.25,-6.45) 11(2.5,0) 12(4.75,-6.45) 13(5,0) 14(5.25,-6.45) 15(5.5,0) 16(5.75,-6.45) 17(6,0) 18(6.25,-6.45) 19(6.5,0) 20(6.75,-6.45) 21(7,0) 22(7.25,-6.45) 23(7.5,0) 24(7.75,-6.45) 25(8,0) 26(8.25,-6.45) 27(8.5,0) 28(8.75,-6.45) 29(9,0) 30(9.25,-6.45) 31(9.5,0) 32(9.75,-6.45) 33(10,0) 34(10.25,-6.45) 35(10.5,0) 36(10.75,-6.45) 37(11,0) 38(11.25,-6.45) 39(11.5,0) 40(11.75,-6.45) 41(12,0) 42(12.25,-6.45) 43(12.5,0) 44(12.75,-6.45) 45(13,0) 46(13.25,-6.45) 47(13.5,0) 48(13.75,-6.45) 49(14,0) 50(14.25,-6.45) 51(14.5,0) 52(14.75,-6.45) 53(15,0) 54(15.25,-6.45) 55(15.5,0) 56(15.75,-6.45) 57(16,0) 58(16.25,-6.45) 59(16.5,0) 60(16.75,-6.45) 61(17,0) 62(17.25,-6.45) 63(17.5,0) 64(17.75,-6.45) 65(18,0) 66(18.25,-6.45) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.225) 69(19.6,-0.225)
FUTUR_061-HA18-0001_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.2) 3(1,0) 4(1.5,1.2) 5(2,0) 6(2.5,1.2) 7(3,0) 8(3.5,1.2) 9(4,0) 10(4.5,1.2) 11(5,0) 12(5.5,1.2) 13(6,0) 14(6.5,1.2) 15(7,0) 16(7.5,1.2) 17(8,0) 18(8.5,1.2) 19(9,0)
  oval 1.6x2.21 hole 0.991x1.6: 20(11.75,0.7) 21(13.5,-7.7) 22(-4.5,-7.7) 23(-2.75,0.7)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_2P0N
  round 2.007 hole 2.007 unplated: (0,0)
H_2P0X2P3N
  oval 2.007x2.311 hole 2.007x2.311 unplated: (0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P5
  round 4.013 hole 3.505: 1(0,0)
H_3P5X4P1
  oval 4.013x4.597 hole 3.505x4.089: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
HASWELL_BGA_1364P-T
  round 0.406 smd: A3(-1.298,0) A4(-2.11,0) A5(-2.914,0) A6(-3.777,0) A8(-4.641,0) A9(-5.504,0) A48(-31.158,0) A49(-31.955,0) A50(-32.818,0) A51(-33.631,0) A52(-34.404,0) AA7(-4.593,13.569) AA8(-5.293,13.569) AA9(-5.993,13.569) AA46(-30.016,13.769) AA47(-30.766,13.769) AB8(-4.968,14.269) AB9(-5.668,14.269) AB45(-29.591,14.469) AB46(-30.341,14.469) AB48(-31.141,14.469) AC7(-4.593,15.069) AC8(-5.293,15.069) AC9(-5.993,15.069) AC46(-30.016,15.169) AC47(-30.766,15.169) AD8(-4.968,15.769) AD9(-5.668,15.769) AD45(-29.591,15.869) AD46(-30.341,15.869) AD48(-31.141,15.869) AE7(-4.593,16.469) AE8(-5.293,16.469) AE9(-5.993,16.469) AE46(-30.016,16.569) AE47(-30.766,16.569) AF8(-4.968,17.169) AF9(-5.668,17.169) AG7(-4.593,17.869) AG8(-5.293,17.869) AG9(-5.993,17.869) AG45(-29.591,17.269) AG46(-30.341,17.269) AG48(-31.141,17.269) AH8(-4.968,18.569) AH9(-5.668,18.569) AH46(-30.016,17.969) AH47(-30.766,17.969) AJ45(-29.591,18.669) AJ46(-30.341,18.669) AJ48(-31.141,18.669) AK7(-4.593,19.269) AK8(-5.293,19.269) AK9(-5.993,19.269) AK46(-30.016,19.369) AK47(-30.766,19.369) AL8(-4.968,19.969) AL9(-5.668,19.969) AL45(-29.591,20.069) AL46(-30.341,20.069) AL48(-31.141,20.069) AM7(-4.593,20.769) AM8(-5.293,20.769) AM9(-5.993,20.769) AM46(-30.016,20.769) AM47(-30.766,20.769) AN8(-4.968,21.469) AN9(-5.668,21.469) AN10(-6.687,21.794) AN12(-7.387,21.469) AN13(-8.087,21.794) AN14(-8.787,21.469) AN15(-9.512,21.794) AN16(-10.212,21.469) AN17(-10.912,21.794) AN18(-11.612,21.469) AN19(-12.336,21.794) AN20(-13.036,21.469) AN21(-13.736,21.794) AN22(-14.436,21.469) AN23(-15.087,21.794) AN24(-15.787,21.469) AN25(-16.487,21.794) AN26(-17.137,21.469) AN27(-17.837,21.794) AN29(-18.587,21.469) AN30(-19.287,21.794) AN31(-19.987,21.469) AN32(-20.687,21.794) AN33(-21.337,21.469) AN34(-22.037,21.794) AN35(-22.737,21.469) AN36(-23.437,21.794) AN37(-24.137,21.469) AN38(-24.787,21.794) AN39(-25.487,21.469) AN40(-26.187,21.794) AN41(-26.887,21.469) AN42(-27.538,21.794) AN43(-28.188,21.469) AN44(-28.888,21.794) AN45(-29.591,21.469) AN46(-30.341,21.469) AN48(-31.141,21.469) AP7(-4.593,22.169) AP8(-5.293,22.169) AP9(-5.993,22.169) AP10(-6.687,22.494) AP12(-7.387,22.169) AP13(-8.087,22.494) AP14(-8.787,22.169) AP15(-9.512,22.494) AP16(-10.212,22.169) AP17(-10.912,22.494) AP18(-11.612,22.169) AP19(-12.336,22.494) AP20(-13.036,22.169) AP21(-13.736,22.494) AP22(-14.436,22.169) AP23(-15.087,22.494) AP24(-15.787,22.169) AP25(-16.487,22.494) AP26(-17.137,22.169) AP27(-17.837,22.494) AP29(-18.587,22.169) AP30(-19.287,22.494) AP31(-19.987,22.169) AP32(-20.687,22.494) AP33(-21.337,22.169) AP34(-22.037,22.494) AP35(-22.737,22.169) AP36(-23.437,22.494) AP37(-24.137,22.169) AP38(-24.787,22.494) AP39(-25.487,22.169) AP40(-26.187,22.494) AP41(-26.887,22.169) AP42(-27.538,22.494) AP43(-28.188,22.169) AP44(-28.888,22.494) AP46(-30.016,22.169) AP47(-30.766,22.169) AR8(-4.968,22.869) AR9(-5.668,22.869) AR12(-7.387,22.869) AR14(-8.787,22.869) AR16(-10.212,22.869) AR18(-11.612,22.869) AR20(-13.036,22.869) AR22(-14.436,22.869) AR24(-15.787,22.869) AR26(-17.137,22.869) AR29(-18.587,22.869) AR31(-19.987,22.869) AR33(-21.337,22.869) AR35(-22.737,22.869) AR37(-24.137,22.869) AR39(-25.487,22.869) AR41(-26.887,22.869) AR43(-28.188,22.869) AR45(-29.591,22.869) AR46(-30.341,22.869) AR48(-31.141,22.869) AW1(0,25.856) AY54(-35.855,26.314) B2(-0.563,0.532) B3(-1.298,0.7) B4(-2.11,0.7) B5(-3.066,0.7) B51(-33.571,0.7) B52(-34.404,0.7) B53(-35.155,0.7) BA1(0,26.72) BA54(-35.855,27.177) BB1(0,27.584) BB54(-35.855,27.877) BC1(0,28.447) BC2(-0.7,28.352) BC53(-35.155,28.463) BC54(-35.855,28.577) BD1(0,29.147) BD2(-0.731,29.186) BD3(-1.431,29.186) BD53(-35.155,29.186) BD54(-35.855,29.277) BE2(-0.731,29.886) BE3(-1.431,29.886) BE4(-2.131,29.886) BE51(-33.751,29.886) BE52(-34.455,29.886) BE53(-35.155,29.886) BF3(-1.475,30.586) BF4(-2.175,30.586) BF5(-2.875,30.586) BF6(-3.739,30.586) BF7(-4.628,30.586) BF48(-31.526,30.586) BF49(-32.39,30.586) BF50(-33.09,30.586) BF51(-33.79,30.586) BF52(-34.49,30.586) C1(0,1.319) C2(-0.7,1.319) C3(-1.438,1.405) C4(-2.152,1.4) C52(-34.41,1.425) C53(-35.155,1.461) C54(-35.855,1.461) D1(0,2.131) D2(-0.7,2.131) D3(-1.4,2.131) D53(-35.155,2.161) D54(-35.855,2.161) E1(0,2.844) E2(-0.7,3.047) E54(-35.855,2.861) F1(0,3.708) F54(-35.855,3.561) G1(0,4.571) G8(-4.942,4.271) G9(-5.643,4.271) G10(-6.343,4.271) G11(-7.037,4.592) G12(-7.773,4.267) G13(-8.51,4.592) G14(-9.272,4.267) G16(-10.034,4.592) G17(-10.821,4.267) G18(-11.583,4.592) G19(-12.371,4.267) G20(-13.133,4.592) G21(-13.945,4.267) G23(-14.707,4.592) G24(-15.52,4.267) G25(-16.282,4.592) G26(-17.095,4.267) G27(-17.857,4.592) G29(-18.619,4.267) G30(-19.356,4.592) G31(-20.143,4.267) G32(-20.905,4.592) G33(-21.692,4.267) G34(-22.48,4.592) G36(-23.276,4.267) G37(-24.089,4.642) G54(-35.855,4.266) H7(-4.593,4.957) H8(-5.293,4.957) H9(-5.993,4.957) H11(-7.037,5.292) H12(-7.773,4.967) H13(-8.51,5.292) H14(-9.272,4.967) H16(-10.034,5.292) H17(-10.821,4.967) H18(-11.583,5.292) H19(-12.371,4.967) H20(-13.133,5.292) H21(-13.945,4.967) H23(-14.707,5.292) H24(-15.52,4.967) H25(-16.282,5.292) H26(-17.095,4.967) H27(-17.857,5.292) H29(-18.619,4.967) H30(-19.356,5.292) H31(-20.143,4.967) H32(-20.905,5.292) H33(-21.692,4.967) H34(-22.48,5.292) H36(-23.276,4.967) H37(-24.089,5.342) H38(-24.826,4.967) H39(-25.613,5.342) J1(0,5.435) J8(-4.942,5.671) J9(-5.643,5.671) J10(-6.343,5.671) J12(-7.773,5.667) J14(-9.272,5.667) J17(-10.821,5.667) J19(-12.371,5.667) J21(-13.945,5.667) J24(-15.52,5.667) J26(-17.095,5.667) J29(-18.619,5.667) J31(-20.143,5.667) J33(-21.692,5.667) J36(-23.276,5.667) J37(-24.089,6.042) J38(-24.826,5.667) J39(-25.613,6.042) K7(-4.593,6.334) K8(-5.293,6.334) K9(-5.993,6.334) K38(-24.826,6.367) L8(-4.942,7.071) L9(-5.642,7.071) L37(-24.089,6.742) L38(-24.826,7.067) L39(-25.613,6.742) L40(-26.401,7.067) L43(-28.009,7.067) L44(-28.796,7.067) L46(-29.89,7.067) L47(-30.69,7.067) M7(-4.593,7.858) M8(-5.293,7.858) M9(-5.993,7.858) M37(-24.089,7.442) M38(-24.826,7.767) M39(-25.613,7.442) M40(-26.401,7.767) M42(-27.188,7.442) M43(-28.009,7.767) M44(-28.796,7.767) M45(-29.54,7.768) M46(-30.341,7.768) M48(-31.141,7.768) N8(-4.968,8.57) N9(-5.668,8.57) N37(-24.089,8.142) N38(-24.826,8.467) N39(-25.613,8.142) N40(-26.401,8.467) N42(-27.188,8.142) N43(-28.009,8.467) N44(-28.796,8.467) N46(-29.889,8.378) N47(-30.766,8.378) P7(-4.593,9.27) P8(-5.293,9.27) P9(-5.993,9.27) P45(-29.591,9.021) P46(-30.341,9.021) P48(-31.141,9.021) R8(-4.968,9.97) R9(-5.668,9.97) R46(-29.94,9.651) R47(-30.766,9.651) T45(-29.591,10.268) T46(-30.341,10.268) T48(-31.141,10.268) U7(-4.593,10.72) U8(-5.293,10.72) U9(-5.993,10.72) U46(-30.016,10.968) U47(-30.766,10.968) V8(-4.968,11.42) V9(-5.668,11.42) V45(-29.591,11.669) V46(-30.341,11.669) V48(-31.141,11.669) W7(-4.593,12.12) W8(-5.293,12.12) W9(-5.993,12.12) W46(-30.016,12.369) W47(-30.766,12.369) Y8(-4.968,12.82) Y9(-5.668,12.82) Y45(-29.591,13.069) Y46(-30.341,13.069) Y48(-31.141,13.069)
  round 0.356 smd: A10(-6.368,0) A11(-7.181,0) A12(-7.994,0) A14(-8.806,0) A15(-9.619,0) A16(-10.432,0) A17(-11.245,0) A19(-12.058,0) A20(-12.87,0) A21(-13.683,0) A22(-14.496,0) A24(-15.309,0) A25(-16.122,0) A26(-16.934,0) A27(-17.747,0) A28(-18.56,0) A30(-19.347,0) A31(-20.135,0) A32(-20.922,0) A33(-21.71,0) A34(-22.497,0) A36(-23.284,0) A37(-24.072,0) A38(-24.859,0) A39(-25.647,0) A40(-26.434,0) A42(-27.221,0) A43(-28.009,0) A44(-28.796,0) A45(-29.584,0) A46(-30.371,0) AA1(0,13.614) AB1(0,14.426) AB54(-35.855,14.071) AC1(0,15.239) AC54(-35.855,14.884) AD54(-35.855,15.696) AE1(0,16.052) AE54(-35.855,16.509) AF1(0,16.865) AG1(0,17.678) AG54(-35.855,17.322) AH1(0,18.49) AH54(-35.855,18.135) AJ54(-35.855,18.948) AK1(0,19.303) AK54(-35.855,19.76) AL1(0,20.116) AM1(0,20.929) AM54(-35.855,20.573) AN1(0,21.742) AN54(-35.855,21.386) AP54(-35.855,22.199) AR1(0,22.554) AR54(-35.855,23.012) AT1(0,23.367) AT54(-35.855,23.824) AU1(0,24.18) AV1(0,24.993) AV54(-35.855,24.637) AW54(-35.855,25.45) BF9(-5.466,30.586) BF10(-6.279,30.586) BF11(-7.092,30.586) BF12(-7.904,30.586) BF14(-8.717,30.586) BF15(-9.53,30.586) BF16(-10.343,30.586) BF17(-11.156,30.586) BF18(-11.968,30.586) BF20(-12.781,30.586) BF21(-13.594,30.586) BF22(-14.407,30.586) BF23(-15.22,30.586) BF25(-16.032,30.586) BF26(-16.845,30.586) BF27(-17.658,30.586) BF28(-18.471,30.586) BF30(-19.284,30.586) BF31(-20.096,30.586) BF32(-20.909,30.586) BF33(-21.722,30.586) BF34(-22.535,30.586) BF36(-23.348,30.586) BF37(-24.16,30.586) BF38(-24.973,30.586) BF39(-25.786,30.586) BF41(-26.599,30.586) BF42(-27.412,30.586) BF43(-28.224,30.586) BF44(-29.037,30.586) BF46(-29.85,30.586) BF47(-30.663,30.586) H54(-35.855,5.13) J54(-35.855,5.943) K1(0,6.298) L1(0,7.111) L54(-35.855,6.756) M1(0,7.924) M54(-35.855,7.568) N54(-35.855,8.381) P1(0,8.737) P54(-35.855,9.194) R1(0,9.55) R54(-35.855,10.007) T1(0,10.362) U1(0,11.175) U54(-35.855,10.82) V1(0,11.988) V54(-35.855,11.632) W54(-35.855,12.445) Y1(0,12.801) Y54(-35.855,13.258)
  round 0.533 smd: A53(-35.155,0) B54(-35.855,0.7) BE1(0,29.897) BE54(-35.855,29.977) BF2(-0.726,30.586) BF53(-35.19,30.586)
  round 0.33 smd: AA2(-0.7,13.614) AA3(-1.4,13.614) AA4(-2.1,13.614) AA5(-2.8,13.614) AA6(-3.5,13.614) AA48(-31.516,13.769) AB2(-0.7,14.426) AB3(-1.4,14.426) AB4(-2.1,14.426) AB5(-2.8,14.426) AB6(-3.5,14.426) AB7(-4.268,14.269) AB49(-32.355,14.071) AB50(-33.055,14.071) AB51(-33.755,14.071) AB52(-34.455,14.071) AB53(-35.155,14.071) AC2(-0.7,15.239) AC3(-1.4,15.239) AC4(-2.1,15.239) AC5(-2.8,15.239) AC6(-3.5,15.239) AC48(-31.516,15.169) AC49(-32.355,14.884) AC50(-33.055,14.884) AC51(-33.755,14.884) AC52(-34.455,14.884) AC53(-35.155,14.884) AD7(-4.268,15.769) AD49(-32.355,15.696) AD50(-33.055,15.696) AD51(-33.755,15.696) AD52(-34.455,15.696) AD53(-35.155,15.696) AE2(-0.7,16.052) AE3(-1.4,16.052) AE4(-2.1,16.052) AE5(-2.8,16.052) AE6(-3.5,16.052) AE48(-31.516,16.569) AE49(-32.355,16.509) AE50(-33.055,16.509) AE51(-33.755,16.509) AE52(-34.455,16.509) AE53(-35.155,16.509) AF2(-0.7,16.865) AF3(-1.4,16.865) AF4(-2.1,16.865) AF5(-2.8,16.865) AF6(-3.5,16.865) AF7(-4.268,17.169) AG2(-0.7,17.678) AG3(-1.4,17.678) AG4(-2.1,17.678) AG5(-2.8,17.678) AG6(-3.5,17.678) AG49(-32.355,17.322) AG50(-33.055,17.322) AG51(-33.755,17.322) AG52(-34.455,17.322) AG53(-35.155,17.322) AH2(-0.7,18.49) AH3(-1.4,18.49) AH4(-2.1,18.49) AH5(-2.8,18.49) AH6(-3.5,18.49) AH7(-4.268,18.569) AH48(-31.516,17.969) AH49(-32.355,18.135) AH50(-33.055,18.135) AH51(-33.755,18.135) AH52(-34.455,18.135) AH53(-35.155,18.135) AJ49(-32.355,18.948) AJ50(-33.055,18.948) AJ51(-33.755,18.948) AJ52(-34.455,18.948) AJ53(-35.155,18.948) AK2(-0.7,19.303) AK3(-1.4,19.303) AK4(-2.1,19.303) AK5(-2.8,19.303) AK6(-3.5,19.303) AK48(-31.516,19.369) AK49(-32.355,19.76) AK50(-33.055,19.76) AK51(-33.755,19.76) AK52(-34.455,19.76) AK53(-35.155,19.76) AL2(-0.7,20.116) AL3(-1.4,20.116) AL4(-2.1,20.116) AL5(-2.8,20.116) AL6(-3.5,20.116) AL7(-4.268,19.969) AM2(-0.7,20.929) AM3(-1.4,20.929) AM4(-2.1,20.929) AM5(-2.8,20.929) AM6(-3.5,20.929) AM48(-31.516,20.769) AM49(-32.355,20.573) AM50(-33.055,20.573) AM51(-33.755,20.573) AM52(-34.455,20.573) AM53(-35.155,20.573) AN2(-0.7,21.742) AN3(-1.4,21.742) AN4(-2.1,21.742) AN5(-2.8,21.742) AN6(-3.5,21.742) AN7(-4.268,21.469) AN49(-32.355,21.386) AN50(-33.055,21.386) AN51(-33.755,21.386) AN52(-34.455,21.386) AN53(-35.155,21.386) AP48(-31.516,22.169) AP49(-32.355,22.199) AP50(-33.055,22.199) AP51(-33.755,22.199) AP52(-34.455,22.199) AP53(-35.155,22.199) AR2(-0.7,22.554) AR3(-1.4,22.554) AR4(-2.1,22.554) AR5(-2.8,22.554) AR6(-3.5,22.554) AR7(-4.268,22.869) AR49(-32.228,22.91) AR50(-33.055,23.012) AR51(-33.755,23.012) AR52(-34.455,23.012) AR53(-35.155,23.012) AT2(-0.7,23.367) AT3(-1.4,23.367) AT4(-2.1,23.367) AT5(-2.8,23.367) AT6(-3.827,23.585) AT8(-4.767,23.585) AT9(-5.706,23.585) AT10(-6.646,23.585) AT12(-7.586,23.585) AT13(-8.526,23.585) AT15(-9.466,23.585) AT16(-10.405,23.585) AT18(-11.345,23.585) AT19(-12.285,23.585) AT20(-13.225,23.585) AT22(-14.165,23.585) AT23(-15.104,23.585) AT25(-16.044,23.585) AT26(-16.984,23.585) AT27(-17.924,23.585) AT29(-18.864,23.585) AT30(-19.803,23.585) AT32(-20.743,23.585) AT33(-21.683,23.585) AT35(-22.623,23.585) AT36(-23.563,23.585) AT37(-24.502,23.585) AT39(-25.442,23.585) AT40(-26.382,23.585) AT42(-27.322,23.585) AT43(-28.262,23.585) AT45(-29.201,23.585) AT46(-30.141,23.585) AT47(-31.081,23.585) AT49(-32.021,23.585) AT50(-33.055,23.824) AT51(-33.755,23.824) AT52(-34.455,23.824) AT53(-35.155,23.824) AU2(-0.7,24.18) AU3(-1.4,24.18) AU4(-2.1,24.18) AU5(-2.8,24.18) AU6(-3.827,24.285) AU8(-4.767,24.285) AU9(-5.706,24.285) AU10(-6.646,24.285) AU12(-7.586,24.285) AU13(-8.526,24.285) AU15(-9.466,24.285) AU16(-10.405,24.285) AU18(-11.345,24.285) AU19(-12.285,24.285) AU20(-13.225,24.285) AU22(-14.165,24.285) AU23(-15.104,24.285) AU25(-16.044,24.285) AU26(-16.984,24.285) AU27(-17.924,24.285) AU29(-18.864,24.285) AU30(-19.803,24.285) AU32(-20.743,24.285) AU33(-21.683,24.285) AU35(-22.623,24.285) AU36(-23.563,24.285) AU37(-24.502,24.285) AU39(-25.442,24.285) AU40(-26.382,24.285) AU42(-27.322,24.285) AU43(-28.262,24.285) AU45(-29.201,24.285) AU46(-30.141,24.285) AU47(-31.081,24.285) AU49(-32.021,24.285) AV2(-0.7,24.993) AV3(-1.4,24.993) AV4(-2.1,24.993) AV5(-2.8,24.993) AV6(-3.827,24.985) AV8(-4.767,24.985) AV9(-5.706,24.985) AV10(-6.646,24.985) AV12(-7.586,24.985) AV13(-8.526,24.985) AV15(-9.466,24.985) AV16(-10.405,24.985) AV18(-11.345,24.985) AV19(-12.285,24.985) AV20(-13.225,24.985) AV22(-14.165,24.985) AV23(-15.104,24.985) AV25(-16.044,24.985) AV26(-16.984,24.985) AV27(-17.924,24.985) AV29(-18.864,24.985) AV30(-19.803,24.985) AV32(-20.743,24.985) AV33(-21.683,24.985) AV35(-22.623,24.985) AV36(-23.563,24.985) AV37(-24.502,24.985) AV39(-25.442,24.985) AV40(-26.382,24.985) AV42(-27.322,24.985) AV43(-28.262,24.985) AV45(-29.201,24.985) AV46(-30.141,24.985) AV47(-31.081,24.985) AV49(-32.021,24.985) AV50(-33.055,24.637) AV51(-33.755,24.637) AV52(-34.455,24.637) AV53(-35.155,24.637) AW2(-0.7,25.806) AW3(-1.4,25.806) AW4(-2.1,25.806) AW5(-2.8,25.806) AW6(-3.827,25.685) AW8(-4.767,25.685) AW9(-5.706,25.685) AW10(-6.646,25.685) AW12(-7.586,25.685) AW13(-8.526,25.685) AW15(-9.466,25.685) AW16(-10.405,25.685) AW18(-11.345,25.685) AW19(-12.285,25.685) AW20(-13.225,25.685) AW22(-14.165,25.685) AW23(-15.104,25.685) AW25(-16.044,25.685) AW26(-16.984,25.685) AW27(-17.924,25.685) AW29(-18.864,25.685) AW30(-19.803,25.685) AW32(-20.743,25.685) AW33(-21.683,25.685) AW35(-22.623,25.685) AW36(-23.563,25.685) AW37(-24.502,25.685) AW39(-25.442,25.685) AW40(-26.382,25.685) AW42(-27.322,25.685) AW43(-28.262,25.685) AW45(-29.201,25.685) AW46(-30.141,25.685) AW47(-31.081,25.685) AW49(-32.021,25.685) AW50(-33.055,25.45) AW51(-33.755,25.45) AW52(-34.455,25.45) AW53(-35.155,25.45) AY6(-3.827,26.386) AY8(-4.767,26.386) AY9(-5.706,26.386) AY10(-6.646,26.386) AY12(-7.586,26.386) AY13(-8.526,26.386) AY15(-9.466,26.386) AY16(-10.405,26.386) AY18(-11.345,26.386) AY19(-12.285,26.386) AY20(-13.225,26.386) AY22(-14.165,26.386) AY23(-15.104,26.386) AY25(-16.044,26.386) AY26(-16.984,26.386) AY27(-17.924,26.386) AY29(-18.864,26.386) AY30(-19.803,26.386) AY32(-20.743,26.386) AY33(-21.683,26.386) AY35(-22.623,26.386) AY36(-23.563,26.386) AY37(-24.502,26.386) AY39(-25.442,26.386) AY40(-26.382,26.386) AY42(-27.322,26.386) AY43(-28.262,26.386) AY45(-29.201,26.386) AY46(-30.141,26.386) AY47(-31.081,26.386) AY49(-32.021,26.386) AY50(-33.055,26.263) AY51(-33.755,26.263) AY52(-34.455,26.263) AY53(-35.155,26.263) B6(-3.93,0.7) B8(-4.742,0.7) B9(-5.555,0.7) B10(-6.368,0.7) B11(-7.181,0.7) B12(-7.994,0.7) B14(-8.806,0.7) B15(-9.619,0.7) B16(-10.432,0.7) B17(-11.245,0.7) B19(-12.058,0.7) B20(-12.87,0.7) B21(-13.683,0.7) B22(-14.496,0.7) B24(-15.309,0.7) B25(-16.122,0.7) B26(-16.934,0.7) B27(-17.747,0.7) B28(-18.56,0.7) B30(-19.347,0.7) B31(-20.135,0.7) B32(-20.922,0.7) B33(-21.71,0.7) B34(-22.497,0.7) B36(-23.284,0.7) B37(-24.072,0.7) B38(-24.859,0.7) B39(-25.647,0.7) B40(-26.434,0.7) B42(-27.221,0.7) B43(-28.009,0.7) B44(-28.796,0.7) B45(-29.584,0.7) B46(-30.371,0.7) B48(-31.158,0.7) B49(-31.946,0.7) B50(-32.733,0.7) BA2(-0.7,26.618) BA3(-1.4,26.618) BA4(-2.1,26.618) BA5(-2.8,26.618) BA6(-3.827,27.086) BA8(-4.767,27.086) BA9(-5.706,27.086) BA10(-6.646,27.086) BA12(-7.586,27.086) BA13(-8.526,27.086) BA15(-9.466,27.086) BA16(-10.405,27.086) BA18(-11.345,27.086) BA19(-12.285,27.086) BA20(-13.225,27.086) BA22(-14.165,27.086) BA23(-15.104,27.086) BA25(-16.044,27.086) BA26(-16.984,27.086) BA27(-17.924,27.086) BA29(-18.864,27.086) BA30(-19.803,27.086) BA32(-20.743,27.086) BA33(-21.683,27.086) BA35(-22.623,27.086) BA36(-23.563,27.086) BA37(-24.502,27.086) BA39(-25.442,27.086) BA40(-26.382,27.086) BA42(-27.322,27.086) BA43(-28.262,27.086) BA45(-29.201,27.086) BA46(-30.141,27.086) BA47(-31.081,27.086) BA49(-32.021,27.086) BA50(-33.055,27.076) BA51(-33.755,27.076) BA52(-34.455,27.076) BA53(-35.155,27.076) BB2(-0.7,27.431) BB3(-1.4,27.431) BB4(-2.1,27.431) BB5(-2.977,27.786) BB6(-3.79,27.786) BB7(-4.653,27.786) BB9(-5.466,27.786) BB10(-6.279,27.786) BB11(-7.092,27.786) BB12(-7.904,27.786) BB14(-8.717,27.786) BB15(-9.53,27.786) BB16(-10.343,27.786) BB17(-11.156,27.786) BB18(-11.968,27.786) BB20(-12.781,27.786) BB21(-13.594,27.786) BB22(-14.407,27.786) BB23(-15.22,27.786) BB25(-16.032,27.786) BB26(-16.845,27.786) BB27(-17.658,27.786) BB28(-18.471,27.786) BB30(-19.284,27.786) BB31(-20.096,27.786) BB32(-20.909,27.786) BB33(-21.722,27.786) BB34(-22.535,27.786) BB36(-23.348,27.786) BB37(-24.16,27.786) BB38(-24.973,27.786) BB39(-25.786,27.786) BB41(-26.599,27.786) BB42(-27.412,27.786) BB43(-28.224,27.786) BB44(-29.037,27.786) BB46(-29.85,27.786) BB47(-30.663,27.786) BB48(-31.476,27.786) BB49(-32.337,27.786) BB51(-33.405,27.692) BB52(-34.105,27.692) BB53(-34.805,27.692) BC3(-1.41,28.352) BC4(-2.12,28.352) BC5(-2.977,28.486) BC6(-3.79,28.486) BC7(-4.653,28.486) BC9(-5.466,28.486) BC10(-6.279,28.486) BC11(-7.092,28.486) BC12(-7.904,28.486) BC14(-8.717,28.486) BC15(-9.53,28.486) BC16(-10.343,28.486) BC17(-11.156,28.486) BC18(-11.968,28.486) BC20(-12.781,28.486) BC21(-13.594,28.486) BC22(-14.407,28.486) BC23(-15.22,28.486) BC25(-16.032,28.486) BC26(-16.845,28.486) BC27(-17.658,28.486) BC28(-18.471,28.486) BC30(-19.284,28.486) BC31(-20.096,28.486) BC32(-20.909,28.486) BC33(-21.722,28.486) BC34(-22.535,28.486) BC36(-23.348,28.486) BC37(-24.16,28.486) BC38(-24.973,28.486) BC39(-25.786,28.486) BC41(-26.599,28.486) BC42(-27.412,28.486) BC43(-28.224,28.486) BC44(-29.037,28.486) BC46(-29.85,28.486) BC47(-30.663,28.486) BC48(-31.476,28.486) BC49(-32.337,28.486) BC50(-32.956,28.836) BC52(-34.455,28.309) BD4(-2.131,29.186) BD5(-2.977,29.186) BD6(-3.79,29.186) BD7(-4.653,29.186) BD9(-5.466,29.186) BD10(-6.279,29.186) BD11(-7.092,29.186) BD12(-7.904,29.186) BD14(-8.717,29.186) BD15(-9.53,29.186) BD16(-10.343,29.186) BD17(-11.156,29.186) BD18(-11.968,29.186) BD20(-12.781,29.186) BD21(-13.594,29.186) BD22(-14.407,29.186) BD23(-15.22,29.186) BD25(-16.032,29.186) BD26(-16.845,29.186) BD27(-17.658,29.186) BD28(-18.471,29.186) BD30(-19.284,29.186) BD31(-20.096,29.186) BD32(-20.909,29.186) BD33(-21.722,29.186) BD34(-22.535,29.186) BD36(-23.348,29.186) BD37(-24.16,29.186) BD38(-24.973,29.186) BD39(-25.786,29.186) BD41(-26.599,29.186) BD42(-27.412,29.186) BD43(-28.224,29.186) BD44(-29.037,29.186) BD46(-29.85,29.186) BD47(-30.663,29.186) BD48(-31.476,29.186) BD49(-32.339,29.186) BD50(-32.956,29.536) BD51(-33.578,29.186) BE5(-2.977,29.886) BE6(-3.79,29.886) BE7(-4.653,29.886) BE9(-5.466,29.886) BE10(-6.279,29.886) BE11(-7.092,29.886) BE12(-7.904,29.886) BE14(-8.717,29.886) BE15(-9.53,29.886) BE16(-10.343,29.886) BE17(-11.156,29.886) BE18(-11.968,29.886) BE20(-12.781,29.886) BE21(-13.594,29.886) BE22(-14.407,29.886) BE23(-15.22,29.886) BE25(-16.032,29.886) BE26(-16.845,29.886) BE27(-17.658,29.886) BE28(-18.471,29.886) BE30(-19.284,29.886) BE31(-20.096,29.886) BE32(-20.909,29.886) BE33(-21.722,29.886) BE34(-22.535,29.886) BE36(-23.348,29.886) BE37(-24.16,29.886) BE38(-24.973,29.886) BE39(-25.786,29.886) BE41(-26.599,29.886) BE42(-27.412,29.886) BE43(-28.224,29.886) BE44(-29.037,29.886) BE46(-29.85,29.886) BE47(-30.663,29.886) BE48(-31.476,29.886) BE49(-32.339,29.886) C5(-3.066,1.4) C6(-3.93,1.4) C8(-4.742,1.4) C9(-5.555,1.4) C10(-6.368,1.4) C11(-7.181,1.4) C12(-7.994,1.4) C14(-8.806,1.4) C15(-9.619,1.4) C16(-10.432,1.4) C17(-11.245,1.4) C19(-12.058,1.4) C20(-12.87,1.4) C21(-13.683,1.4) C22(-14.496,1.4) C24(-15.309,1.4) C25(-16.122,1.4) C26(-16.934,1.4) C27(-17.747,1.4) C28(-18.56,1.4) C30(-19.347,1.4) C31(-20.135,1.4) C32(-20.922,1.4) C33(-21.71,1.4) C34(-22.497,1.4) C36(-23.284,1.4) C37(-24.072,1.4) C38(-24.859,1.4) C39(-25.647,1.4) C40(-26.434,1.4) C42(-27.221,1.4) C43(-28.009,1.4) C44(-28.796,1.4) C45(-29.584,1.4) C46(-30.371,1.4) C48(-31.158,1.4) C49(-31.946,1.4) C50(-32.733,1.4) C51(-33.571,1.451) D4(-2.1,2.234) D5(-3.066,2.1) D6(-3.93,2.1) D8(-4.742,2.1) D9(-5.555,2.1) D10(-6.368,2.1) D11(-7.181,2.1) D12(-7.994,2.1) D14(-8.806,2.1) D15(-9.619,2.1) D16(-10.432,2.1) D17(-11.245,2.1) D19(-12.058,2.1) D20(-12.87,2.1) D21(-13.683,2.1) D22(-14.496,2.1) D24(-15.309,2.1) D25(-16.122,2.1) D26(-16.934,2.1) D27(-17.747,2.1) D28(-18.56,2.1) D30(-19.347,2.1) D31(-20.135,2.1) D32(-20.922,2.1) D33(-21.71,2.1) D34(-22.497,2.1) D36(-23.284,2.1) D37(-24.072,2.1) D38(-24.859,2.1) D39(-25.647,2.1) D40(-26.434,2.1) D42(-27.221,2.1) D43(-28.009,2.1) D44(-28.796,2.1) D45(-29.584,2.1) D46(-30.371,2.1) D48(-31.158,2.1) D49(-31.946,2.1) D50(-32.733,2.1) D51(-33.571,2.151) D52(-34.359,2.151) E3(-1.4,3.047) E4(-2.1,3.047) E5(-3.066,2.8) E6(-3.93,2.8) E8(-4.742,2.8) E9(-5.555,2.8) E10(-6.368,2.8) E11(-7.181,2.8) E12(-7.994,2.8) E14(-8.806,2.8) E15(-9.619,2.8) E16(-10.432,2.8) E17(-11.245,2.8) E19(-12.058,2.8) E20(-12.87,2.8) E21(-13.683,2.8) E22(-14.496,2.8) E24(-15.309,2.8) E25(-16.122,2.8) E26(-16.934,2.8) E27(-17.747,2.8) E28(-18.56,2.8) E30(-19.347,2.8) E31(-20.135,2.8) E32(-20.922,2.8) E33(-21.71,2.8) E34(-22.497,2.8) E36(-23.284,2.8) E37(-24.072,2.8) E38(-24.859,2.8) E39(-25.647,2.8) E40(-26.434,2.8) E42(-27.221,2.8) E43(-28.009,2.8) E44(-28.796,2.8) E45(-29.584,2.8) E46(-30.371,2.8) E48(-31.158,2.8) E49(-31.946,2.8) E50(-32.733,2.8) E51(-33.571,2.851) E52(-34.359,2.851) E53(-35.155,2.861) F2(-0.7,3.86) F3(-1.4,3.86) F4(-2.1,3.86) F5(-3.066,3.5) F6(-3.93,3.5) F8(-4.742,3.5) F9(-5.555,3.5) F10(-6.368,3.5) F11(-7.181,3.5) F12(-7.994,3.5) F14(-8.806,3.5) F15(-9.619,3.5) F16(-10.432,3.5) F17(-11.245,3.5) F19(-12.058,3.5) F20(-12.87,3.5) F21(-13.683,3.5) F22(-14.496,3.5) F24(-15.309,3.5) F25(-16.122,3.5) F26(-16.934,3.5) F27(-17.747,3.5) F28(-18.56,3.5) F30(-19.347,3.5) F31(-20.135,3.5) F32(-20.922,3.5) F33(-21.71,3.5) F34(-22.497,3.5) F36(-23.284,3.5) F37(-24.072,3.5) F38(-24.859,3.5) F39(-25.647,3.5) F40(-26.434,3.5) F42(-27.221,3.5) F43(-28.009,3.5) F44(-28.796,3.5) F45(-29.584,3.5) F46(-30.371,3.5) F48(-31.158,3.5) F49(-31.946,3.5) F50(-32.733,3.5) F51(-33.571,3.551) F52(-34.359,3.551) F53(-35.155,3.561) G2(-0.7,4.673) G3(-1.4,4.673) G4(-2.1,4.673) G5(-2.8,4.673) G6(-3.5,4.673) G7(-4.242,4.271) G38(-24.826,4.267) G39(-25.613,4.642) G40(-26.401,4.267) G42(-27.221,4.2) G43(-28.009,4.2) G44(-28.796,4.2) G45(-29.584,4.2) G46(-30.371,4.2) G48(-31.158,4.2) G49(-31.946,4.2) G50(-32.733,4.2) G51(-33.571,4.251) G52(-34.359,4.251) G53(-35.155,4.312) H40(-26.401,4.967) H42(-27.221,4.9) H43(-28.009,4.9) H44(-28.796,4.9) H45(-29.584,4.9) H46(-30.371,4.9) H48(-31.158,4.9) H49(-31.946,4.9) H50(-33.055,5.13) H51(-33.755,5.13) H52(-34.455,5.13) H53(-35.155,5.13) J2(-0.7,5.486) J3(-1.4,5.486) J4(-2.1,5.486) J5(-2.8,5.486) J6(-3.5,5.486) J7(-4.242,5.671) J40(-26.401,5.667) J42(-27.188,6.042) J43(-28.009,5.6) J44(-28.796,5.6) J45(-29.584,5.6) J46(-30.371,5.6) J48(-31.158,5.6) J49(-32.355,5.943) J50(-33.055,5.943) J51(-33.755,5.943) J52(-34.455,5.943) J53(-35.155,5.943) K2(-0.7,6.298) K3(-1.4,6.298) K4(-2.1,6.298) K5(-2.8,6.298) K6(-3.5,6.298) K40(-26.401,6.367) K43(-28.009,6.367) K44(-28.796,6.367) K45(-29.534,6.367) K46(-30.334,6.367) K48(-31.16,6.367) L2(-0.7,7.111) L3(-1.4,7.111) L4(-2.1,7.111) L5(-2.8,7.111) L6(-3.5,7.111) L7(-4.242,7.071) L42(-27.188,6.742) L48(-31.516,7.067) L49(-32.355,6.756) L50(-33.055,6.756) L51(-33.755,6.756) L52(-34.455,6.756) L53(-35.155,6.756) M2(-0.7,7.924) M3(-1.4,7.924) M4(-2.1,7.924) M5(-2.8,7.924) M6(-3.5,7.924) M49(-32.355,7.568) M50(-33.055,7.568) M51(-33.755,7.568) M52(-34.455,7.568) M53(-35.155,7.568) N7(-4.268,8.57) N48(-31.516,8.378) N49(-32.355,8.381) N50(-33.055,8.381) N51(-33.755,8.381) N52(-34.455,8.381) N53(-35.155,8.381) P2(-0.7,8.737) P3(-1.4,8.737) P4(-2.1,8.737) P5(-2.8,8.737) P6(-3.5,8.737) P49(-32.355,9.194) P50(-33.055,9.194) P51(-33.755,9.194) P52(-34.455,9.194) P53(-35.155,9.194) R2(-0.7,9.55) R3(-1.4,9.55) R4(-2.1,9.55) R5(-2.8,9.55) R6(-3.5,9.55) R7(-4.268,9.97) R48(-31.516,9.651) R49(-32.355,10.007) R50(-33.055,10.007) R51(-33.755,10.007) R52(-34.455,10.007) R53(-35.155,10.007) T2(-0.7,10.362) T3(-1.4,10.362) T4(-2.1,10.362) T5(-2.8,10.362) T6(-3.5,10.362) U2(-0.7,11.175) U3(-1.4,11.175) U4(-2.1,11.175) U5(-2.8,11.175) U6(-3.5,11.175) U48(-31.516,10.968) U49(-32.355,10.82) U50(-33.055,10.82) U51(-33.755,10.82) U52(-34.455,10.82) U53(-35.155,10.82) V2(-0.7,11.988) V3(-1.4,11.988) V4(-2.1,11.988) V5(-2.8,11.988) V6(-3.5,11.988) V7(-4.268,11.42) V49(-32.355,11.632) V50(-33.055,11.632) V51(-33.755,11.632) V52(-34.455,11.632) V53(-35.155,11.632) W48(-31.516,12.369) W49(-32.355,12.445) W50(-33.055,12.445) W51(-33.755,12.445) W52(-34.455,12.445) W53(-35.155,12.445) Y2(-0.7,12.801) Y3(-1.4,12.801) Y4(-2.1,12.801) Y5(-2.8,12.801) Y6(-3.5,12.801) Y7(-4.268,12.82) Y49(-32.355,13.258) Y50(-33.055,13.258) Y51(-33.755,13.258) Y52(-34.455,13.258) Y53(-35.155,13.258)
