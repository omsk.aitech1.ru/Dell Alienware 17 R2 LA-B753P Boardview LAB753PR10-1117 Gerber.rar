# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_CMD MS_D2: length 2.4
  TOP w0.127: UR1.19 327.88,21.91 327.96,21.99 v1(327.96,22.18) 327.96,22.6 RR5.1
SD_CMD MS_D2_R: length 40.1
  TOP w0.127: RR5.2 v3(327.37,25.07)
  IN6 w0.099: v3(304.34,26.44) 307.19,23.59 324.29,23.59 324.3,23.6 324.7,23.6 324.8,23.5 324.8,22.58 324.89,22.48 325.2,22.48 325.3,22.58 325.3,23.5 325.4,23.6 325.71,23.6 325.81,23.5 325.81,22.58 325.91,22.48 326.21,22.48 326.31,22.58 326.31,23.5 326.41,23.6 326.71,23.6 326.84,23.47 326.84,22.57 326.96,22.44 327.24,22.44 327.37,22.57 v3(327.37,25.07)
  BOTTOM w0.127: JCR.10 303.78,25.18 304.34,25.74 v3(304.34,26.44) 304.34,28.23 303.58,28.98 JCR.6
SD_D0 MS_D1: length 3.5
  TOP w0.127: RR8.1 330.99,22.49 330.42,21.92 v1(330.42,21.53) 330.42,21.06 329.77,20.41 UR1.16
SD_D0 MS_D1_R: length 39.7
  TOP w0.127: RR8.2 v3(333.35,22.49)
  IN1 w0.099: v3(333.35,22.49) 332.98,22.13 305.95,22.13 v3(304.13,20.31)
  BOTTOM w0.127: JCR.13 303.86,22.14 304.13,21.87 v3(304.13,20.31) 304.13,17.78 303.17,16.82 JCR.18
SD_D1: length 3.2
  TOP w0.127: UR1.15 330.31,20.01 v1(330.46,20.16) 330.9,20.6 330.9,21.36 331.06,21.52 RR7.1
SD_D1_R: length 35.2
  TOP w0.127: RR7.2 333.16,21.52 v3(333.33,21.69)
  IN1 w0.099: v3(333.33,21.69) 310.72,21.69 v3(303.57,14.54)
  BOTTOM w0.127: JCR.19 303.57,14.54 v3(303.57,14.54)
SD_D2 MS_CLK: length 3.7
  TOP w0.127: RR3.2 325.19,22.89 v1(325.19,22.23) 325.68,21.73 326.81,21.73 327.08,21.46 UR1.21
SD_D2 MS_CLK_R: length 41.5
  TOP w0.127: RR3.1 v3(325.49,24.91)
  IN6 w0.099: v3(325.49,24.91) 325.05,24.47 316.79,24.47 316.66,24.59 316.66,25.48 316.53,25.61 316.26,25.61 316.14,25.48 316.14,24.58 316.04,24.48 315.73,24.48 315.63,24.58 315.63,25.49 315.5,25.62 315.25,25.62 315.13,25.49 315.13,24.58 315.03,24.48 314.72,24.48 314.62,24.58 314.62,25.5 314.49,25.63 314.23,25.63 314.1,25.5 314.1,24.6 313.97,24.47 313.7,24.47 313.58,24.6 313.58,25.58 313.45,25.71 309.39,25.71 v3(304.15,30.94)
  BOTTOM w0.127: RR10.2 JCR.1 303.13,33.54 303.96,32.7 303.96,31.99 304.15,31.8 v3(304.15,30.94) 304.15,29.92 303.97,29.74 JCR.5
SD_D3 MS_D3: length 2.7
  TOP w0.127: RR6.1 326.45,22.36 v1(326.61,22.2) 326.87,22.2 327.48,21.6 UR1.20
SD_D3 MS_D3_R: length 39
  TOP w0.127: RR6.2 326.45,24.9 v3(326.44,24.91)
  IN6 w0.099: v3(326.44,24.91) 325.57,24.03 313.32,24.03 313.2,24.16 313.2,25.31 313.07,25.44 312.76,25.44 312.64,25.31 312.64,24.17 312.51,24.04 312.19,24.04 312.07,24.17 312.07,25.29 311.94,25.41 309.06,25.41 304.59,29.89 301.18,29.89 v3(300.73,30.34)
  BOTTOM w0.127: JCR.3 300.92,32.02 300.73,31.83 v3(300.73,30.34) 300.73,28.72 301.22,28.22 JCR.7
SD_WP MS_BS: length 44.3
  TOP w0.127: v3(324.08,18.7) 324.2,18.81 UR1.29
  IN4 w0.091: v3(324.08,18.7) 323.18,17.79 323.18,16.27 323.05,16.14 322.7,16.14 322.57,16.27 322.57,17.96 322.44,18.09 322.07,18.09 321.95,17.96 321.95,16.27 321.82,16.14 321.48,16.14 321.35,16.27 321.35,17.96 321.22,18.09 320.87,18.09 320.74,17.96 320.74,16.27 320.61,16.14 v3(300.78,16.14)
  BOTTOM w0.127: JCR.22 301.15,12.26 300.78,12.64 v3(300.78,16.14) 300.78,20.22 301.18,20.62 JCR.15
SDA: length 3.2
  TOP w0.127: PR505.2 134.95,131.01 PR500.1 136.13,129.84 v3(136.13,129.58)
  BOTTOM w0.127: v3(136.13,129.58) 136.13,129.15 PU500.31
SENSE A#: length 5.5
  TOP w0.203: RA49.2 25.12,13.76 24.62,14.26 v1(24.22,14.26) 23.65,14.26 23.59,14.2 UA1.47
  TOP w0.254: RA49.2 RA47.2 25.12,11.72 RA48.2 RA46.2
SENSOR_DIODE_N1: length 25.8
  IN6 w0.099: v3(215.24,119.72) 214.18,120.79 212.53,120.79 211.36,121.96 209.16,121.96 204.53,126.58 202.14,126.58 201.79,126.93 v3(201.18,126.93)
  BOTTOM w0.127: v1(215.75,124.09) 216.33,123.51 216.33,122.72 216.96,122.1 216.96,121.53 QF2.3
  BOTTOM w0.254: v3(201.18,126.93) 200.93,127.18 CF3.2 201.16,127.81 U2410.3 ; QF2.3 216.52,120.54 216.65,120.41 CF2.2 216.37,119.72 v3(215.24,119.72)
SENSOR_DIODE_P1: length 26.6
  IN6 w0.099: v3(201.63,126.51) 201.78,126.35 204.44,126.35 209.06,121.73 211.27,121.73 212.44,120.56 213.71,120.56 215.03,119.24 v3(215.65,119.24)
  BOTTOM w0.127: v1(217.58,124.09) 217.17,123.69 QF2.1
  BOTTOM w0.254: v3(201.63,126.51) 201.84,126.72 CF3.1 201.81,127.6 U2410.2 ; QF2.1 217.43,122.75 217.43,121.5 QF2.2 217.82,120.55 217.57,120.3 CF2.1 216.8,119.24 v3(215.65,119.24)
SERIRQ: length 126
  TOP w0.102: 210.89,35.45 211.53,35.45 211.72,35.26 211.72,33.97 212.62,33.07 214.31,33.07 214.31,33.07 215.21,33.07 215.75,32.53 216.4,32.53 216.89,33.02 216.89,33.23 v3(217.39,33.73)
  TOP w0.127: UE5.3 287.6,26.55 287.77,26.38 287.77,26.01 v3(287.23,25.47) ; RH98.2 210.06,35.45 210.89,35.45
  IN1 w0.099: v3(235.84,14.82) 233.75,14.82 232.73,13.8 226.06,13.8 224.51,15.35 215.92,15.35 215.29,15.98 215.29,20.27 215.89,20.86 215.89,22.33 216.18,22.62 216.18,24.13 216.04,24.27 216.04,26.93 217.45,28.34 217.45,30.47 217.85,30.86 217.85,33.26 217.39,33.71 v3(217.39,33.73)
  IN6 w0.099: v3(285.56,10.38) 284.42,9.23 274.9,9.23 271.78,12.36 271.78,13.72 271.25,14.25 270.54,14.25 270.01,14.78 264.88,14.78 262.83,12.73 242.94,12.73 242.58,12.37 237.87,12.37 236.86,13.39 236.86,14.48 236.51,14.82 v3(235.84,14.82)
  BOTTOM w0.089: v3(217.39,33.73) 217.73,33.4 UH1.AL11
  BOTTOM w0.127: v3(285.56,10.38) v1(285.56,12.09) 285.56,15.06 285.74,15.24 285.74,16.31 286.03,16.6 286.03,21.78 286.36,22.11 286.36,23.81 287.23,24.68 v3(287.23,25.47)
SIO_PWRBTN#_R: length 5.7
  TOP w0.127: v3(226.23,28.44) 225.72,28.44 v1(225.41,28.13) 225.41,27.18 224.61,26.38 224.61,24.56 RH56.2
  BOTTOM w0.089: v3(226.23,28.44) 226.22,28.44 226.22,28.67 226.35,28.8 UH1.K1
SLP_S3: length 5.5
  BOTTOM w0.127: RE15.2 263.51,19.32 263.48,19.32 QE1.1 262.69,20.87 v1(263.25,21.43) 264.51,22.69
SLP_S5: length 12.6
  BOTTOM w0.127: UE1.21 270.04,22.71 271.2,22.71 272.06,23.57 272.49,23.57 274.3,21.77 275.36,21.77 v1(275.76,21.37) 276.08,21.06 QE3.1 275.48,19.39 273.76,19.39
SM_RCOMP0: length 10.3
  TOP w0.381: v3(95.24,73.9) 95.8,73.34 95.8,70.98 96.71,70.07 v2(96.71,68.98) RC21.1
  BOTTOM w0.254: CPU1.BB51 94.82,74.31 94.96,74.17 94.96,74.15 95.21,73.91 95.22,73.91 95.22,73.9 v3(95.24,73.9)
SM_RCOMP1: length 11.4
  TOP w0.381: v3(92.93,74.34) 91.98,73.39 v2(91.98,72.89) 91.98,72.52 93.77,70.73 93.77,70.02 94.43,69.37 RC22.1
  BOTTOM w0.254: CPU1.BB53 92.97,74.38 v3(92.93,74.34)
SM_RCOMP2: length 12.1
  TOP w0.381: RC23.1 95.57,69.69 94.79,70.47 94.79,71.23 v2(94.32,71.7) 93.03,72.99 93.03,73.6 93.46,74.03 94.47,74.03 v3(94.52,73.98)
  BOTTOM w0.254: CPU1.BB52 94.14,74.38 94.53,73.98 v3(94.52,73.98)
SML0CLK: length 120.7
  TOP w0.089: 226.74,28.41 226.74,28.42 226.75,28.44 226.75,28.52 226.07,29.2 224.66,29.2 224.03,29.83 224.03,30.77 224.12,30.86 224.12,31.48 v3(223.74,31.85)
  TOP w0.127: 226.74,28.41 226.74,25.54 226.52,25.31 RPH4.4
  IN6 w0.099: v3(223.74,31.85) 224.18,32.3 224.18,34.1 223.9,34.38 223.59,34.38 223.27,34.7 223.27,35.65 223.65,36.03 224.55,36.03 224.91,36.39 224.91,38.44 224.51,38.84 224.01,38.84 223.22,39.64 223.22,40.36 223.86,41.01 224.56,41.01 224.63,41.08 224.85,41.29 224.85,42.51 225.14,42.81 225.14,46.5 224.57,47.07 224.57,55.55 226.06,57.05 226.97,57.05 v3(227.14,57.22)
  BOTTOM w0.089: UH1.U8 223.39,32.2 v3(223.74,31.85)
  BOTTOM w0.127: RM36.1 215.11,118.25 214.9,118.25 214.31,117.65 213.1,117.65 212.57,117.13 212.57,113.94 215.11,111.41 216.88,111.41 220.96,107.33 223.81,107.33 229.26,101.88 230.48,101.88 233.07,99.29 233.07,98.72 234.13,97.66 234.13,66.95 233.25,66.07 233.25,62.31 232.6,61.66 227.93,56.99 227.37,56.99 v3(227.14,57.22)
SML0DATA: length 120.1
  TOP w0.089: v3(224.73,31.87) 224.33,31.47 224.33,30.77 224.25,30.68 224.25,29.92 224.75,29.42 226.16,29.42 226.97,28.61 226.97,28.52 226.98,28.51 226.98,28.44 227,28.42 227,28.41
  TOP w0.127: RPH4.3 227.02,25.4 227,25.43 227,28.41
  IN6 w0.099: v3(227.14,56.63) 226.95,56.82 226.16,56.82 224.79,55.46 224.79,47.16 225.36,46.59 225.36,42.71 225.07,42.42 225.07,41.2 224.79,40.92 224.65,40.78 223.95,40.78 223.44,40.27 223.44,39.73 224.11,39.07 224.6,39.07 225.13,38.54 225.13,36.29 224.64,35.81 223.74,35.81 223.49,35.56 223.49,34.79 223.68,34.61 224,34.61 224.41,34.19 224.41,32.19 v3(224.73,31.87)
  BOTTOM w0.089: v3(224.73,31.87) 224.47,31.61 UH1.R7
  BOTTOM w0.127: RM37.1 215.08,117.99 215.01,117.99 214.42,117.4 213.2,117.4 212.83,117.03 212.83,114.05 215.22,111.66 216.99,111.66 221.06,107.58 223.92,107.58 229.36,102.14 230.58,102.14 233.33,99.39 233.33,98.82 234.38,97.77 234.38,66.84 233.5,65.97 233.5,62.21 228.04,56.75 227.25,56.75 v3(227.14,56.63)
SML1CLK: length 31.6
  TOP w0.089: v3(226.75,30.95) 226.75,30.63 226.75,29.65 227.98,28.43 227.98,28.41
  TOP w0.127: QH3.6 231.09,18.93 231.69,19.52 233.75,19.52 234.44,20.22 234.44,21.42 234.83,21.81 235.79,21.81 v3(235.97,21.63) ; RPH4.2 227.52,25.11 227.52,25.11 227.52,27.44 227.98,27.89 227.98,28.41
  IN1 w0.099: v3(235.97,21.63) 235.76,21.84 235.37,21.84 235.03,22.17 235.03,24.37 234.22,25.18 234.22,27.05 230.12,31.15 230.12,31.85 229.49,32.48 229,32.48 228.59,32.07 228,32.07 227.56,31.63 227.38,31.63 226.75,31 v3(226.75,30.95)
  BOTTOM w0.089: UH1.K6 226.69,31.01 v3(226.75,30.95)
SML1DATA: length 38.3
  TOP w0.089: 228.23,28.41 228.23,28.42 228.21,28.44 228.21,28.51 228.07,28.65 228.06,28.65 226.97,29.74 226.97,30.54 227.24,30.81 227.24,31.59 226.87,31.96 226.43,31.96 225.78,32.6 v3(225.78,33.08)
  TOP w0.127: v3(235.97,22.21) 235.79,22.04 234.76,22.04 234.74,22.06 234.73,22.06 234.19,21.53 234.19,20.33 233.64,19.78 231.95,19.78 231.66,20.07 231.66,20.74 231.25,21.15 230.1,21.15 229.79,20.84 QH3.3 ; 228.23,28.41 228.23,27.79 227.78,27.33 227.78,25.3 228.02,25.06 RPH4.1
  IN1 w0.099: v3(235.97,22.21) 235.82,22.06 235.46,22.06 235.26,22.27 235.26,24.46 234.44,25.28 234.44,27.14 230.34,31.24 230.34,31.94 229.58,32.7 228.9,32.7 228.5,32.3 227.9,32.3 227.47,31.86 227.01,31.86 v3(225.78,33.08)
  BOTTOM w0.089: v3(225.78,33.08) 225.47,33.4 UH1.N11
SNB_CPU_P1: length 2.1
  TOP w0.127: PR554.1 128.77,121.87 v1(128.77,122.24)
SNB_CPU_P2: length 1.5
  TOP w0.127: PC524.2 v1(117.29,118.89)
SNB_CPU_P3: length 1.7
  TOP w0.127: PC508.2 v1(109.16,118.86)
SNUB_+1.05V_GPUP: length 3
  BOTTOM w0.127: v1(146.43,83.83) 145.37,83.83 PC662.1
  BOTTOM w0.508: PC662.1 PR674.2
SNUB_CHG: length 6.1
  TOP w0.127: v1(49.85,42.99) 49.85,42.97 50.37,42.45 50.37,40.54 51.64,39.27 PR713.2
  TOP w0.508: PR713.2 51.17,38.75 PC715.1
SPI_MOCLK: length 4
  BOTTOM w0.127: UE1.2 260.8,29.69 260.8,30.25 v1(260.48,30.57) RE3.1
SPI_MOCLK_R: length 14.1
  IN6 w0.099: v3(254.01,42.59) 254.71,41.89 254.71,41.23 260.06,35.88 v3(260.06,33.59)
  BOTTOM w0.127: RE3.2 259.64,33.17 v3(260.06,33.59) ; v3(254.01,42.59) 253.63,42.2 RE11.2 CE57.1
SPI_MOCS#: length 14.3
  TOP w0.127: v3(262.89,27.79) v1(262.89,28.6)
  IN6 w0.099: v3(262.89,27.79) 260.91,29.77 260.4,29.77 v3(260.2,29.97)
  BOTTOM w0.127: v3(262.89,27.79) 262.89,26.73 UE1.31 ; RE12.2 258.23,34.67 257.62,34.06 UE2.1 257.62,32.22 259.88,29.97 v3(260.2,29.97)
SPI_MOSI: length 19.6
  BOTTOM w0.127: RE9.2 252.54,38.94 252.54,32.92 253.75,31.71 254.95,31.71 256.71,29.96 v1(257.88,29.96) 260.68,27.15 261.58,27.15 261.8,26.94 261.8,26.77 UE1.32
SPI_MOSO: length 5.4
  BOTTOM w0.127: RE10.2 v1(259.38,29.21) 259.53,29.06 260.3,29.06 UE1.1
SPI_PCH_DO2_R: length 27.5
  IN4 w0.091: v3(216.38,20.04) 216.18,19.84 214.67,19.84 214.52,19.69 214.52,18.86 214.4,18.74 214.03,18.74 213.91,18.86 213.91,19.69 213.79,19.81 211.71,19.81 211.58,19.69 211.58,18.87 211.46,18.74 210.95,18.74 210.82,18.86 210.82,19.49 210.7,19.62 210.34,19.62 210.21,19.49 210.21,18.86 210.09,18.74 208.72,18.74 v3(208.16,18.19)
  BOTTOM w0.127: UH4.3 205.48,18.44 205.6,18.57 205.6,19.6 205.73,19.73 206.08,19.73 206.21,19.6 206.21,19.12 206.34,19 206.59,19 206.72,19.12 206.72,19.45 206.83,19.56 209.63,19.56 209.74,19.45 209.74,19.01 209.62,18.89 207.46,18.89 207.33,18.76 207.33,18.32 207.46,18.19 v3(208.16,18.19) ; RPH5.4 217.06,18.62 216.74,18.94 216.74,19.69 v3(216.38,20.04) 216.14,20.28 RH106.2
SPI_PCH_DO3_R: length 30.9
  BOTTOM w0.127: UH4.7 212.47,17.17 212.7,16.95 212.7,16.46 213.25,15.91 213.25,15.65 213.36,15.53 v1(213.79,15.53) 214.19,15.53 214.7,15.03 216.1,15.03 216.54,15.46 216.54,16.73 216.66,16.85 217.62,16.85 217.74,16.73 217.74,15.27 218.06,14.95 218.25,14.95 218.38,15.08 218.38,16.93 218.51,17.06 218.82,17.06 218.95,16.93 218.95,15.08 219.08,14.95 219.33,14.95 219.46,15.08 219.46,17.36 219.59,17.49 219.9,17.49 220.03,17.36 220.03,16.41 220.08,16.36 RH105.2 220.6,17.62 220.73,17.74 220.92,17.74 221.43,18.25 221.43,18.63 221.17,18.89 220.3,18.89 220.19,18.99 220.19,20.06 220.07,20.18 219.81,20.18 219.69,20.06 219.69,18.63 219.56,18.51 219.27,18.51 219.14,18.63 219.14,18.76 219.01,18.89 217.68,18.89 217.56,18.76 RPH5.3
SPK_L1-_CONN: length 5.5
  TOP w0.508: JSPK.3 35.87,14.3 v2(35.4,13.83) 35.16,13.59 CA33.1 33.26,13.59 LA5.2
SPK_L2+_CONN: length 5.6
  TOP w0.508: LA6.2 33.57,16.25 CA29.1 34.93,16.25 v2(35.4,15.78) 35.62,15.55 JSPK.4
SPK_MUTE: length 30.2
  IN6 w0.254: v3(9.49,27.28) 8.8,26.59 8.8,26.28 7.52,25 7.52,22.83 4.78,20.08 4.78,13 5.66,12.12 6.38,12.12 7.34,11.15 9.74,11.15 10.34,11.75 12.27,11.75 12.75,12.23 v3(12.75,12.75)
  BOTTOM w0.254: QA2.1 14.54,13.73 RA43.1 14.04,13.18 13.92,13.3 13.18,13.3 12.75,12.87 v3(12.75,12.75) ; v3(9.49,27.28) 9.38,27.4 8.82,27.4 UA4.7
SPK_MUTE#: length 34.5
  TOP w0.254: v3(8.17,17.49) 8.17,17.77 9.43,19.03 JIO.29
  IN1 w0.254: v3(2.33,15.88) 1.93,16.27 1.93,18.74 2.73,19.55 2.73,23.59 3.67,24.53 3.67,26.51 4.1,26.94 v3(4.1,29.19)
  IN4 w0.254: v3(8.17,17.49) 6.54,15.85 6.54,14.67 5.69,13.82 v3(5.36,13.82) 5.22,13.82 3.16,15.88 v3(2.33,15.88)
  BOTTOM w0.127: DE3.1 7.36,11.8 v1(6.42,10.86)
  BOTTOM w0.254: DE3.1 7.36,12.96 6.3,14.01 RA137.2 5.86,13.82 v3(5.36,13.82) ; v3(2.33,15.88) 2.33,15.39 2.62,15.1 DA15.1 3.14,15.6 RA41.1
SPK_MUTE#_R: length 12.3
  BOTTOM w0.254: QA2.2 12.74,13.42 13.15,13.83 13.15,15.98 12.75,16.37 12.04,16.37 11.41,17.01 CA113.1 9.98,17.01 v1(9.67,16.7) 9.25,16.27 8.9,16.27 8.6,15.97 8.6,15.71 8.08,15.19 8.08,14.76 7.77,14.45 DE3.2 6.89,14.92 RA137.1
SPK_R1-_CONN: length 6.1
  TOP w0.508: JSPK.1 37.34,11.8 v2(35.49,9.95) CA32.1 33.66,9.95 LA3.2
SPK_R2+_CONN: length 5.8
  TOP w0.508: JSPK.2 37.09,13.05 v2(36.13,12.09) 35.02,12.09 34.5,12.61 CA31.1 33.35,12.61 LA4.2
SPKL+: length 33.5
  TOP w0.508: LA6.1 30.47,15.8 v3(29.67,15)
  IN4 w0.508: v3(29.67,15) 29.61,14.94 28.86,14.94 27.89,15.9 27.41,15.9 24.43,18.88 23.68,18.88 23.53,19.03 17.26,19.03 16.11,20.19 16.11,21.96 14.05,24.02 12.02,24.02 9.43,21.43 7.58,21.43 7.53,21.38 7.41,21.38 v3(5.3,19.27)
  vias: v1(5.56,18.65)
SPKL-: length 35.6
  TOP w0.508: LA5.1 30.89,13.73 v3(30.23,14.39)
  IN4 w0.508: v3(3.3,19.89) 4.69,18.51 5.83,18.51 7.99,20.66 9.84,20.66 11.85,22.67 14.32,22.67 15.34,21.64 15.34,19.87 16.95,18.27 21.79,18.27 22.41,17.66 24.58,17.66 27.11,15.13 27.59,15.13 28.54,14.18 30.02,14.18 v3(30.23,14.39)
  vias: v1(3.71,20.35)
SPKR+: length 50
  TOP w0.508: v3(32.31,11.37) 32.32,11.38 32.32,11.79 LA4.1
  IN1 w0.508: v3(1.55,21.57) 1.55,27.14 v3(1.74,27.33)
  IN4 w0.508: v3(1.55,21.57) 1.65,21.67 5.42,21.67 6.7,22.95 8.79,22.95 10.56,24.72 10.56,25.82 11.91,27.18 14.8,27.18 18.11,23.88 20.18,23.88 21.43,22.63 22.84,22.63 26.62,18.85 27.98,18.85 32.31,14.52 v3(32.31,11.37)
  BOTTOM w0.508: v3(1.55,21.57) 1.55,21.07 CA85.1
  vias: v1(1.45,26.9)
SPKR-: length 39.6
  TOP w0.508: v3(31.52,11.37) 31.52,10.68 LA3.1
  IN4 w0.508: v3(3.24,20.91) 5.73,20.91 7.01,22.19 9.11,22.19 11.32,24.4 11.32,25.35 11.88,25.91 15,25.91 18.25,22.66 20.33,22.66 21.11,21.87 22.52,21.87 27.73,16.66 29.08,16.66 31.52,14.22 v3(31.52,11.37)
  vias: v1(1.54,22.48)
SRTCRST#: length 9.9
  BOTTOM w0.089: 231.59,32.59 231.39,32.78 229.99,32.78 UH1.B9
  BOTTOM w0.127: 231.59,32.59 232.64,31.53 232.64,30.86 233.75,29.76 RH15.2 234.52,29.29 235.99,29.29 CH3.2 236.46,30.71 v1(236.21,30.96)
SSID_GPIO34: length 10.7
  TOP w0.127: v3(212.51,28.59) 212.51,28.13 v1(212.31,27.94) 212.17,27.79 211.47,27.79 211.18,27.5 211.18,27.31 RH117.1 210.58,26.58 RH161.1
  IN6 w0.089: v3(212.51,28.59) 212.51,28.96 212.98,29.43 215.97,29.43 217.35,30.81 v3(217.35,30.99)
  BOTTOM w0.089: v3(217.35,30.99) 217.33,31.01 UH1.AN6
SSID_GPIO52: length 7.5
  TOP w0.127: RH68.1 233,30.77 RH69.1 v1(233,31.89) 233,32.17 v3(233.42,32.59)
  BOTTOM w0.127: v3(233.42,32.59) 233.38,32.59 232.71,33.26 232.58,33.26 231.5,34.34 229.93,34.34 UH1.B13
STRAP0: length 15
  TOP w0.127: RV230.1 154.55,72.8 154.76,73.02 154.76,73.04 RV228.2 155.48,73.75 157.98,73.75 158.97,72.76 v2(165.01,72.76) 165.85,72.76 166.66,71.95 v3(166.8,71.95)
  BOTTOM w0.089: v3(166.8,71.95) 167.17,71.58 UV1.BA6
STRAP1: length 16.8
  TOP w0.127: v3(168.4,73.58) 168,73.98 166.63,73.98 166.11,74.5 165.08,74.5 164.01,75.57 v2(163.72,75.57) 155.96,75.57 RV216.2 155.22,76.3 153.99,76.3 RV218.1
  BOTTOM w0.1: v3(168.4,73.58) UV1.AW8
STRAP2: length 16.2
  TOP w0.127: RV217.1 154.02,74.23 154.99,74.23 RV232.2 155.46,74.69 158.24,74.69 v2(158.99,73.94) 159.76,73.17 165.76,73.17 166.51,72.43 167.13,72.43 v3(167.58,71.99)
  BOTTOM w0.089: v3(167.58,71.99) 167.2,72.36 UV1.BA7
STRAP3: length 19.2
  TOP w0.127: RV214.1 153.62,77.81 154.69,77.81 154.99,77.51 154.99,77.15 155.16,76.99 RV221.2 155.49,77.28 155.34,77.43 155.34,77.85 155.54,78.06 160.95,78.06 v2(161.03,77.98) 163.13,77.98 163.44,77.68 163.44,76.98 165.56,74.86 166.92,74.86 167.4,74.38 v3(167.6,74.38)
  BOTTOM w0.1: UV1.BA8 167.2,73.98 v3(167.6,74.38)
STRAP4: length 14
  TOP w0.127: RV219.1 154.51,71.85 RV224.2 155.48,71.85 157.36,71.85 v2(157.72,71.48) 161.11,71.48 161.32,71.27 165.33,71.27 v3(166.04,71.99)
  BOTTOM w0.1: UV1.BB6 166.04,71.94 v3(166.04,71.99)
SUS_STAT#: length 25.8
  TOP w0.089: v3(223.74,31.28) 223.67,31.22 T73.1
  TOP w0.127: v3(219.18,19.69) 218.78,19.69 RH30.2
  IN2 w0.099: v3(219.18,19.69) 219.18,20.26 219.78,20.86 222.19,20.86 223.09,19.96 224.54,19.96 225.08,20.49 226.26,20.49 229.25,23.48 229.25,24.45 228.85,24.84 228.19,24.84 225.85,27.18 225.85,28.5 223.74,30.61 v3(223.74,31.28)
  BOTTOM w0.089: UH1.U7 223.65,31.28 v3(223.74,31.28)
SUSACK#: length 80.8
  TOP w0.127: v3(286.68,18.19) 286.68,16.87 287.38,16.17 287.38,14.29 288.22,13.45 UE5.97 290.89,13.45 291.38,12.96 v1(291.38,12.18)
  IN1 w0.099: v3(229.19,20.17) 229.54,20.53 230.8,20.53 231.82,19.51 236.5,19.51 237.62,20.63 237.62,22.88 245.25,30.51 255.16,30.51 259.29,26.38 259.29,25.03 259.7,24.61 261.01,24.61 264.91,20.72 280.91,20.72 281.36,21.16 283.71,21.16 v3(286.68,18.19)
  BOTTOM w0.127: v3(229.19,20.17) 229.07,20.28 R178.1
SUSACK#_R: length 12.4
  IN2 w0.099: v3(228.2,25.92) 226.76,27.36 226.76,28.44 225.05,30.15 225.05,30.93 v3(224.71,31.27)
  BOTTOM w0.089: UH1.R6 224.45,31.01 v3(224.71,31.27)
  BOTTOM w0.127: v3(228.2,25.92) 228.81,25.92 229.05,25.68 229.05,25.2 229.31,24.93 229.31,24.3 229.75,23.87 RH34.2 229.75,22.81 R178.2
SUSCLK: length 62.3
  TOP w0.127: RM32.2 174.32,22.18 174.32,21.2 175.34,20.18 176.63,20.18 177.46,19.36 v1(177.46,17.06) 177.46,16.51 v3(177.27,16.32)
  IN6 w0.099: v3(222.74,31.3) 220.79,29.35 217.22,29.35 216.35,28.48 216.35,28.02 213.97,25.64 213.97,24.89 212.45,23.37 212.45,22.6 210.64,20.79 207.39,20.79 206.86,20.26 206.13,20.26 205.77,19.91 200.17,19.91 199.47,19.21 193.67,19.21 192.48,18.02 191.81,18.02 190.69,16.9 189.68,16.9 189.09,16.32 179.87,16.32 179.38,15.83 177.75,15.83 v3(177.27,16.32)
  BOTTOM w0.089: UH1.Y6 222.44,31.01 v3(222.74,31.3)
SUSCLK_R: length 7.2
  TOP w0.127: v3(171.21,23.46) 171.21,24.09 171.59,24.47 v1(173.38,24.47) 173.64,24.47 173.89,24.22 RM32.1
  BOTTOM w0.127: JWLAN1.42 172.6,23.78 172.47,23.92 171.67,23.92 v3(171.21,23.46)
SUSP: length 203.5
  TOP w0.127: R175.2 312.79,39.84 Q40.1 311.49,39.36 310.01,37.87 300.36,37.87 299.9,37.42 v1(299.9,34.63) 299.9,25.54 v3(299.6,25.24) ; Q41.2 145.86,23.73 145.57,23.43 145.57,22.86 145.15,22.44 145.15,16.6 v3(144.74,16.19)
  IN2 w0.099: v3(299.6,25.24) 298.97,24.61 293.7,24.61 289.49,20.4 288.51,20.4 288.23,20.68 288.23,21.01 287.96,21.27 281.71,21.27 280.94,20.5 276.28,20.5 273.51,17.73 268.13,17.73 267.86,17.46 262.14,17.46 258.23,13.55 253.2,13.55 252.6,12.95 232.69,12.95 230.32,10.59 222.16,10.59 221.17,9.6 210.03,9.6 206.36,13.27 194.49,13.27 191.99,10.77 173.2,10.77 172.38,9.95 158.24,9.95 155.41,12.78 150.67,12.78 149.01,14.44 147.47,14.44 145.71,16.19 v3(144.74,16.19)
SUSP#: length 318.2
  TOP w0.127: v3(297.84,25.17) 297.84,27.74 299.44,29.34 299.44,39.69 300.05,40.3 R176.1 308.1,40.81 Q40.2 ; UE5.116 288.93,21.05 v3(288.75,20.87) ; v3(77.03,31.65) v1(77.03,31.02)
  TOP w0.254: v3(148.27,24.35) 148.25,24.37 PR209.1
  IN2 w0.099: v3(297.84,25.17) 297.61,24.94 293.58,24.94 289.5,20.87 v3(288.75,20.87) 288.12,21.5 281.36,21.5 280.75,20.89 276.33,20.89 273.39,17.96 267.96,17.96 267.69,17.69 261.98,17.69 258.07,13.78 253.1,13.78 252.76,13.43 242.3,13.43 241.82,13.91 239.08,13.91 v3(238.91,14.07)
  IN4 w0.254: v3(77.03,31.65) 78.11,30.57 137.23,30.57 v3(139.83,27.97) ; v3(238.72,19.52) 231.85,19.52 230.85,20.53 230.05,20.53 228.73,21.85 226.28,21.85 225.87,22.25 217.17,22.25 216.54,21.62 215.52,21.62 215.2,21.93 214.51,21.93 214.31,21.74 212.03,21.74 211.65,22.13 205.75,22.13 205.57,22.3 198.41,22.3 197.16,21.05 192.52,21.05 191.8,20.32 183.54,20.32 182.96,20.89 180.6,20.89 180.03,20.32 174.59,20.32 174.32,20.58 166.73,20.58 165.83,21.49 158.98,21.49 156.3,24.17 154.05,24.17 153.63,24.59 152.33,24.59 151.58,23.84 148.78,23.84 v3(148.27,24.35)
  IN6 w0.254: v3(238.72,19.52) 238.72,18 238.33,17.6 238.33,14.66 v3(238.91,14.07) ; v3(139.83,27.97) 139.77,27.97 139.34,27.54 139.34,27.06 139.89,26.51 143.39,26.51 143.65,26.77 144.32,26.77 145.98,25.12 147.5,25.12 v3(148.27,24.35)
  BOTTOM w0.127: R174.1 R182.1 51.34,15.38 53.76,15.38 54.26,14.89 55.78,14.89 56.39,15.5 70.54,15.5 71.19,16.14 72.17,16.14 73.54,17.51 73.54,19.38 74.11,19.95 74.11,23.99 76.41,26.29 76.41,29.71 77.03,30.33 v3(77.03,31.65)
  BOTTOM w0.254: v3(238.72,19.52) 238.72,25.43 239.54,26.25 PR300.1
SW_1.35V: length 2.4
  TOP w0.127: 150.12,36.97 v2(150.12,36.18)
  IN2 w1.016: 153.04,32.79 153.04,34.38
  vias: v3(151.26,38.89) v3(151.64,38.38) v3(151.96,38.89) v3(152.28,38.38) v3(152.59,38.89) v3(152.78,35.27) v3(152.78,31.65) v3(152.72,31.02) v3(153.48,39.08) v3(153.48,38.44) v3(153.42,35.27) v3(154.12,39.08) v3(154.12,38.44) v3(154.88,39.02) v3(154.88,38.38) v3(154.88,37.75) v3(154.88,37.11) v3(154.88,36.48)
SW_+1.05VSP: length 4.9
  TOP w0.127: v2(245.85,28.06) 245.85,27.93 v3(246.26,27.52)
  IN2 w1.016: 250.76,25.05 250,25.05 247.59,27.46
  vias: v3(246.83,27.78) v3(251.65,25.11) v3(251.65,24.47)
SW_+1.35VS_VGAP: length 0.6
  TOP w0.127: v3(135.83,109.88) v2(135.23,109.88)
  vias: v3(136.46,109.88) v3(137.99,108.23) v3(138.37,110.2) v3(138.37,109.59) v3(138.62,108.23) v3(139.07,110.23) v3(139.07,109.59) v3(139.26,108.23) v3(139.89,108.23) v3(140.53,108.23) v3(141.16,108.23) v3(142.06,112.66) v3(142.06,111.97) v3(142.06,111.27) v3(142.7,112.66) v3(142.7,111.97) v3(142.7,111.27)
SYS_PEX_RST_MON#: length 70.4
  TOP w0.127: v3(162.27,51.18) 161.88,51.18 161.18,51.88 161.18,52.4 161.33,52.55 QV13.2 QV13.5 ; v3(150.4,71.73) 150.08,71.41 v1(150.08,71.12) ; v3(150.51,61.11) 150.51,60.56 150.28,60.33 QV91.5 QV91.2 150.28,57.33 149.3,56.35 v3(149.3,56.2)
  IN1 w0.099: v3(150.4,71.73) 151.01,71.12 151.01,64.02 150.51,63.53 v3(150.51,61.11)
  IN6 w0.089: v3(161.22,73.56) 162.5,72.28 162.5,70.97 163.5,69.97 167.72,69.97 167.97,69.71 167.97,69.21 v3(168.37,68.81)
  IN6 w0.099: v3(162.27,51.18) 159.22,51.18 155.54,54.87 v3(155.2,54.87) 154.09,53.76 150.79,53.76 149.3,55.25 v3(149.3,56.2)
  BOTTOM w0.089: v3(161.22,73.56) 160.39,73.56 160.21,73.74 159.33,73.74
  BOTTOM w0.127: UV1.AW2 v3(168.37,68.81) ; DV8.2 155.08,56.63 RV208.1 155.27,54.94 v3(155.2,54.87) ; 159.33,73.74 RV187.1 156.9,73.74 156.61,73.45 UV14.4 156.61,72.64 155.64,71.67 153.67,71.67 RV64.1 152.97,72.37 151.03,72.37 v3(150.4,71.73) ; v3(162.27,51.18) 162.13,51.04 160.58,51.04 160.4,51.22 QV89.5 QV89.2
SYS_PWROK: length 427.5
  TOP w0.127: v3(77.57,65.41) 80.32,65.41 RC57.1 ; v3(76.42,32.26) v1(76.42,32.9) ; v3(210.87,22.79) 211.2,22.47 211.75,22.47 212.09,22.13 212.09,22.02 UH2.4 213.38,21.7 213.96,22.28 213.96,23.07 213.82,23.2 RH47.1 ; v3(132.17,90.88) 132.17,94.63 RC53.1 ; CE46.1 284.42,10.63 284.4,10.65 UE5.86 284.4,13.07 284.58,13.26 284.58,13.73 v3(284.08,14.24)
  IN1 w0.099: v3(284.08,14.24) 282.48,12.64 276.06,12.64 274.47,14.23 268.57,14.23 267.78,15.01 261.72,15.01 259.69,12.98 253.44,12.98 252.76,12.3 221.4,12.3 220.46,11.36 217.91,11.36 216.8,12.46 208.89,12.46 208.03,13.32 208.03,17.27 210.66,19.9 210.66,22.58 v3(210.87,22.79)
  IN2 w0.099: v3(132.17,90.88) 132.17,89.6 133.54,88.23 133.54,83.34 135.18,81.7 135.18,67.46 136.34,66.31 v3(136.34,63.46)
  IN6 w0.099: v3(210.87,22.79) 210.28,23.38 202.58,23.38 202.58,23.39 201.84,23.39 201.11,22.66 197.66,22.66 196.7,23.61 193.91,23.61 192.56,22.26 192.56,21.65 191.36,20.45 190.8,20.45 190.48,20.14 183.13,20.14 182.49,19.49 175.91,19.49 175.55,19.85 170.48,19.85 169.15,18.52 167.31,18.52 166.75,17.95 157.21,17.95 154.93,20.23 147.95,20.23 147.48,19.76 141.61,19.76 140.43,18.58 83.81,18.58 83,19.39 83,23.6 79.77,26.83 77.57,26.83 75.48,28.92 v3(74.98,28.92) ; v3(77.57,65.41) 79.03,63.95 79.03,44.64 76.99,42.6 76.99,37.07 75.32,35.39 75.32,33.36 v3(76.42,32.26) 77,32.26 78.18,31.08 85.41,31.08 85.98,30.51 122.18,30.51 122.89,31.22 140.67,31.22 141.73,32.29 141.73,45.68 139.13,48.29 139.13,60.67 v3(136.34,63.46)
  BOTTOM w0.127: v3(76.42,32.26) 76.42,30.36 v3(74.98,28.92)
SYS_PWROK_R: length 14.3
  TOP w0.127: v3(220.29,31.22) 219.85,31.66 219.85,32.59 219.53,32.91 219.08,32.91 218.63,32.46 218.09,32.46 217.73,32.11 217.73,30.74 v2(217.14,30.14) 215.74,28.74 215.74,27.88 215.53,27.68 215.53,25.8 214.61,24.87 214.26,24.87 RH47.2
  BOTTOM w0.089: v3(220.29,31.22) 220.38,31.22 UH1.AD7
SYS_RESET#: length 6.5
  TOP w0.127: v3(214.39,25.3) 214.74,25.65 214.76,25.65 v1(214.76,25.65) 214.9,25.78 RH32.2
  BOTTOM w0.089: UH1.AM1 217.41,28.44 216.73,27.76 216.73,27.69 216.69,27.65
  BOTTOM w0.127: 216.69,27.65 214.39,25.35 v3(214.39,25.3)
SYSON: length 287.5
  TOP w0.127: UE5.95 288,10.97 v3(287.43,10.41) 287.28,10.25 CE42.1
  TOP w0.254: PR208.1 150.71,24.77 150.71,24.16 150.27,23.71 147.89,23.71 v3(147,24.6)
  IN2 w0.099: v3(242.13,11.46) 242.68,12.01 252.65,12.01 253.51,12.87 259.74,12.87 262.26,15.4 270.37,15.4 270.87,15.9 280.06,15.9 281.03,14.92 284.34,14.92 285.09,14.18 285.09,12.75 v3(287.43,10.41)
  IN2 w0.254: v3(242.13,11.46) 241.68,11.01 240.1,11.01 238.91,9.83 222.51,9.83 221.41,8.74 209.82,8.74 206.1,12.46 196.16,12.46 193.39,9.68 173.61,9.68 172.81,8.88 170.4,8.88 169.09,7.57 159.05,7.57 156.7,9.93 152.16,9.93 150.11,11.97 v3(148.68,11.97)
  IN3 w0.254: v3(134.77,104.82) 135.41,104.82 135.74,104.48 135.74,100 136.54,99.2 136.54,95.18 134.06,92.7 134.06,86.03 135.17,84.93 135.17,67.59 137.09,65.67 137.09,63.24 v3(136.35,62.5)
  IN4 w0.254: v3(136.35,62.5) 136.35,45.06 141.67,39.74 141.67,32.26 142.57,31.36 142.57,29 143.19,28.39 144.08,28.39 147,25.47 v3(147,24.6)
  BOTTOM w0.254: v3(134.77,104.82) 134.51,104.55 v1(132.46,104.55) 131.32,104.55 129.8,106.07 129.52,106.07 128.31,107.28 128.31,107.9 128.82,108.41 129.16,108.41 PR315.1 ; v3(242.13,11.46) 242.13,12.14 242.46,12.47 242.46,13.92 239.21,17.17 239.21,24.69 PR304.1 ; v3(148.68,11.97) 147.04,11.97 146.75,12.26 146.75,16.35 147.97,17.57 147.97,20.94 148.13,21.11 148.13,23.47 v3(147,24.6)
TB_STAT#_CHG: length 13
  TOP w0.127: v3(46.8,42.84) 46.8,43.74 v1(47,43.94)
  TOP w0.203: PU700.16 45.34,36.59 45.91,36.02
  TOP w0.254: 45.91,36.02 46.01,36.02 PR718.1 46.15,35.52 v3(45.7,35.52) ; PQ705.2 46.43,42.46 v3(46.8,42.84)
  IN1 w0.254: v3(45.7,35.52) 45.09,36.13 45.09,39.18 45.67,39.77 45.67,41.71 v3(46.8,42.84)
TMDS_L_TX0N: length 12.4
  BOTTOM w0.089: 123.4,140.3 123.14,140.04 123.14,139.96 123.18,139.93 123.22,139.88 123.4,139.8 123.62,139.8 123.9,139.93 124.15,139.93 124.42,139.8 124.59,139.8 124.86,139.93 125.12,139.93 125.42,139.8 125.56,139.8 125.91,139.93 126.18,139.93 126.44,139.79 126.59,139.79 126.81,139.92 126.82,139.92 126.83,139.92 127.15,139.92 127.43,139.79 127.6,139.79 127.87,139.92 128.14,139.92 128.43,139.79 128.63,139.68 128.79,139.68 128.99,139.48 128.98,139.47 128.98,139.01 129.02,138.97
  BOTTOM w0.127: RV22.2 126.77,135.07 LV4.2 127.53,135.84 127.53,136.23 127.97,136.67 127.97,137.37 129.02,138.42 129.02,138.97 ; 123.4,140.3 123.47,140.38 JHDMI1.9
TMDS_L_TX0P: length 12.2
  BOTTOM w0.089: 122.67,140.3 122.96,140.01 122.96,139.88 123.05,139.8 123.12,139.74 123.36,139.62 123.66,139.62 123.94,139.75 124.1,139.75 124.37,139.62 124.64,139.62 124.91,139.75 125.08,139.75 125.37,139.62 125.59,139.62 125.95,139.75 126.12,139.75 126.31,139.65 126.39,139.61 126.65,139.61 126.87,139.74 127.11,139.74 127.39,139.61 127.65,139.61 127.92,139.74 128.09,139.74 128.39,139.61 128.6,139.49 128.71,139.49 128.8,139.4 128.8,138.98 128.79,138.97
  BOTTOM w0.127: RV24.2 126.2,135.63 LV4.3 126.97,136.4 127.36,136.4 127.73,136.77 127.73,137.47 128.78,138.52 128.78,138.96 128.79,138.97 ; 122.67,140.3 122.59,140.38 JHDMI1.7
TMDS_L_TX1N: length 4.7
  BOTTOM w0.127: JHDMI1.6 121.6,138.78 121.6,136.77 121.23,136.4 121.23,136 LV5.2 120.46,135.24 RV26.2
TMDS_L_TX1P: length 4.5
  BOTTOM w0.127: JHDMI1.4 121.36,138.82 121.36,136.87 121.06,136.57 120.66,136.57 LV5.3 119.9,135.8 RV28.2
TMDS_L_TX2N: length 6.5
  BOTTOM w0.127: RV30.2 117.32,135.41 LV6.2 119.21,137.3 119.21,139.24 119.76,139.79 119.91,139.79 JHDMI1.3
TMDS_L_TX2P: length 6.4
  BOTTOM w0.127: RV29.2 116.76,135.98 LV6.3 117.46,136.68 117.58,136.68 117.85,136.41 117.98,136.41 118.97,137.4 118.97,139.34 119.57,139.95 119.57,140.3 JHDMI1.1
TMDS_L_TXCN: length 5
  BOTTOM w0.127: JHDMI1.12 124.65,138.83 124.65,136.61 124.3,136.26 124.21,136.17 124.21,135.77 LV3.2 123.45,135.01 RV19.2
TMDS_L_TXCP: length 4.8
  BOTTOM w0.127: RV21.2 122.88,135.57 123.65,136.34 124.04,136.34 124.13,136.43 124.41,136.71 124.41,138.77 JHDMI1.10
TMDS_TX0N: length 20.5
  TOP w0.127: v3(109.37,135.41) 109.54,135.58 109.54,136.24 109.47,136.3 UV4.24
  BOTTOM w0.127: RV22.1 125.97,134.27 LV4.1 124.22,132.53 120.43,132.53 119.99,132.97 114.97,132.97 114.96,132.96 114.45,132.96 114.44,132.97 111.09,132.97 109.48,134.58 109.48,135.3 v3(109.37,135.41)
TMDS_TX0N_C: length 2.1
  TOP w0.127: UV4.7 109.47,142.44 109.53,142.5 109.53,142.74 109.64,142.85 109.64,143.51 CV43.1
TMDS_TX0P: length 20.4
  TOP w0.127: v3(109.95,135.41) 109.78,135.58 109.78,136.21 109.87,136.3 UV4.25
  BOTTOM w0.127: RV24.1 125.4,134.84 LV4.4 124.63,134.07 124.63,133.93 124.87,133.69 124.87,133.52 124.12,132.77 120.54,132.77 120.09,133.21 v4(114.71,133.21) 111.19,133.21 109.72,134.68 109.72,135.18 v3(109.95,135.41)
TMDS_TX0P_C: length 2.2
  TOP w0.127: UV4.6 109.87,142.44 109.78,142.54 109.78,142.64 109.88,142.75 109.88,143.42 CV42.1
TMDS_TX1N: length 11.6
  TOP w0.127: v3(117.66,133.97) 113.31,133.97 112.56,134.72 111.3,134.72 110.27,135.74 UV4.26
  BOTTOM w0.127: v3(117.66,133.97) 117.82,133.81 119.04,133.81 LV5.1 119.66,134.44 RV26.1
TMDS_TX1N_C: length 3.4
  TOP w0.127: CV41.1 111.47,144.31 111.47,144.01 110.37,142.9 110.37,142.54 110.27,142.44 UV4.5
TMDS_TX1P: length 11.6
  TOP w0.127: UV4.27 110.67,136.25 110.52,136.09 110.52,135.84 111.4,134.96 112.66,134.96 113.41,134.22 117.27,134.22 117.36,134.3 117.36,134.41 117.5,134.56 v3(117.66,134.56)
  BOTTOM w0.127: v3(117.66,134.56) 117.92,134.56 118.04,134.44 118.04,134.2 118.19,134.05 118.64,134.05 118.72,134.14 118.72,134.63 LV5.4 119.1,135 RV28.1
TMDS_TX1P_C: length 3.4
  TOP w0.127: UV4.4 110.67,142.44 110.61,142.51 110.61,142.8 111.71,143.91 111.71,144.28 CV39.1
TMDS_TX2N: length 7.7
  TOP w0.127: UV4.29 111.47,136.15 111.52,136.1 111.52,135.76 111.79,135.5 113.36,135.5 113.58,135.28 v3(113.58,135)
  BOTTOM w0.127: RV30.1 116.52,134.61 LV6.1 115.98,134.06 115.85,134.06 115.64,133.85 114.35,133.85 113.69,134.5 113.69,134.89 v3(113.58,135)
TMDS_TX2N_C: length 3.7
  TOP w0.127: UV4.2 111.47,142.44 111.54,142.51 111.54,142.75 112.05,143.26 112.3,143.26 112.32,143.28 112.8,143.28 112.83,143.26 113.22,143.26 113.35,143.39 113.35,143.55 CV38.1
TMDS_TX2P: length 7.6
  TOP w0.127: UV4.30 111.87,136.15 111.76,136.04 111.76,135.86 111.89,135.74 113.46,135.74 114.17,135.04 v3(114.17,135)
  BOTTOM w0.127: RV29.1 115.96,135.18 LV6.4 115.34,134.56 115.34,134.48 115.58,134.24 115.58,134.15 115.52,134.09 114.45,134.09 113.94,134.6 113.94,134.77 v3(114.17,135)
TMDS_TX2P_C: length 3.7
  TOP w0.127: CV37.1 113.59,143.55 113.59,143.29 113.32,143.02 v4(112.56,143.02) 112.15,143.02 111.79,142.65 111.79,142.53 111.87,142.44 UV4.1
TMDS_TXCN: length 17.4
  TOP w0.127: UV4.21 108.27,135.03 109.47,133.83 112.32,133.83 112.94,133.21 120.96,133.21 120.99,133.25 121.47,133.25 v3(121.51,133.29)
  BOTTOM w0.127: RV19.1 122.65,134.21 LV3.1 122.1,133.66 121.89,133.66 121.51,133.29 v3(121.51,133.29)
TMDS_TXCN_C: length 2.3
  TOP w0.127: UV4.10 108.27,142.44 108.33,142.5 108.33,142.63 107.86,143.11 107.86,143.49 CV45.1
TMDS_TXCP: length 17.4
  TOP w0.127: v3(121.06,133.9) 121.06,133.66 120.86,133.46 113.04,133.46 112.42,134.08 109.57,134.08 108.52,135.13 108.52,135.99 108.67,136.15 UV4.22
  BOTTOM w0.127: v3(121.06,133.9) 121.24,133.72 121.6,133.72 121.69,133.81 121.69,133.94 121.53,134.1 121.53,134.22 122.08,134.77 RV21.1
TMDS_TXCP_C: length 2.4
  TOP w0.127: UV4.9 108.67,142.44 108.58,142.54 108.58,142.73 108.1,143.21 108.1,143.45 CV44.1
TON_1.35V: length 1.8
  TOP w0.203: PU200.9 151.29,26.88 v3(151.62,26.55) 151.81,26.37 PR206.2
TP_CLK: length 219.5
  TOP w0.127: UE5.87 284.8,12.62 284.9,12.73 284.9,12.96 285.04,13.1 285.04,14.37 284.38,15.04 284.38,19.45 282.05,21.78 281.61,21.78 280.19,23.2 280.19,24.53 v3(280.01,24.7) ; v3(185.97,133.05) 186.18,133.26 186.18,136.14 185.61,136.71 185.61,143.6 185.05,144.16 185.05,144.88 183.28,146.66 183.28,147.05 183.15,147.18 JPWR1.21
  IN1 w0.099: v3(280.01,24.7) 280.18,24.54 280.18,24.36 280.1,24.28 279.17,24.28 278.94,24.52 264.72,24.52 256.24,32.99 242.94,32.99 241.96,32.02 237.54,32.02 236.8,32.76 236.8,37.43 233.49,40.75 233.49,44.03 233.71,44.25 233.71,45.79 232.88,46.61 232.88,50.6 233.67,51.38 233.67,53.79 233.09,54.37 233.09,59.63 233.58,60.12 233.58,65.16 234.29,65.87 234.29,69.6 234.92,70.23 234.92,97.17 232.62,99.48 232.62,100.09 230.79,101.92 229.9,101.92 224.89,106.92 223.34,106.92 222.23,108.04 222.23,111.61 221.69,112.14 220.8,112.14 220.58,112.37 220.58,112.86 220.63,112.91 v3(220.76,113.04)
  IN6 w0.099: v3(220.76,113.04) 220.59,113.22 220.59,118.56 218.97,120.18 215.97,120.18 214.78,121.36 212.78,121.36 211.71,122.43 209.32,122.43 203.02,128.73 200.87,128.73 196.07,133.53 194.52,133.53 194.36,133.37 190.01,133.37 189.15,134.24 186.59,134.24 186.16,133.81 186.16,133.24 v3(185.97,133.05)
  BOTTOM w0.127: RE100.2 185.97,132.59 v3(185.97,133.05)
TP_DATA: length 219.4
  TOP w0.127: UE5.88 285.2,12.66 285.16,12.7 285.16,12.85 285.29,12.99 285.29,14.48 284.63,15.14 284.63,19.56 282.16,22.04 281.72,22.04 280.44,23.31 280.44,24.55 v3(280.6,24.7) ; JPWR1.22 183.65,147.18 183.53,147.06 183.53,146.76 185.31,144.99 185.31,144.26 185.87,143.7 185.87,136.82 186.44,136.25 186.44,133.19 v3(186.58,133.05)
  IN1 w0.099: v3(220.18,113.04) 220.35,112.88 220.35,112.28 220.71,111.92 221.6,111.92 222,111.52 222,107.95 223.25,106.7 224.8,106.7 229.81,101.69 230.7,101.69 232.39,100 232.39,99.39 234.7,97.08 234.7,70.32 234.07,69.69 234.07,65.97 233.35,65.25 233.35,60.21 232.86,59.72 232.86,54.28 233.44,53.7 233.44,51.48 232.66,50.69 232.66,46.52 233.48,45.69 233.48,44.34 233.27,44.13 233.27,40.65 236.58,37.34 236.58,32.66 237.45,31.79 242.06,31.79 243.03,32.77 256.15,32.77 264.62,24.29 278.85,24.29 279.08,24.06 280.19,24.06 280.41,24.27 280.41,24.44 280.41,24.51 v3(280.6,24.7)
  IN6 w0.099: v3(220.18,113.04) 220.36,113.22 220.36,118.47 218.87,119.95 215.88,119.95 214.69,121.14 212.68,121.14 211.62,122.2 209.23,122.2 202.93,128.5 200.78,128.5 195.98,133.3 194.61,133.3 194.45,133.15 189.92,133.15 189.05,134.01 186.68,134.01 186.39,133.72 186.39,133.24 v3(186.58,133.05)
  BOTTOM w0.127: RE101.2 186.58,132.54 v3(186.58,133.05)
TP_EN: length 201.4
  TOP w0.127: UE6.14 240.7,48.99 240.2,49.49 v3(240.2,50.05)
  IN2 w0.099: v3(193.36,136.25) 192.9,135.79 187.75,135.79 184.68,132.72 180.18,132.72 179.85,132.39 179.85,132.06 179.1,131.31 175.34,131.31 174.85,131.79 170.45,131.79 169.53,132.7 161.75,132.7 160.43,131.38 159.84,131.38 159.59,131.13 159.59,128.5 159.25,128.16 159.25,124.85 160.05,124.05 160.05,110.49 160.35,110.19 160.35,95.13 161.58,93.9 161.58,83.97 160.82,83.21 160.82,80.99 161.41,80.39 162.52,80.39 163.41,79.51 163.41,74.54 162.66,73.8 162.66,71.03 162.14,70.51 162.14,66.9 162.69,66.34 174.91,66.34 176.17,65.09 178.33,65.09 179.12,64.29 180.56,64.29 183.75,61.1 197.36,61.1 202.55,55.91 205.41,55.91 209.13,59.62 227.27,59.62 229.18,57.71 231.07,57.71 236.29,52.49 237.28,52.49 239.33,50.45 239.8,50.45 v3(240.2,50.05)
  BOTTOM w0.127: UT1.4 196.39,134.36 195.65,134.36 194.76,135.24 193.83,135.24 193.36,135.71 v3(193.36,136.25) 193.36,136.48 v1(193.04,136.79)
TP_LED_B#: length 17.8
  TOP w0.127: JPWR1.10 177.65,146.02 178.7,144.97 178.7,143.73 179.08,143.34 179.08,139.64 179.96,138.77 179.96,135.64 179.19,134.86 v3(179.19,133.66) 179.19,133.58 v1(179.96,132.81)
  BOTTOM w0.127: UE8.5 179.18,133.66 v3(179.19,133.66)
TP_LED_EN: length 142.9
  TOP w0.127: v3(268.23,38.84) 269.23,37.84 274.04,37.84 v1(275.79,36.09) 278.3,33.58 278.3,28.78 278.8,28.28 UE5.25
  IN2 w0.099: v3(216.46,121.9) 217.49,120.87 220.79,120.87 222.12,119.54 222.12,107.44 228.77,100.79 229.71,100.79 234.38,96.11 234.38,72.04 233.89,71.55 233.89,67.41 233.43,66.94 233.43,65.83 232.35,64.75 232.35,59.88 237.14,55.1 241.19,55.1 248.27,48.01 248.27,39.98 249.32,38.94 251.64,38.94 252.82,37.76 262.46,37.76 263.02,38.32 267.71,38.32 v3(268.23,38.84)
  BOTTOM w0.127: v3(216.46,121.9) 216.22,121.66 Q2410.2
TP_LED_G#: length 18.8
  TOP w0.127: JPWR1.9 177.15,146.16 178.44,144.86 178.44,143.48 178.11,143.14 178.11,139.87 178.86,139.12 178.86,135 178.73,134.88 v3(178.73,133.24) 178.28,132.79 v1(178.13,132.79)
  BOTTOM w0.127: UE8.4 179.68,133.56 179.36,133.24 v3(178.73,133.24)
TP_LED_R#: length 22.2
  TOP w0.127: JPWR1.8 176.65,147.24 176.87,147.02 176.87,146.07 178.19,144.76 178.19,143.59 177.85,143.25 177.85,139.76 178.6,139.01 178.6,135.7 176.92,134.02 v3(176.92,133.25) 176.49,132.82 v1(176.27,132.82)
  BOTTOM w0.127: v3(176.92,133.25) 177.36,132.82 179.44,132.82 179.94,133.32 179.94,133.93 180.18,134.17 UE8.3
TPM_PIRQ#: length 21.9
  BOTTOM w0.127: UT2.20 243.48,35.5 243.64,35.66 244.05,35.66 244.42,35.29 244.42,32.58 243.7,31.87 240.55,31.87 v1(239.93,32.49) 239.38,32.49 238.8,31.9 237.63,31.9 RH154.2 236.82,32.72 235.19,32.72 234.86,33.05 234.1,33.05 233.87,33.28 233.44,33.28 232.95,33.77 232.79,33.77 231.71,34.85 230.7,34.85 230.51,35.03 230.25,35.03 229.94,34.73 UH1.C14
TRIP_+1.05VSP: length 3.8
  BOTTOM w0.254: PU300.2 241.74,27.01 241.54,26.81 v3(241.54,25.57) 241.54,25.13 PR303.2
TRIP_+1.35VS_VGAP: length 4.3
  BOTTOM w0.127: v1(130.76,106.22) 130.34,106.64 PR312.2
  BOTTOM w0.254: PR312.2 130.93,107.8 130.93,108.88 131.41,109.37 PU301.2
TS_EN: length 342.7
  TOP w0.127: v3(98.36,122.53) 96.93,122.53 94.76,124.7 94.76,125.81 94.07,126.5 JEDP1.27 ; v3(279.59,13.63) 279.3,13.34 279.3,12.74 279.2,12.64 UE5.73
  IN2 w0.099: v3(91.32,125.56) 89.63,125.56 84.76,120.7 84.76,103.24 86.88,101.12 91.41,101.12 91.94,101.65 110.67,101.65 114.62,105.59 129.71,105.59 132.95,102.36 132.95,89.84 134.22,88.57 134.22,88.56 134.31,88.47 134.31,83.83 135.98,82.16 135.98,67.84 138.81,65 138.81,57.94 143.44,53.32 148.01,53.32 156.91,44.42 156.91,41.65 158.31,40.25 158.31,39.62 161.28,36.66 161.28,34.91 168.83,27.35 168.83,25.79 170.37,24.25 172.17,24.25 174.55,21.88 179.65,21.88 180.26,22.48 189.86,22.48 201.19,33.8 201.19,44.59 202.36,45.76 204.26,45.76 209.97,51.48 219.79,51.48 220.66,52.35 224.95,52.35 226.36,50.94 230.82,50.94 v3(232.24,49.52)
  IN2 w0.122: v3(98.36,122.53) 93.98,122.53 91.76,124.75 91.76,125.12 v3(91.32,125.56)
  IN6 w0.099: v3(279.59,13.63) 279.59,14.67 278.04,16.23 277.63,16.23 273.51,20.34 272.32,20.34 266.65,26.01 263.38,26.01 260.36,29.04 259.89,29.04 257.41,31.52 257.41,34.52 249.48,42.45 249.48,43.19 243.63,49.04 242.55,49.04 240.6,50.99 238.73,50.99 238.37,51.35 234.06,51.35 v3(232.24,49.52)
  BOTTOM w0.127: v3(279.59,13.63) v1(279.59,12.78) ; v3(91.32,125.56) 91.09,125.56 UV2.4
U2_BOOT1:
  vias: v1(177.57,28.35)
U2_BOOT2: length 3
  TOP w0.127: PR617.1 184.82,29.79 185.54,30.51 185.54,31.87 v1(185.99,32.32)
U2_BOOT3: length 2.6
  TOP w0.254: PU601.4 187.97,28.68 v1(187.84,28.54) 187.84,27.84 PR633.1
U2_LGATE1: length 16.3
  TOP w0.127: 180.1,30.29 179.55,30.83 v1(179.55,32.37)
  IN2 w1.016: 177.45,43.06 176.79,42.39 176.79,39.36 177,39.14 ; 180.15,30.56 179.28,30.56 175.73,34.1 175.73,37.59 175.96,37.82
  vias: v3(176.82,38.15) v3(177.41,38.15) v3(177.74,43.89) v3(178.37,43.87) v3(179.97,29.03) v3(180,29.67)
U2_LGATE2: length 14.3
  IN2 w1.016: 180.94,38.53 181.85,38.53 182.67,37.72 182.67,30.79 181.93,30.05 ; 179.72,39.02 179.91,39.21 179.91,42.71 179.54,43.08
  vias: v1(179.76,38.18) v3(179.06,43.92) v3(179.75,43.97) v3(180.28,38.25) v3(180.91,38.25) v3(181.65,28.96) v3(182.23,29.16)
U2_LGATE3: length 7.6
  TOP w0.127: v1(192.35,28.86) 192.35,29.48 192.01,29.81 v3(192.01,29.82)
  IN2 w1.016: 193.54,37.3 193.54,33.15 192.5,32.11 192.5,31.27
  vias: v3(192.01,30.43) v3(192.6,30.43) v3(192.84,38.19) v3(193.45,38.19) v3(193.84,43.61) v3(193.84,43)
U2_PHASE1: length 24.3
  TOP w0.254: PR648.1 v3(186.15,25.36)
  IN1 w0.254: v3(186.15,25.36) 183.7,25.36 181.34,27.71 180.51,27.71 v3(179.24,28.98)
  IN2 w1.016: 177.71,29.16 174.33,32.54 174.33,43
  vias: v2(173.67,46.31) v3(172.13,48.41) v3(172.15,47.47) v3(172.3,46.33) v3(172.3,45.7) v3(172.3,45.06) v3(172.32,44.48) v3(172.58,48.9) v3(172.58,47.93) v3(172.56,46.97) v3(172.94,49.38) v3(172.94,48.41) v3(172.91,47.45) v3(172.94,46.33) v3(172.94,45.7) v3(172.94,45.06) v3(172.94,44.48) v3(173.34,48.9) v3(173.34,47.93) v3(173.32,46.97) v3(173.67,47.45) v3(173.7,49.38) v3(173.7,48.41) v3(173.95,43.84) v3(174.08,48.9) v3(174.04,47.92) v3(174.06,46.97) v3(174.41,49.38) v3(174.41,48.41) v3(174.39,47.45) v3(174.77,48.9) v3(174.74,47.93) v3(174.74,46.97) v3(174.72,43.84) v3(175.07,47.45) v3(175.1,49.38) v3(175.1,48.41) v3(175.48,46.97) v3(175.43,43.84) v3(175.5,48.9) v3(175.5,47.93) v3(175.86,49.38) v3(175.86,48.41) v3(175.83,47.45) v3(176.02,43.86) v3(176.27,48.9) v3(176.27,47.93) v3(176.24,46.97) v3(176.62,49.38) v3(176.62,48.41) v3(176.6,47.45) v3(176.63,43.84) v3(177.03,48.9) v3(177.03,47.93) v3(177,46.97) v3(177.38,49.38) v3(177.38,48.41) v3(177.36,47.45) v3(178.6,28.98)
U2_PHASE2: length 22.1
  TOP w0.254: v3(186.57,25.81) 186.64,25.73 186.64,24.96 186.15,24.47 PR646.1
  IN1 w0.254: v3(186.57,25.81) 186.63,25.81 186.6,25.84 183.76,25.84 182.59,27 v3(182.59,28.3)
  IN2 w1.016: 183.83,29.11 184.19,29.47 184.19,39.17 183.3,40.06 183.3,42.57
  vias: v2(179.52,48.38) v3(179.97,48.95) v3(179.97,47.98) v3(179.95,47.02) v3(180.33,49.43) v3(180.33,48.47) v3(180.3,47.5) v3(180.74,48.95) v3(180.74,47.98) v3(180.71,47.02) v3(180.96,43.84) v3(181.07,47.5) v3(181.09,49.43) v3(181.09,48.47) v3(181.47,48.95) v3(181.42,47.97) v3(181.45,47.02) v3(181.78,47.5) v3(181.73,43.84) v3(181.8,49.43) v3(181.8,48.47) v3(182.16,48.95) v3(182.13,47.98) v3(182.13,47.02) v3(182.46,47.5) v3(182.49,49.43) v3(182.49,48.47) v3(182.49,43.84) v3(182.87,47.02) v3(182.89,48.95) v3(182.89,47.98) v3(183.12,43.84) v3(183.17,28.55) v3(183.25,49.43) v3(183.25,48.47) v3(183.22,47.5) v3(183.66,48.95) v3(183.66,47.98) v3(183.63,47.02) v3(184.01,49.43) v3(184.01,48.47) v3(183.99,47.5) v3(184.42,48.95) v3(184.42,47.98) v3(184.39,47.02) v3(184.49,46.41) v3(184.49,45.77) v3(184.49,45.14) v3(184.49,44.5) v3(184.77,49.43) v3(184.77,48.47) v3(184.75,47.5) v3(185.16,48.95) v3(185.16,47.98) v3(185.13,46.99) v3(185.13,46.41) v3(185.13,45.77) v3(185.13,45.14) v3(185.13,44.5)
U2_PHASE3: length 20.8
  TOP w0.254: PR638.1 185.91,23.59 187.05,24.73 187.05,26.1 v3(187.33,26.38)
  IN4 w0.254: v3(187.33,26.38) 186.95,26.76 186.95,29.62 187.2,29.87 v3(187.52,29.87)
  IN4 w1.016: 189.68,42.89 189.7,42.86 189.7,33.07 187.9,31.27 187.9,30.7
  vias: v2(188.66,46.13) v3(187.57,49) v3(187.57,48.03) v3(187.54,47.07) v3(187.92,49.48) v3(187.92,48.52) v3(187.9,47.55) v3(187.9,43.72) v3(188.1,29.87) v3(188.33,49) v3(188.33,48.03) v3(188.3,47.07) v3(188.66,47.55) v3(188.66,43.72) v3(188.69,49.48) v3(188.69,48.52) v3(189.07,49) v3(189.07,48.03) v3(189.04,47.07) v3(189.4,49.48) v3(189.4,48.52) v3(189.4,47.55) v3(189.42,43.72) v3(189.75,49) v3(189.75,48.03) v3(189.73,47.07) v3(190.08,49.48) v3(190.08,48.52) v3(190.06,43.72) v3(190.11,47.54) v3(190.46,47.07) v3(190.49,49) v3(190.49,48.03) v3(190.84,49.48) v3(190.84,48.52) v3(190.82,47.55) v3(190.82,43.72) v3(191.25,49) v3(191.25,48.03) v3(191.2,47.08) v3(191.58,47.55) v3(191.61,49.48) v3(191.61,48.52) v3(191.63,43.72) v3(191.81,46.89) v3(191.81,46.26) v3(191.81,45.62) v3(191.81,44.99) v3(191.81,44.35) v3(192.01,49) v3(192.01,48.03) v3(192.37,48.52) v3(192.34,47.55) v3(192.42,46.83) v3(192.39,46.23) v3(192.39,45.62) v3(192.39,44.99) v3(192.39,44.35) v3(192.39,43.72)
U2_PWM3: length 13
  TOP w0.127: v3(189.75,27.71) 189.45,27.41 v1(189.45,27.28)
  TOP w0.254: v3(180.61,29.14) 180.5,29.03 PU600.22 ; PR642.1 v3(189.75,27.71)
  IN1 w0.254: v3(189.75,27.71) 187.78,27.71 185.68,29.81 180.85,29.81 180.61,29.57 v3(180.61,29.14)
U2_UGATE1: length 12.3
  TOP w0.127: v1(171.27,44.64) 171.27,43.33 PQ605.1
  IN4 w1.016: 176.66,27.97 176.66,30.56 173.99,33.23 173.99,36.62 173.2,37.4
  vias: v3(171.82,38.28) v3(172.07,43.7) v3(172.07,43.12) v3(172.43,38.25) v3(177.38,27.37) v3(177.87,27.01)
U2_UGATE2: length 11.7
  TOP w0.127: v3(186.17,39.09) 186.17,38.57 v1(186.39,38.36)
  IN4 w1.016: 185.31,38.67 184.1,37.47 184.1,28.3
  vias: v3(183.63,26.85) v3(183.94,27.46) v3(186.17,42.78) v3(186.17,39.68) v3(186.2,42.19)
U2_UGATE3: length 12.8
  IN2 w1.016: 188.86,28.91 189.07,29.11 189.07,37.28 188.71,37.63 ; 187.54,39.07 187.06,39.55 187.06,42.67
  vias: v1(186.44,43.36) v3(186.58,43.87) v3(187.16,38.15) v3(187.19,43.87) v3(187.52,29.21) v3(187.75,38.15) v3(188.1,29.21)
UG_3V: length 13.6
  TOP w0.127: v3(24.83,26.63) 25.3,26.63 v1(26,25.94)
  IN1 w1.016: 36.83,23.46 35.94,23.46 34.33,25.07 26.65,25.07 25.72,26
  vias: v3(24.7,27.27) v3(37.66,23.78) v3(37.66,23.17)
UG_5V: length 9.6
  IN6 w1.016: 25.91,31.59 34.48,31.59
  BOTTOM w0.127: v1(23.74,30.58) 23.98,30.81 v3(24.7,30.81)
  vias: v3(25.06,31.29) v3(34.95,30.51) v3(35.56,30.51)
UG_+1.05VSP: length 1
  TOP w0.127: v2(245.81,25.72) 246.34,26.25 v3(246.57,26.25)
  vias: v3(246.26,26.76) v3(248.41,24.98) v3(248.41,24.35)
UG_+1.35VS_VGAP: length 10.2
  TOP w0.127: v3(135.77,108.55) 135.77,108.5 v2(135.28,108.02)
  IN2 w1.016: 144.02,108.93 144.02,108.36 142.72,107.06 136.49,107.06 135.89,107.66
  vias: v3(135.77,109.18) v3(143.7,109.76) v3(144.34,109.76)
UGATE1: length 15.5
  TOP w0.127: v3(135.32,123.34) v2(135.88,122.79)
  IN2 w1.016: 134.75,121.82 132.08,119.15 124.46,119.15 122.08,121.53
  vias: v3(121.41,127.47) v3(121.41,126.89) v3(121.59,122.52) v3(122.18,122.52) v3(135.7,123.79)
UGATE2: length 23.4
  TOP w0.127: v2(134.56,128.46) v3(134.56,127.73)
  IN2 w1.016: 133.92,128.55 133.78,128.55 131.94,130.39 129.03,130.39 127.83,131.6 116.78,131.6 113.79,128.61
  vias: v3(113.34,127.73) v3(113.41,122.52) v3(113.92,127.73) v3(114,122.52) v3(133.92,127.73)
UGATE3: length 10.7
  TOP w1.016: 104.02,122.71 v1(104.02,123.69) 104.02,126.71
  IN2 w1.016: 101.35,116.04 101.35,118.84 104.08,121.57
  vias: v3(102.36,116.3) v3(102.36,115.71) v3(104.95,122.46) v3(105.54,122.46)
USB3RN1: length 149.7
  IN5 w0.099: v3(317.79,65.35) 318,65.15 318,64.45 317.83,64.29 317.83,55.73 316.75,54.65 316.75,46.68 317.46,45.97 317.46,38.73 317.81,38.38 317.81,32.44 315.28,29.92 315.28,29.66 314.93,29.32 308.93,29.32 308.57,28.96 298.77,28.96 296.69,31.04 277.54,31.04 276.72,30.23 270.47,30.23 269.78,30.93 266.73,30.93 266.49,30.69 260.12,30.69 254.14,36.67 251.78,36.67 250.36,38.09 249.44,38.09 246.03,41.49 243.27,41.49 241.58,43.19 237.38,43.19 236.14,41.94 232.02,41.94 231.61,42.34 230.36,42.34 228.73,40.71 225.54,40.71 225.14,41.11 217.47,41.11 217.13,40.76 216.12,40.76 215.95,40.59 215.95,40.28 v3(215.83,40.16)
  BOTTOM w0.089: v3(215.83,40.16) 215.75,40.08 215.75,39.9 215.98,39.67 UH1.AR26
  BOTTOM w0.127: RI5.1 319.5,66.43 LI2.3 318.92,66.43 318.77,66.28 318.19,66.28 317.9,65.99 317.9,65.46 v3(317.79,65.35)
USB3RN1_R: length 13.4
  BOTTOM w0.127: JUSB1.5 328.22,71.67 328.15,71.59 327.65,71.59 326.78,70.72 325.37,70.72 324.69,70.04 324.69,66.3 324.3,65.91 323.87,65.91 323.79,65.99 DI3.1 DI3.9 322.25,65.99 322.1,65.84 321.98,65.84 321.4,66.43 LI2.4 320.58,66.43 RI5.2
USB3RN2: length 140.1
  IN5 w0.099: v3(213.87,40.16) 214.08,39.96 214.08,39.72 214.24,39.56 216.65,39.56 216.9,39.31 218.12,39.31 219.16,40.36 224.75,40.36 225.5,39.61 228.55,39.61 228.78,39.37 229.53,39.37 230.29,40.13 235.95,40.13 236.55,40.73 242.01,40.73 242.24,40.5 245.66,40.5 249.14,37.02 250.04,37.02 251.7,35.36 253.77,35.36 259.95,29.18 266.43,29.18 267.19,29.94 269.36,29.94 270.11,29.18 277.17,29.18 277.94,29.96 296.31,29.96 298.46,27.81 310.93,27.81 311.41,28.29 315.49,28.29 319.08,31.88 319.08,36.73 318.85,36.96 318.85,38.98 318.53,39.3 318.53,46.45 317.79,47.19 317.79,50.26 318.91,51.39 318.91,52.5 318.69,52.72 318.52,52.72 318.29,52.95 v3(318.29,52.95)
  BOTTOM w0.089: v3(213.87,40.16) 214.28,39.75 UH1.AW26
  BOTTOM w0.127: RI62.1 319.57,53.03 LI6.3 319.01,53.03 318.76,52.79 318.45,52.79 v3(318.29,52.95)
USB3RN2_R: length 9
  BOTTOM w0.127: JUSB2.5 328.22,53.31 328.09,53.18 327.57,53.18 326.93,52.53 323.95,52.53 323.83,52.65 DI5.1 DI5.9 322.22,52.65 322.12,52.75 321.53,52.75 321.24,53.03 LI6.4 320.65,53.03 RI62.2
USB3RN3: length 235.9
  TOP w0.127: RI71.1 15.69,28.69 LI11.2 16.3,28.69 16.53,28.92 16.94,28.92 v3(17.04,28.82)
  IN1 w0.099: v3(17.04,28.82) 17.21,28.99 17.3,28.99 17.55,28.74 17.55,25.76 17.25,25.45 17.25,23.96 19.55,21.66 22.44,21.66 25.09,19 25.09,17.56 29.63,13.02 30.62,13.02 31.75,11.89 35.29,11.89 36.57,10.6 49.47,10.6 50,11.14 52.62,11.14 53.85,12.37 56.82,12.37 57.86,13.41 64.03,13.41 65.1,12.34 67.51,12.34 68.8,11.05 72.14,11.05 72.87,10.31 95.59,10.31 95.97,10.69 111.22,10.69 111.45,10.92 142.14,10.92 143.71,12.49 149.9,12.49 151.14,13.74 162.01,13.74 164.63,16.36 169.7,16.36 170.62,15.44 172.39,15.44 173.09,16.14 176.29,16.14 176.78,15.65 179.55,15.65 179.81,15.92 189.44,15.92 191.8,18.27 198.92,18.27 205.07,24.43 205.07,33.52 209.18,37.63 211.21,37.63 211.94,38.36 211.94,41.48 212.5,42.03 213.27,42.03 213.73,41.58 214.01,41.58 214.16,41.72 214.19,41.72 214.3,41.83 214.39,41.83 v3(214.63,42.08)
  BOTTOM w0.089: UH1.AW31 214.28,41.73 v3(214.63,42.08)
