# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D3: length 62.6
  TOP w0.089: UV8.B2 v3(185.05,127.08)
  IN3 w0.112: v3(185.05,127.08) 185.42,126.71 186.92,126.71 187.04,126.83 188.98,126.83 191.01,124.8 191.01,124.59 191.85,123.75 194.03,123.75 194.25,123.53 194.25,112.49 195.84,110.9 195.84,110.74 194.98,109.88 194.98,109.72 195.14,109.57 195.29,109.57 196.15,110.43 196.31,110.43 196.48,110.26 196.48,110.06 195.61,109.19 195.61,109.03 195.77,108.87 195.93,108.87 196.9,109.84 197.05,109.84 197.21,109.69 197.21,109.53 196.24,108.56 196.24,108.4 196.4,108.24 196.56,108.24 197.53,109.21 197.69,109.21 197.85,109.05 197.85,108.89 196.87,107.92 196.87,107.77 197.03,107.61 197.19,107.61 198.16,108.58 198.32,108.58 198.48,108.42 198.48,108.26 197.51,107.29 197.51,107.13 197.66,106.97 197.82,106.97 198.79,107.95 198.95,107.95 199.17,107.72 199.17,101.98 197.57,100.38 197.57,93.27 196.8,92.5 196.8,91.75 196.4,91.35 v3(196.4,91.18)
  BOTTOM w0.089: v3(196.4,91.18) 195.6,91.18 UV1.F30
FBB_D4: length 58.6
  TOP w0.089: UV8.E4 v3(186.65,123.88)
  IN3 w0.112: v3(186.65,123.88) 186.92,123.88 187.33,123.47 187.75,123.47 189.17,122.05 189.17,113.1 189.2,113.07 189.2,112.92 188.42,112.14 188.42,111.96 188.56,111.83 188.74,111.83 189.51,112.6 189.67,112.6 189.84,112.43 189.84,112.27 189.03,111.47 189.03,111.29 189.17,111.15 189.35,111.15 190.16,111.96 190.31,111.96 190.48,111.79 190.48,111.63 189.68,110.82 189.68,110.64 189.81,110.51 189.99,110.51 190.8,111.31 190.96,111.31 191.12,111.15 191.12,111 190.28,110.16 190.28,109.98 190.42,109.84 190.59,109.84 191.43,110.68 191.59,110.68 191.75,110.52 191.75,110.36 191.08,109.69 191.08,109.53 191.24,109.38 191.39,109.38 192.07,110.05 192.22,110.05 192.38,109.89 192.38,109.73 191.71,109.06 191.71,108.9 191.87,108.74 192.03,108.74 192.69,109.4 192.87,109.4 193,109.27 193,109.09 192.34,108.43 192.34,108.27 192.51,108.1 192.67,108.1 192.99,108.41 193.17,108.41 193.3,108.28 193.3,108.1 192.99,107.78 192.99,107.62 193.16,107.45 193.31,107.45 193.98,108.12 194.15,108.12 194.29,107.98 194.29,107.8 193.63,107.14 193.63,106.98 193.8,106.81 193.96,106.81 194.47,107.32 194.65,107.32 194.78,107.19 194.78,107.01 194.57,106.79 194.27,106.49 194.27,106.34 194.38,106.24 194.38,99.89 194.67,99.6 194.91,99.6 195.17,99.33 195.17,93.35 194.38,92.55 194.38,90.74 v3(194,90.36)
  BOTTOM w0.089: v3(194,90.36) 194.03,90.32 194.05,90.32 194.39,89.98 UV1.G29
FBB_D5: length 60
  TOP w0.089: UV8.E2 v3(185.05,124.68)
  IN3 w0.112: v3(194.8,89.58) 194.41,89.97 193.86,89.97 193.61,90.22 193.61,92.61 194.38,93.37 194.38,99.34 193.61,100.1 193.61,106.52 191.92,108.21 191.76,108.21 190.87,107.32 190.71,107.32 190.55,107.48 190.55,107.64 191.44,108.53 191.44,108.69 191.28,108.85 191.12,108.85 190.24,107.96 190.08,107.96 189.92,108.12 189.92,108.27 190.81,109.16 190.81,109.32 190.64,109.49 190.05,109.49 189.01,108.45 188.83,108.45 188.69,108.59 188.69,108.77 189.75,109.83 189.75,110 189.61,110.14 189.43,110.14 188.09,108.8 187.91,108.8 187.77,108.94 187.77,109.12 189.16,110.51 189.16,110.69 188.97,110.88 188.79,110.88 188.25,110.34 188.07,110.34 187.93,110.47 187.93,110.65 188.37,111.09 188.37,111.25 188.2,111.42 188.04,111.42 187.64,111.02 187.46,111.02 187.33,111.16 187.33,111.34 187.73,111.74 187.73,111.9 187.56,112.07 187.4,112.07 186.54,111.21 186.38,111.21 186.22,111.37 186.22,111.52 187.08,112.38 187.07,112.39 187.07,123.28 186.88,123.47 186.53,123.47 185.32,124.68 v3(185.05,124.68)
  BOTTOM w0.089: UV1.F29 v3(194.8,89.58)
FBB_D6: length 60.8
  TOP w0.089: UV8.F4 186.25,123.47 v3(186.63,123.08)
  IN3 w0.112: v3(186.63,123.08) 186.21,122.65 184.78,122.65 184.66,122.77 183.96,122.77 183.83,122.65 183.83,113.69 182.77,112.63 182.77,112.45 182.95,112.27 183.12,112.27 184.02,113.16 184.2,113.16 184.33,113.02 184.33,112.85 183.2,111.71 183.2,111.53 183.34,111.38 183.52,111.38 184.85,112.71 185.03,112.71 185.19,112.55 185.19,112.37 184.72,111.9 184.72,111.72 184.86,111.59 185.04,111.59 186.19,112.74 186.37,112.74 186.57,112.54 186.57,112.36 184.88,110.67 184.88,110.49 185.05,110.32 185.23,110.32 185.92,111.01 186.1,111.01 186.25,110.86 186.25,110.68 185.5,109.92 185.5,109.74 185.64,109.6 185.81,109.6 186.71,110.5 186.89,110.5 187.04,110.36 187.04,110.18 186.18,109.31 186.18,109.13 186.34,108.96 186.5,108.96 187.18,109.64 187.36,109.64 187.5,109.5 187.5,109.32 186.82,108.64 186.82,108.49 187.19,108.11 189.11,108.11 190.63,106.59 190.63,105.44 190.92,105.15 192.56,105.15 192.81,104.9 192.81,100.38 193.61,99.57 193.61,93.31 193.2,92.9 193.2,90.39 v3(193.19,90.38)
  BOTTOM w0.089: UV1.J29 192.8,89.99 v3(193.19,90.38)
FBB_D7: length 60.3
  TOP w0.089: UV8.F2 184.22,123.05 182.99,123.05 v3(182.76,123.28)
  IN3 w0.112: v3(182.76,123.28) 182.76,120.23 182.31,119.79 182.31,113.99 182.2,113.88 181.34,113.88 181.23,113.76 181.23,113.54 181.34,113.43 182.2,113.43 182.31,113.32 182.31,113.09 182.2,112.98 181.34,112.98 181.23,112.87 181.23,112.65 181.34,112.53 182.2,112.53 182.61,112.12 182.61,110.7 181.8,109.88 181.8,109.7 181.93,109.56 182.11,109.56 183.6,111.05 183.78,111.05 184.62,110.21 184.62,110.03 183.99,109.4 183.99,109.22 184.12,109.08 184.3,109.08 184.9,109.68 185.05,109.68 185.22,109.51 185.22,109.35 183.84,107.96 183.84,107.78 183.97,107.65 184.15,107.65 185.54,109.03 185.7,109.03 185.92,108.81 185.92,108.65 184.6,107.33 184.6,107.15 184.73,107.01 184.91,107.01 186.24,108.34 186.4,108.34 186.96,107.77 188.61,107.77 190.37,106.02 190.37,104.05 190.87,103.55 191.87,103.55 192,103.42 192,98.2 192.79,97.41 192.79,89.99 v3(193.2,89.58)
  BOTTOM w0.089: UV1.H29 v3(193.2,89.58)
FBB_D8: length 42
  TOP w0.089: UV8.A11 v3(192.25,127.08)
  IN4 w0.112: v3(192.25,127.08) 192.25,126.83 191.86,126.44 191.86,124.28 192.59,123.54 193.29,123.54 193.46,123.38 193.46,122.74 194.31,121.88 194.88,121.88 196.6,120.17 196.6,113.25 200.35,109.5 200.35,107.4 200.68,107.07 200.68,97.17 198.51,95 198.51,94.08 v3(198,93.58)
  BOTTOM w0.089: v3(198,93.58) 198,92.91 197.87,92.78 197.29,92.78 197.16,92.91 197.16,93.05 197.29,93.18 UV1.C33
FBB_D9: length 45.6
  TOP w0.089: UV8.A13 v3(193.85,127.88)
  IN4 w0.112: v3(196.4,93.58) 196.81,93.98 196.81,94.54 197.41,95.14 198.08,95.14 200.41,97.47 200.41,106.36 194.25,112.52 194.25,119.72 193.74,120.23 193.74,121.03 193.44,121.33 193.44,121.64 193.2,121.89 192.88,121.89 192.64,122.13 192.64,122.44 192.4,122.69 192.08,122.69 191.86,122.92 191.86,123.23 191.05,124.03 191.05,126.56 191.18,126.69 191.61,126.69 191.86,126.93 191.86,127.24 192.1,127.49 193.46,127.49 v3(193.85,127.88)
  BOTTOM w0.089: v3(196.4,93.58) 196.4,92.89 196.27,92.76 195.69,92.76 195.56,92.89 195.56,93.05 195.69,93.18 UV1.E33
FBB_D10: length 43.7
  TOP w0.089: UV8.B11 v3(191.45,127.08)
  IN4 w0.112: v3(191.45,127.08) 191.09,127.08 190.63,126.61 190.35,126.61 189.97,126.23 189.97,124.07 190.42,123.62 190.67,123.62 190.9,123.39 190.9,123.08 191.3,122.67 191.61,122.67 191.86,122.43 191.86,122.12 192.1,121.87 192.41,121.87 192.66,121.63 192.66,121.32 192.9,121.07 193.21,121.07 193.46,120.83 193.46,112.68 198.68,107.46 199.98,106.16 199.98,97.4 198.39,95.81 198.16,95.58 196.25,95.58 195.21,94.54 195.21,93.98 v3(194.8,93.58)
  BOTTOM w0.089: UV1.F33 v3(194.8,93.58)
FBB_D11: length 42.9
  TOP w0.089: UV8.B13 v3(193.85,127.08)
  IN4 w0.112: v3(193.85,127.08) 193.46,126.69 192.9,126.69 192.66,126.44 192.66,124.18 193.04,123.79 193.87,123.79 194.24,123.42 194.24,122.93 194.49,122.69 194.97,122.69 195.21,122.45 195.21,122.26 197.1,120.37 197.1,113.39 201.13,109.36 201.13,96.64 199.54,95.05 199.54,93.79 198.93,93.18 197.59,93.18 v3(197.2,93.58)
  BOTTOM w0.089: UV1.D33 v3(197.2,93.58)
FBB_D12: length 50.1
  TOP w0.089: 195.21,124.59 194.68,124.59 194.67,124.58 194.12,124.58 193.81,124.27 193.81,124.21 193.57,123.97 192.15,123.97 UV8.E11
  TOP w0.157: 195.21,124.59 195.37,124.59 195.71,124.93 195.71,126.19 v3(195.79,126.28)
  IN4 w0.112: v3(195.79,126.28) 196.35,125.71 196.97,125.71 199.62,123.06 199.62,120.15 200.36,119.42 200.36,115.36 203.44,112.28 203.44,102.14 204.42,101.16 204.42,94.19 201.91,91.68 199.75,91.68 199.74,91.68 199.24,91.18 v3(198,91.18)
  BOTTOM w0.089: UV1.C30 v3(198,91.18)
FBB_D13: length 49.6
  TOP w0.089: v3(195.21,125.03) 195.21,125.03 194.85,125.03 194.59,124.77 193.94,124.77 UV8.E13
  IN4 w0.112: v3(191.4,93.58) 192.55,92.43 199.64,92.43 200.36,93.15 201.12,93.15 202.76,94.78 202.76,111.76 199.68,114.84 199.68,118.82 198.71,119.79 198.71,122.63 196.31,125.03 195.21,125.03 v3(195.21,125.03)
  BOTTOM w0.089: UV1.K33 v3(191.4,93.58)
FBB_D14: length 54.4
  TOP w0.089: 195.21,123.82 194.61,123.82 194.45,123.97 193.9,123.97 193.71,123.78 192.15,123.78 UV8.F11
  TOP w0.157: 195.21,123.82 195.42,123.82 196.28,124.68 196.28,125.49 196.41,125.62 v3(196.41,126.3)
  IN4 w0.112: v3(196.41,126.3) 197.02,126.3 200.07,123.25 200.07,120.34 200.7,119.71 200.7,115.5 203.78,112.42 203.78,102.29 205.27,100.8 205.27,94.4 202.1,91.23 200.03,91.23 199.58,90.78 197.04,90.78 196.8,91.02 196.8,91.58 v3(196.4,91.98)
  BOTTOM w0.089: UV1.E32 v3(196.4,91.98)
FBB_D15: length 46.8
  TOP w0.089: UV8.F13 193.67,123.48 193.97,123.78 194.37,123.78 194.55,123.6 194.63,123.6 194.8,123.44 194.98,123.26 195.21,123.26
  TOP w0.157: 195.21,123.26 195.69,123.26 v1(196.45,124.02) 196.84,124.42 v3(196.84,125.19)
  IN4 w0.112: v3(196.84,125.19) 196.84,125.19 199.18,122.86 199.18,119.97 200.02,119.13 200.02,115.13 203.1,112.04 203.1,102 203.98,101.12 203.98,95.37 201.3,92.69 200.26,92.69 199.74,92.18 198.83,92.18 198.23,91.58 197.59,91.58 v3(197.2,91.98)
  BOTTOM w0.089: UV1.D32 v3(197.2,91.98)
FBB_D16: length 22.5
  TOP w0.13: v3(191.45,113.48) 191.85,113.88 UV8.U11
  IN5 w0.119: v3(191.45,113.48) 192.6,112.32 192.6,111.59 194.27,109.92 194.27,109.67 194.15,109.56 193.27,109.56 193.14,109.43 193.14,109.21 193.27,109.08 194.15,109.08 194.27,108.96 194.27,108.11 194.15,107.99 193.34,107.99 193.22,107.87 193.22,107.63 193.34,107.52 194.15,107.52 194.27,107.4 194.27,106.38 193.61,105.72 193.61,98.78 v3(193.2,98.38)
  BOTTOM w0.089: UV1.H39 v3(193.2,98.38)
FBB_D17: length 22.5
  TOP w0.13: UV8.U13 v3(193.05,114.28)
  IN5 w0.119: v3(193.05,114.28) 193.6,114.28 193.94,113.94 193.94,112.15 196.79,109.3 196.79,100.43 196.28,99.91 195.65,99.91 195.21,99.48 195.21,98.78 v3(194.8,98.38)
  BOTTOM w0.089: UV1.G39 194.06,97.98 193.93,98.1 193.93,98.58 194.17,98.81 195.01,98.81 195.14,98.69 195.14,98.5 195.01,98.38 v3(194.8,98.38)
FBB_D18: length 20.7
  TOP w0.13: v3(193.05,113.48) 192.31,114.22 192.31,114.77 191.85,115.23 UV8.T11
  IN5 w0.119: v3(194,97.58) 194.39,97.97 194.39,105.7 194.69,106 194.69,110.13 193.05,111.78 v3(193.05,113.48)
  BOTTOM w0.089: v3(194,97.58) 194.8,97.58 UV1.F39
FBB_D19: length 20.7
  TOP w0.13: UV8.T13 v3(193.05,115.08)
  IN5 w0.119: v3(193.05,115.08) 192.53,114.56 192.53,114.07 192.72,113.88 193.3,113.88 193.49,113.68 193.49,111.97 196.01,109.45 196.01,100.59 195.71,100.29 195.1,100.29 v3(194.8,100)
  BOTTOM w0.089: UV1.D41 196.38,100 v3(194.8,100)
FBB_D20: length 30.5
  TOP w0.089: UV8.N11 v3(192.25,118.28)
  IN5 w0.119: v3(192.25,118.28) 192.8,118.28 193.54,117.54 195.24,117.54 195.36,117.66 196.27,117.66 196.67,117.26 196.67,114.66 200.48,110.85 200.48,101.12 197.39,98.03 197.37,98.03 196.54,97.2 196.03,97.2 v3(195.6,96.78)
  BOTTOM w0.089: UV1.F38 v3(195.6,96.78)
FBB_D21: length 28.3
  TOP w0.089: 195.65,117.5 195.63,117.52 194.61,117.52 194.55,117.57 193.75,117.57 UV8.N13
  TOP w0.157: 195.65,117.5 v3(195.9,117.25)
  IN5 w0.119: v3(195.9,117.25) 195.97,117.25 196.32,116.89 196.32,114.35 200.13,110.54 200.13,102.04 197.45,99.36 197.45,98.47 196.44,97.46 195.48,97.46 v3(194.8,96.78)
  BOTTOM w0.089: UV1.G38 v3(194.8,96.78)
FBB_D22: length 31.2
  TOP w0.089: UV8.M11 v3(192.25,119.08)
  IN5 w0.119: v3(197.2,96.78) 197.2,97.05 201.17,101.02 201.17,112.51 199.62,114.06 199.62,115.31 195.46,119.47 192.64,119.47 v3(192.25,119.08)
  BOTTOM w0.089: UV1.D38 v3(197.2,96.78)
FBB_D23: length 28.8
  TOP w0.089: v3(193.85,118.21) 193.45,118.61 UV8.M13
  IN5 w0.119: v3(193.85,118.21) 193.93,118.3 196.13,118.3 197.02,117.41 197.02,116.17 200.83,112.36 200.83,101.16 197.35,97.68 197.33,97.68 196.43,96.78 v3(196.4,96.78)
  BOTTOM w0.089: UV1.E38 v3(196.4,96.78)
FBB_D24: length 28.6
  TOP w0.13: v3(187.58,113.88) 187.04,113.88 186.25,114.68 UV8.U4
  IN5 w0.119: v3(194.8,95.98) 194.59,95.98 194.2,96.37 193.54,96.37 193.2,96.71 193.02,96.71 191.99,97.74 191.99,105.09 192.34,105.44 192.34,106.6 192.34,106.61 192.34,108.42 192.22,108.54 191.35,108.54 191.23,108.66 191.23,108.9 191.35,109.02 192.22,109.02 192.34,109.13 192.34,109.37 192.22,109.49 191.35,109.49 191.23,109.61 191.23,109.85 191.35,109.97 192.22,109.97 192.34,110.09 192.34,110.34 188.79,113.88 v3(187.58,113.88)
  BOTTOM w0.089: UV1.F36 v3(194.8,95.98)
FBB_D25: length 29.3
  TOP w0.13: v3(185.05,114.28) 185.05,114.28 UV8.U2
  IN5 w0.119: v3(185.05,114.28) 185.05,114.2 185.79,113.46 185.79,113.3 185.63,113.14 185.63,112.96 185.79,112.81 185.97,112.81 186.12,112.96 186.29,112.96 186.46,112.79 186.46,112.62 186.31,112.47 186.31,112.29 186.47,112.13 186.65,112.13 186.8,112.28 186.97,112.28 187.21,112.04 187.94,112.04 188.06,112.16 188.06,113.01 188.18,113.14 188.41,113.14 188.54,113.01 188.54,112.16 188.65,112.04 188.91,112.04 189.13,112.25 189.3,112.25 189.46,112.08 189.46,111.92 189.25,111.7 189.25,111.53 189.42,111.37 189.59,111.37 189.8,111.58 189.97,111.58 190.14,111.41 190.54,111.01 190.54,106.37 190.72,106.18 190.72,102.08 190.81,101.99 190.83,101.98 190.83,98.7 191.13,98.4 191.13,96.62 191.43,96.31 v3(191.56,96.31)
  BOTTOM w0.089: v3(191.56,96.31) 191.65,96.22 191.65,94.53 191.75,94.44 191.92,94.44 192,94.52 UV1.K35
FBB_D26: length 30.2
  TOP w0.13: UV8.T4 v3(186.65,115.88)
  IN5 w0.119: v3(195.6,95.98) 195.19,96.38 194.64,96.38 194.35,96.67 193.75,96.67 193.46,96.96 193.13,96.96 192.79,97.3 192.79,110.51 191.94,111.36 191.94,111.53 192.25,111.84 192.25,112.02 192.09,112.18 191.91,112.18 191.6,111.87 191.44,111.87 191.26,112.04 191.26,112.21 191.65,112.6 191.65,112.78 191.49,112.94 191.31,112.94 190.92,112.55 190.75,112.55 190.59,112.72 190.59,112.89 191.07,113.37 191.07,113.55 190.91,113.71 190.73,113.71 190.25,113.23 190.08,113.23 188.28,115.03 187.26,115.03 187.07,115.22 187.07,115.45 v3(186.65,115.88)
  BOTTOM w0.089: UV1.E36 v3(195.6,95.98)
FBB_D27: length 29.9
  TOP w0.13: v3(185.05,115.08) 184.65,115.48 UV8.T2
  IN5 w0.119: v3(185.05,115.08) 185.44,114.69 186.14,114.69 187.32,113.51 188.53,113.51 190.88,111.16 190.88,106.59 191.08,106.4 191.08,98.83 191.45,98.45 191.45,97.69 192.01,97.14 192.01,95.84 192.26,95.59 193.03,95.59 193.09,95.53 196.75,95.53 v3(197.2,95.98)
  BOTTOM w0.089: UV1.D36 v3(197.2,95.98)
FBB_D28: length 35.6
  TOP w0.089: UV8.N4 185.94,118.18 183.12,118.18 182.95,118.01 182.95,115.15 v3(183.33,114.77)
  IN5 w0.119: v3(194.8,94.38) 194.41,94.77 193.84,94.77 193.33,94.26 191.68,94.26 190.86,95.08 190.23,95.08 189.8,95.51 189.8,96.77 189.6,96.96 189.6,97.67 188.01,99.27 188.01,104.82 186.16,106.67 186.16,109.12 184.25,111.02 184.25,111.74 182.94,113.06 182.94,114.39 v3(183.33,114.77)
  BOTTOM w0.089: UV1.G35 v3(194.8,94.38)
FBB_D29: length 32.2
  TOP w0.089: v3(184.25,117.48) 184.25,117.48 UV8.N2
  IN5 w0.119: v3(195.6,94.38) 194.95,95.02 193.74,95.02 193.24,94.52 191.83,94.52 190.82,95.53 190.31,95.53 190.07,95.77 190.07,97.02 189.82,97.26 189.82,97.92 188.72,99.02 188.72,99.25 188.8,99.33 188.8,100.17 188.79,100.18 188.79,100.36 188.41,100.74 188.41,105.18 186.62,106.97 186.62,109.91 186.04,110.49 186.04,110.59 183.8,112.83 183.8,117.03 v3(184.25,117.48)
  BOTTOM w0.089: UV1.F35 v3(195.6,94.38)
FBB_D30: length 39.9
  TOP w0.089: UV8.M4 v3(186.65,118.28)
  IN5 w0.119: v3(186.65,118.28) 186.6,118.33 183.13,118.33 182.49,117.69 182.49,112.87 183.81,111.56 183.81,110.84 185.7,108.95 185.7,106.43 186.82,105.31 186.82,104.51 187.2,104.13 187.2,99.6 187.87,98.93 187.99,98.93 188.47,98.45 188.47,97.56 189.5,96.53 189.5,95.46 190.12,94.83 190.76,94.83 191.6,93.98 195.81,93.98 196,94.17 196,94.62 196.22,94.83 196.75,94.83 v3(197.2,94.38)
  BOTTOM w0.089: UV1.D35 v3(197.2,94.38)
FBB_D31: length 40
  TOP w0.089: v3(182.69,118.77) 183.09,118.37 184.34,118.37 UV8.M2
  IN5 w0.119: v3(182.69,118.77) 182.05,118.13 182.05,112.69 183.36,111.37 183.36,110.65 185.2,108.81 185.2,106.19 186.39,105 186.39,99.03 186.78,98.64 187.84,98.64 188.09,98.39 188.09,97.4 189.19,96.29 189.19,95.2 189.55,94.85 189.55,93.44 189.93,93.05 195.64,93.05 195.99,93.41 195.99,93.72 196.4,94.13 v3(196.4,94.38)
  BOTTOM w0.089: UV1.E35 v3(196.4,94.38)
FBB_D32: length 31.6
  IN2 w0.119: v3(185.85,128.68) 185.45,128.29 185.45,125.28 185.66,125.07 186.01,125.07 186.24,124.84 186.24,122.55 187.04,121.75 187.04,121.28 187.84,120.48 187.84,117.38 188.17,117.05 188.17,112.33 189.68,110.82 189.68,106.45 190.39,105.74 190.39,101.97 v3(190,101.58)
  BOTTOM w0.089: 186.21,128.32 186.25,128.28 UV9.U4 ; UV1.M44 v3(190,101.58)
  BOTTOM w0.157: 186.21,128.32 v3(185.85,128.68)
FBB_D33: length 31.9
  IN2 w0.119: v3(184.25,127.88) 184.64,127.49 184.64,125.21 184.77,125.07 185.28,125.07 185.44,124.91 185.44,122.11 187.05,120.5 187.05,113.97 187.09,113.93 187.09,112.21 188.74,110.57 188.74,105.49 189.04,105.18 189.35,105.18 189.59,104.94 189.59,100.37 v3(189.2,99.98)
  BOTTOM w0.089: UV1.P42 v3(189.2,99.98) ; UV9.U2 v3(184.25,127.88)
FBB_D34: length 29.7
  IN2 w0.119: v3(186.65,127.08) 186.25,126.69 186.25,125.31 186.69,124.88 186.69,124.61 187.05,124.25 187.05,122.92 187.28,122.69 188.27,121.7 188.27,117.79 188.62,117.45 188.62,112.51 190.13,111 190.13,106.36 190.65,105.84 190.65,101.42 v3(190,100.78)
  BOTTOM w0.089: UV9.T4 v3(186.65,127.08) ; UV1.M43 v3(190,100.78)
FBB_D35: length 29.7
  IN2 w0.119: v3(184.25,127.08) 183.84,126.67 183.84,125.25 184.01,125.07 184.41,125.07 184.64,124.84 184.64,121.33 184.89,121.08 185.4,121.08 186.25,120.23 186.25,114.84 186.37,114.71 186.37,113.9 186.2,113.72 186.2,112.83 186.35,112.68 186.35,110.86 187.18,110.03 187.18,106.5 188.81,104.87 188.81,101.97 v3(189.2,101.58)
  BOTTOM w0.089: UV1.P43 v3(189.2,101.58) ; UV9.T2 v3(184.25,127.08)
FBB_D36: length 29.7
  IN2 w0.119: v3(181.58,124.22) 181.89,123.91 181.89,122.3 182.17,122.02 182.17,120.04 182.11,119.98 182.11,113.99 183.59,112.51 183.59,110.41 184.98,109.02 184.98,106.34 185.43,105.9 185.43,104.8 186.64,103.58 187.19,103.58 v3(187.6,103.18)
  BOTTOM w0.089: UV1.R45 v3(187.6,103.18) ; UV9.N4 185.94,123.97 184.27,123.97 184.08,123.78 182.64,123.78 182.53,123.67 182.51,123.67
  BOTTOM w0.157: v3(181.58,124.22) 181.58,124.06 181.97,123.67 182.51,123.67
FBB_D37: length 26
  IN2 w0.119: v3(182.29,124.25) 182.29,122.6 182.89,122.01 182.89,120.04 183.13,119.8 183.48,119.8 183.77,119.51 183.77,116.23 184.04,115.97 184.04,110.7 185.43,109.3 185.43,106.34 186.76,105.01 186.76,104.58 187.37,103.98 v3(187.6,103.98)
  BOTTOM w0.089: UV1.R46 v3(187.6,103.98) ; 182.51,124.27 182.73,124.27 183.03,123.97 184.01,123.97 184.31,124.28 UV9.N2
  BOTTOM w0.157: v3(182.29,124.25) 182.31,124.27 182.51,124.27
FBB_D38: length 32
  IN2 w0.119: v3(187.6,101.58) 187.2,101.98 185.05,101.98 183.3,103.72 183.3,107.14 182.69,107.75 182.69,112.13 180.42,114.41 180.42,121.85 181.38,122.81 v3(181.43,122.81)
  BOTTOM w0.089: UV9.M4 185.94,123.78 184.45,123.78 184.22,123.55 184.22,123.32 184.08,123.17 183.64,123.17 183.27,122.81 182.51,122.81 ; UV1.R43 v3(187.6,101.58)
  BOTTOM w0.157: 182.51,122.81 v3(181.43,122.81)
FBB_D39: length 28.4
  IN2 w0.119: v3(181.43,122.22) 180.91,121.71 180.91,120.45 181.66,119.7 181.66,113.8 183.14,112.32 183.14,107.93 183.75,107.33 183.75,104.07 184.25,103.57 185.6,103.57 186.39,102.78 187.2,102.78 v3(187.6,102.38)
  BOTTOM w0.089: UV1.R44 v3(187.6,102.38) ; 182.51,122.22 182.96,122.22 183.72,122.98 184.16,122.98 184.65,123.47 UV9.M2
  BOTTOM w0.157: 182.51,122.22 v3(181.43,122.22)
FBB_D40: length 30.8
  IN6 w0.119: v3(191.45,127.88) 191.45,127.71 191.06,127.32 191.06,126.84 190.87,126.65 190.18,126.65 188.53,124.99 187.94,124.99 187.06,124.11 187.06,123.71 186.83,123.48 186.43,123.48 186.25,123.3 186.25,114.77 186.57,114.45 186.57,113.85 187.08,113.34 187.08,112.61 188.84,110.85 188.84,109.87 188.03,109.06 v3(188.03,107.36)
  BOTTOM w0.089: UV9.U11 v3(191.45,127.88)
  BOTTOM w0.157: v3(188.03,107.36) 189.21,107.36 189.78,106.79 190.13,106.79 190.83,106.09 190.83,104.8 UV1.M47
FBB_D41: length 35
  IN6 w0.119: v3(193.05,127.88) 192.62,128.31 191.3,128.31 191.05,128.06 191.05,127.62 190.86,127.43 189.71,127.43 189.04,126.77 189.04,125.99 188.48,125.43 187.97,125.43 187.43,124.88 187.02,124.88 185.45,123.31 185.45,113.66 188.43,110.68 188.43,110.29 187.46,109.32 187.46,106.85 188.29,106.02 188.29,103.29 v3(189.2,102.38)
  BOTTOM w0.089: UV1.P44 v3(189.2,102.38) ; UV9.U13 v3(193.05,127.88)
FBB_D42: length 27.6
  IN6 w0.119: v3(191.45,126.28) 191.01,125.84 189.85,125.84 188.82,124.81 188.82,124.65 187.85,123.67 187.85,117.77 188.41,117.2 188.41,113.46 189.66,112.21 189.66,108.78 189.01,108.13 189.01,106.85 188.76,106.6 188.76,104.6 188.99,104.37 189.61,104.37 v3(190,103.98)
  BOTTOM w0.089: v3(191.45,126.28) UV9.T11 ; UV1.M46 v3(190,103.98)
FBB_D43: length 29.3
  IN6 w0.119: v3(193.85,126.28) 194.25,125.88 194.25,124.96 193.33,124.04 191.26,124.04 190.88,123.66 190.39,123.66 189.73,123 189.73,122.26 189.63,122.16 189.63,114.76 191.58,112.8 191.58,107.98 190.88,107.28 190.88,105.31 190.49,104.92 190.49,103.67 v3(190,103.18)
  BOTTOM w0.089: UV9.T13 v3(193.85,126.28) ; UV1.M45 v3(190,103.18)
FBB_D44: length 23.7
  IN6 w0.119: v3(191.45,124.68) 190.75,123.98 190.32,123.98 189.49,123.14 189.49,122.34 189.37,122.23 189.37,114.48 191.17,112.68 191.17,108.15 190.49,107.46 190.49,106.06 v3(189.2,104.78)
  BOTTOM w0.089: UV1.P47 v3(189.2,104.78) ; UV9.N11 v3(191.45,124.68)
FBB_D45: length 25.8
  IN6 w0.119: v3(188.29,106.66) 188.29,106.78 188.6,107.09 188.6,108.3 189.25,108.94 189.25,111.57 188.06,112.76 188.06,116.83 187.06,117.83 187.06,123.27 187.45,123.65 v3(187.45,123.88)
  BOTTOM w0.089: v3(187.45,123.88) 187.55,123.78 190.4,123.78 190.6,123.97 193.14,123.97 UV9.N13
  BOTTOM w0.13: v3(188.29,106.66) 188.8,106.15 UV1.P49
FBB_D46: length 32.7
  IN6 w0.119: v3(194.65,122.28) 194.27,122.66 192.05,122.66 191.85,122.46 191.85,115.58 192.61,114.82 192.61,113.27 192.81,113.07 192.81,103.68 191.89,102.76 191.2,102.76 190.43,101.98 189.77,101.98 189.6,102.15 189.6,102.59 189.2,102.99 v3(189.2,103.18)
  BOTTOM w0.089: UV1.P45 v3(189.2,103.18) ; UV9.M11 192.15,123.78 194.72,123.78 195.02,123.49 195.02,122.65 v3(194.65,122.28)
FBB_D47: length 28.5
  IN6 w0.119: v3(189.2,103.98) 189.61,103.57 189.61,103 189.84,102.77 190.39,102.77 190.73,103.11 190.73,104.53 191.33,105.12 191.96,105.12 192.37,105.53 192.37,112.87 192.17,113.07 192.17,114.38 191.06,115.48 191.06,123.27 191.39,123.6 193.33,123.6 v3(193.85,123.08)
  BOTTOM w0.089: UV9.M13 v3(193.85,123.08) ; UV1.P46 v3(189.2,103.98)
FBB_D48: length 17
  IN2 w0.119: v3(195.6,103.98) 195.99,103.58 196.56,103.58 196.81,103.83 196.81,104.14 197.33,104.67 197.33,109.14 196.09,110.38 v3(196.09,112.51)
  BOTTOM w0.089: 192.48,113.39 192.48,113.68 191.85,114.32 UV9.A11 ; UV1.F46 v3(195.6,103.98)
  BOTTOM w0.157: 192.48,113.39 192.48,113.37 193.33,112.52 v1(193.56,112.52) 196.07,112.52 v3(196.09,112.51)
FBB_D49: length 12.2
  IN2 w0.119: v3(195.6,104.78) 195.99,105.17 195.99,108.58 194.75,109.82 194.75,113.77 v3(194.71,113.81)
  BOTTOM w0.089: UV9.A13 193.45,114.26 193.9,113.81 v3(194.71,113.81) ; UV1.E47 v3(195.6,104.78)
FBB_D50: length 15.6
  IN2 w0.119: v3(196.4,103.98) 196.4,104.18 196.89,104.66 196.89,108.95 195.64,110.2 195.64,113.01 v3(195.65,113.01)
  BOTTOM w0.089: UV1.D47 v3(196.4,103.98) ; UV9.B11 191.85,115.18 192.2,114.82 192.2,114.37 192.67,113.9 193.31,113.9 193.81,113.39
  BOTTOM w0.157: v3(195.65,113.01) 195.52,113.15 194.06,113.15 193.81,113.39
FBB_D51: length 12.9
  IN2 w0.119: v3(196.4,104.78) 196.44,104.82 196.44,108.77 195.2,110.01 195.2,113.91 v3(194.73,114.37)
  BOTTOM w0.089: UV9.B13 193.81,115.12 193.81,114.66 194.1,114.37 v3(194.73,114.37) ; UV1.D48 v3(196.4,104.78)
FBB_D52: length 16
  IN2 w0.119: v3(191.45,117.48) 191.84,117.08 191.84,112.56 192.67,111.73 192.67,108.22 194.06,106.84 194.06,106.3 193.57,105.81 193.57,105.46 193.85,105.17 194.41,105.17 v3(194.8,104.78)
  BOTTOM w0.089: UV1.F48 v3(194.8,104.78) ; UV9.E11 v3(191.45,117.48)
FBB_D53: length 20.6
  IN2 w0.119: v3(193.05,117.48) 193.05,118.39 192.76,118.67 191.28,118.67 190.25,117.64 190.25,112.89 191.78,111.36 191.78,107.85 192.28,107.35 192.28,106.77 192.98,106.07 192.98,105.33 193.55,104.76 193.55,104.68 194,104.22 v3(194,103.98)
  BOTTOM w0.089: v3(194,103.98) UV1.H46 ; UV9.E13 v3(193.05,117.48)
FBB_D54: length 16.4
  IN2 w0.119: v3(194,104.78) 193.93,104.78 193.23,105.48 193.23,105.82 193.69,106.28 193.69,106.57 192.22,108.04 192.22,111.55 191.05,112.72 191.05,117.89 v3(191.45,118.28)
  BOTTOM w0.089: UV9.F11 v3(191.45,118.28) ; v3(194,104.78) UV1.H47
FBB_D55: length 16.1
  IN2 w0.119: v3(193.85,119.01) 193.46,118.62 193.46,117.33 193.19,117.07 192.89,117.07 192.66,116.84 192.66,113 193.12,112.54 193.12,108.41 194.44,107.09 194.44,106.01 v3(194,105.58)
  BOTTOM w0.089: UV9.F13 193.51,118.68 v3(193.85,119.01) ; v3(194,105.58) UV1.H48
FBB_D56: length 17.7
  IN4 w0.112: v3(191.6,102.38) 192.15,102.93 192.15,103.17 193.11,104.13 193.11,105.71 193.66,106.26 193.66,107.65 187.97,113.33 187.37,113.33 186.42,114.28 v3(185.91,114.28)
  BOTTOM w0.089: v3(185.91,114.28) 185.91,114.27 186.25,114.61 UV9.A4 ; v3(191.6,102.38) UV1.L45
FBB_D57: length 22.7
  IN4 w0.112: v3(191.6,101.58) 192.55,101.58 192.8,101.83 192.8,103.47 193.44,104.1 193.44,105.57 194.49,106.62 194.49,108.66 188.62,114.52 v3(187.59,114.52)
  BOTTOM w0.089: UV9.A2 184.65,114.09 184.94,113.79 186.86,113.79 v3(187.59,114.52) ; UV1.L44 v3(191.6,101.58)
FBB_D58: length 18.9
  IN4 w0.112: v3(193.2,103.18) 194.02,103.18 194.39,103.55 194.39,105.92 194.93,106.45 194.93,108.84 188.7,115.08 v3(186.65,115.08)
  BOTTOM w0.089: UV1.J46 v3(193.2,103.18) ; UV9.B4 186.27,115.48 186.63,115.11 186.63,115.09 v3(186.65,115.08)
FBB_D59: length 15.1
  IN4 w0.112: v3(193.22,106.38) 193.21,106.39 193.21,107.46 188.56,112.11 188.17,112.11 v3(187.52,112.76)
  BOTTOM w0.089: v3(193.22,106.38) 193.6,106 UV1.H49 ; 187.33,113.39 187.14,113.59 184.66,113.59 184.34,113.9 184.34,115.17 UV9.B2
  BOTTOM w0.157: v3(187.52,112.76) 187.52,113.2 187.33,113.39
FBB_D60: length 23.9
  IN4 w0.112: v3(183.33,118.79) 183.33,118.79 182.56,118.02 182.56,113.36 183.47,112.44 183.78,112.14 183.78,111.44 184.92,110.29 184.92,108.84 188.58,105.18 190.12,105.18 191.33,103.98 v3(191.6,103.98)
  BOTTOM w0.089: v3(183.33,118.79) 183.33,118.61 183.4,118.53 183.75,118.18 185.94,118.18 UV9.E4 ; UV1.L47 v3(191.6,103.98)
FBB_D61: length 16.8
  IN4 w0.112: v3(185.05,117.48) 184.65,117.08 184.65,113.89 184.79,113.76 185.04,113.76 185.51,113.28 185.51,112.46 186.39,111.59 186.39,111.42 186.39,111.42 186.39,110.56 187.94,109.01 188.77,109.01 190.31,107.47 190.78,107.47 v3(191.34,106.91)
  BOTTOM w0.089: UV1.J49 192.13,106.64 191.86,106.64 191.71,106.79 ; UV9.E2 v3(185.05,117.48)
  BOTTOM w0.157: v3(191.34,106.91) 191.59,106.91 191.71,106.79
FBB_D62: length 23.2
  IN4 w0.112: v3(191.59,104.71) 191.59,104.71 190.27,106.03 188.37,106.03 185.5,108.9 185.5,111.21 183.76,112.95 182.81,113.9 182.81,117.91 183.22,118.33 183.5,118.33 v3(184.25,119.08)
  BOTTOM w0.089: UV1.L48 191.2,105.1 v3(191.59,104.71) ; v3(184.25,119.08) 184.25,118.58 184.45,118.37 185.94,118.37 UV9.F4
FBB_D63: length 18.8
  IN4 w0.112: v3(191.56,105.54) 191.48,105.54 190.59,106.42 189.89,106.42 185.94,110.38 185.94,111.23 185.94,111.4 184.09,113.25 183.83,113.51 183.83,117.87 v3(185.05,119.08)
  BOTTOM w0.089: v3(191.56,105.54) 191.2,105.9 UV1.L49 ; UV9.F2 v3(185.05,119.08)
FBB_DBI0#: length 57.7
  TOP w0.089: UV8.D2 v3(185.05,125.48)
  IN3 w0.112: v3(195.6,90.38) 196,90.77 196,92.52 196.77,93.3 196.77,101.73 196.53,101.98 196.27,101.98 196,102.25 196,107.45 193.71,109.74 193.71,109.9 194.72,110.9 194.72,111.06 194.56,111.22 194.4,111.22 193.4,110.21 193.24,110.21 193.08,110.37 193.08,110.53 194.09,111.54 194.09,111.69 193.93,111.85 193.77,111.85 192.76,110.84 192.61,110.84 192.45,111 192.45,111.16 193.46,112.17 193.46,112.33 193.3,112.49 193.14,112.49 192.13,111.48 191.97,111.48 191.81,111.64 191.81,111.79 192.82,112.8 192.82,112.96 192.66,113.12 192.51,113.12 191.5,112.11 191.34,112.11 191.17,112.28 191.17,112.46 192.23,113.52 192.23,113.68 191.84,114.07 191.84,123.28 191.43,123.69 190.03,123.69 187.87,125.85 185.42,125.85 v3(185.05,125.48)
  BOTTOM w0.089: UV1.E29 v3(195.6,90.38)
FBB_DBI1#: length 43.9
  TOP w0.089: UV8.D13 v3(193.05,124.68)
  IN4 w0.112: v3(193.05,124.68) 193.41,124.32 194.18,124.32 195.18,123.32 196.24,123.32 197.63,121.93 197.63,113.49 201.67,109.45 201.67,96.36 199.91,94.6 199.91,93.81 199.03,92.93 194.65,92.93 v3(194,93.58)
  BOTTOM w0.089: UV1.G33 v3(194,93.58)
FBB_DBI2#: length 28
  TOP w0.089: UV8.P13 193.75,117.38 194.48,117.38 194.53,117.33 194.9,117.33 195.21,117.01
  TOP w0.157: 195.21,117.01 195.67,116.55 v3(195.9,116.55)
  IN5 w0.119: v3(195.9,116.55) 195.9,114 198.54,111.37 198.54,108.67 198.41,108.54 198.41,100.83 197.17,99.6 197.17,98.54 196.46,97.84 195.27,97.84 194.49,97.06 193.72,97.06 v3(193.2,97.58)
  BOTTOM w0.089: UV1.H38 v3(193.2,97.58)
FBB_DBI3#: length 33.3
  TOP w0.089: UV8.P2 v3(184.25,116.68)
  IN5 w0.119: v3(198,95.98) 197.3,95.28 193.49,95.28 192.98,94.77 192.09,94.77 190.89,95.96 190.89,96.14 190.59,96.44 190.59,97.94 190.36,98.17 190.28,98.17 189.59,98.85 189.59,105.77 189.36,106.01 188.34,106.01 187.16,107.19 187.16,110.14 186.59,110.71 186.59,110.81 184.34,113.06 184.34,116.58 v3(184.25,116.68)
  BOTTOM w0.089: v3(198,95.98) UV1.C36
FBB_DBI4#: length 28.3
  IN2 w0.119: v3(188.4,100.01) 188.35,100.06 188.35,104.88 186.63,106.6 186.63,109.75 185.81,110.58 185.81,112.46 185.66,112.6 185.66,113.76 185.45,113.96 185.45,120.14 185.31,120.28 184.58,120.28 183.85,121 183.85,122.57 184.25,122.96 v3(184.25,124.68)
  BOTTOM w0.089: v3(188.4,100.01) 188.41,100 188.41,99.97 UV1.P41 ; UV9.P2 v3(184.25,124.68)
FBB_DBI5#: length 26.9
  IN6 w0.119: v3(189.2,105.58) 190.02,106.4 190.02,107.71 190.67,108.36 190.67,112.55 189.11,114.11 189.11,122.38 188.62,122.86 188.62,123.41 189.51,124.3 189.51,124.65 190.21,125.35 191.67,125.35 191.94,125.08 193.45,125.08 v3(193.85,125.48)
  BOTTOM w0.089: UV1.P48 v3(189.2,105.58) ; UV9.P13 v3(193.85,125.48)
FBB_DBI6#: length 14.9
  IN2 w0.119: v3(193.05,116.68) 193.05,116.63 193.44,116.24 193.44,113.5 193.66,113.28 193.66,109.37 194.9,108.14 194.9,106.31 195.19,106.02 195.19,104.37 v3(194.8,103.98)
  BOTTOM w0.089: UV1.F47 v3(194.8,103.98) ; UV9.D13 v3(193.05,116.68)
FBB_DBI7#: length 18.2
  IN4 w0.112: v3(185.05,116.68) 185.44,116.29 185.44,114.06 186.06,113.44 186.06,112.69 189.03,109.71 189.42,109.71 192.12,107.01 192.12,106.51 192.33,106.3 192.33,105.79 192,105.46 192,103.58 v3(191.6,103.18)
  BOTTOM w0.089: v3(191.6,103.18) 191.56,103.18 191.2,103.53 UV1.L46 ; UV9.D2 v3(185.05,116.68)
FBB_EDC0: length 45.1
  TOP w0.089: UV8.C2 v3(184.25,126.28)
  IN3 w0.112: v3(194.8,91.21) 195.2,91.61 195.2,92.55 195.97,93.32 195.97,99.77 195.2,100.55 195.2,107.66 189.7,113.16 189.7,123.61 188.23,125.08 184.92,125.08 184.25,125.75 v3(184.25,126.28)
  BOTTOM w0.089: UV1.J30 192.8,90.81 193.2,91.21 v3(194.8,91.21)
FBB_EDC1: length 46.9
  TOP w0.089: UV8.C13 v3(193.05,125.48)
  IN4 w0.112: v3(193.2,93.58) 194.1,92.68 199.45,92.68 200.23,93.47 200.67,93.47 202.21,95.01 202.21,111.4 198.13,115.48 198.13,122.32 196.19,124.26 195.35,124.26 194.6,125 193.52,125 v3(193.05,125.48)
  BOTTOM w0.089: UV1.H33 193.6,93.18 v3(193.2,93.58)
FBB_EDC2: length 22.1
  TOP w0.089: UV8.R13 193.45,116.28 v3(193.85,115.88)
  IN5 w0.119: v3(193.85,115.88) 193.85,115.88 194.31,115.41 194.31,113.57 194.37,113.51 194.37,112.5 194.54,112.32 194.71,112.32 195.13,112.74 195.3,112.74 195.47,112.57 195.47,112.4 195.05,111.98 195.05,111.81 197.61,109.25 197.61,100.58 196.79,99.76 196.79,98.77 v3(196.39,98.38)
  BOTTOM w0.089: UV1.D39 196.79,97.98 v3(196.39,98.38)
FBB_EDC3: length 36.2
  TOP w0.089: UV8.R2 184.34,115.97 184.34,113.83 184.77,113.39
  TOP w0.157: 184.77,113.39 v3(185.05,113.12)
  IN5 w0.119: v3(192.39,95.17) 192.05,95.17 191.15,96.07 191.15,96.24 190.87,96.51 190.87,98.27 190.47,98.67 190.47,101.97 190.38,102.06 190.38,102.2 190.39,102.21 190.39,102.54 190.38,102.55 190.38,103 190.39,103.01 190.39,103.34 190.38,103.35 190.38,103.8 190.39,103.81 190.39,104.14 190.38,104.15 190.38,104.57 190.39,104.58 190.39,105.49 189.8,106.07 189.8,108.46 189.68,108.58 187.71,108.58 187.58,108.7 187.58,108.93 187.71,109.06 189.68,109.06 189.8,109.17 189.8,109.42 189.68,109.54 187.71,109.54 187.58,109.67 187.58,109.89 187.71,110.02 189.68,110.02 189.8,110.14 189.8,110.38 188.69,111.5 186.5,111.5 185.05,112.95 v3(185.05,113.12)
  BOTTOM w0.089: UV1.J35 193.18,94.78 193.3,94.89 193.3,95.13 193.17,95.25 192.48,95.25 v3(192.39,95.17)
FBB_EDC4: length 30.8
  IN2 w0.119: v3(182.76,125.08) 182.94,124.9 182.94,124.19 183.17,123.96 183.53,123.96 183.83,123.66 183.83,123.22 183.39,122.77 183.39,120.83 184.65,119.57 184.65,116.41 184.62,116.38 184.62,112.88 185.27,112.23 185.27,110.29 185.97,109.58 185.97,106.67 187.99,104.65 187.99,100.37 v3(187.6,99.98)
  BOTTOM w0.089: v3(182.76,125.08) 183.2,125.52 184.29,125.52 UV9.R2 ; UV1.R42 v3(187.6,99.98)
FBB_EDC5: length 27
  IN6 w0.119: v3(193.05,126.28) 192.63,125.86 191.99,125.86 191.74,125.61 189.94,125.61 189.12,124.79 189.12,124.41 188.33,123.62 188.33,122.77 188.69,122.42 188.69,122.09 188.25,121.66 188.25,118.2 188.71,117.74 188.71,113.84 190.08,112.47 190.08,108.49 189.52,107.92 189.52,106.75 v3(189.24,106.47)
  BOTTOM w0.089: UV1.M48 189.56,106.02 189.56,106.19 189.47,106.28 189.43,106.28 v3(189.24,106.47) ; UV9.R13 v3(193.05,126.28)
FBB_EDC6: length 12.3
  IN2 w0.119: v3(193.85,116.68) 194.24,116.29 194.24,115.02 194.06,114.84 194.06,113.65 194.21,113.51 194.21,109.6 195.33,108.48 195.33,106.65 v3(195.6,106.38)
  BOTTOM w0.089: UV9.C13 v3(193.85,116.68) ; UV1.F49 v3(195.6,106.38)
FBB_EDC7: length 19.7
  IN4 w0.112: v3(186.63,113.2) 186.63,112.88 189.13,110.38 189.52,110.38 192.67,107.24 192.67,105.04 192.41,104.79 v3(192.4,104.78)
  BOTTOM w0.089: UV1.J47 192.8,104.07 192.93,103.94 193.09,103.94 193.22,104.07 193.22,104.65 193.09,104.78 v3(192.4,104.78) ; 184.15,113.39 184.15,115.78 UV9.C2
  BOTTOM w0.157: v3(186.63,113.2) 186.09,112.66 v1(185.69,112.66) 184.8,112.66 184.15,113.31 184.15,113.39
FBB_MA0_MA10_H: length 31.6
  BOTTOM w0.157: UV9.K4 186.61,122.24 187.35,122.24 187.86,122.75 188.52,122.75 189.38,121.88 189.38,113.53 192.41,110.5 v1(193.3,110.5) 194.86,110.5 200.34,105.02 200.34,103.76 199.56,102.98 199.56,102.63 199.31,102.38 198,102.38 UV1.C44
FBB_MA0_MA10_L: length 44
  TOP w0.089: v3(188.25,122.28) 188.19,122.22 186.6,122.22 186.26,121.88 UV8.H4
  IN1 w0.089: 193,119.88 190.63,119.88 190.35,120.15 189.85,120.15 189.47,120.54 189.47,121.14 188.32,122.28
  IN1 w0.119: v3(200.75,92.23) 200.75,92.41 202.82,94.49 202.82,96.55 202.1,97.27 202.1,100.93 202.1,105.07 198.71,108.45 198.71,109.78 196.55,111.94 196.55,112.78 195.44,113.88 195.44,117.2 195.14,117.5 195.14,117.5 194.61,117.5 194.31,117.8 194.31,118.4 194.08,118.64 193.62,118.64 193.42,118.84 193.42,119.46 193,119.88 ; v3(188.25,122.28) 188.32,122.28
  BOTTOM w0.102: UV1.B32 198.73,92.05 200.56,92.05 v3(200.75,92.23)
FBB_MA1_MA9_H: length 27.8
  BOTTOM w0.157: UV1.A45 199.2,102.99 200.01,103.8 200.01,104.98 198.24,106.76 197.93,106.76 v1(195.57,109.12) 194.64,110.05 191.57,110.05 189.08,112.54 189.08,121.66 188.86,121.88 UV9.K5
FBB_MA1_MA9_L: length 46.5
  TOP w0.089: v3(189.05,123.08) 189.05,122.35 188.58,121.88 UV8.H5
  IN1 w0.089: 189.72,122.41 189.72,120.59 189.94,120.37 190.44,120.37 190.72,120.09 193.6,120.09 194.3,119.39 194.3,118.9
  IN1 w0.119: v3(201.39,92.23) 201.39,92.48 203.27,94.35 203.27,96.74 202.51,97.5 202.51,101.1 202.51,105.37 199.12,108.76 199.12,108.86 199.12,109.91 196.91,112.12 196.91,112.91 196.34,113.49 196.34,117.64 196.02,117.95 195.46,117.95 194.96,118.45 194.74,118.45 194.3,118.9 ; 189.72,122.41 v3(189.05,123.08)
  BOTTOM w0.102: UV1.B30 198.8,91.18 199.47,91.18 200.04,91.74 200.83,91.74
  BOTTOM w0.157: v3(201.39,92.23) 201.32,92.23 200.83,91.74
FBB_MA2_BA0_H: length 38.5
  BOTTOM w0.157: UV1.C39 197.18,98.4 197.18,99.76 197.42,100 199.33,100 200.74,101.41 201.15,101.41 202.74,102.99 202.74,106.71 198.17,111.28 196.85,111.28 196.56,110.99 192.54,110.99 v1(191.75,111.78) 189.65,113.88 189.65,120.96 190.03,121.33 190.7,121.33 190.83,121.46 191.43,121.46 UV9.K11
FBB_MA2_BA0_L: length 41.5
  TOP w0.089: v3(191.45,122.28) UV8.H11
  IN1 w0.119: v3(191.45,122.28) 191.83,122.67 195.16,122.67 195.71,123.22 197.61,123.22 198.67,122.16 198.67,120.07 199.77,118.96 199.77,116.83 201.48,115.13 201.48,109.43 204.14,106.76 204.14,101.78 204.14,100.05 204.73,99.46 v3(204.86,99.46)
  BOTTOM w0.157: v3(204.86,99.46) 203.63,99.46 202.67,98.51 202.67,98.05 201.72,97.1 200.72,97.1 UV1.A36
FBB_MA3_BA3_H: length 38.9
  IN1 w0.119: v3(190.25,121.78) 190.35,121.87 194.1,121.87 194.32,121.64 195.59,121.64 196.22,122.26 197.17,122.26 197.8,121.63 197.8,119.71 198.38,119.14 198.38,114.86 199.46,113.78 199.46,112.51 v3(199.91,112.06)
  BOTTOM w0.089: UV9.K10 190.36,121.88 v3(190.25,121.78) ; UV1.B39 198.4,98.3 198.87,98.77 199.39,98.77
  BOTTOM w0.157: 199.39,98.77 200.72,100.09 201.78,100.09 202.9,101.21 203.4,101.21 204.09,101.9 v1(204.09,107.19) 204.09,107.88 v3(199.91,112.06)
FBB_MA3_BA3_L: length 45.1
  TOP w0.089: UV8.H10 v3(190.65,122.28)
  IN1 w0.119: v3(190.65,122.28) 191.02,122.65 191.02,123.5 191.34,123.81 194.97,123.81 195.33,124.17 197.82,124.17 199.57,122.42 199.57,120.33 200.47,119.43 202.3,117.6 202.3,109.65 204.96,106.99 204.96,101.97 205.31,101.62 205.31,100.31 205.05,100.05 v3(204.86,100.05)
  BOTTOM w0.089: UV1.B36 198.55,95.58 200.5,97.53 201.11,97.53
  BOTTOM w0.157: 201.11,97.53 201.54,97.53 202.23,98.23 v1(202.23,98.69) 203.44,99.9 204.71,99.9 v3(204.86,100.05)
FBB_MA4_BA2_H: length 35.5
  BOTTOM w0.157: UV9.H11 191.44,119.87 190.6,119.87 190.21,119.49 190.21,114.64 190.96,113.9 191.63,113.9 191.9,113.63 191.9,113.15 193.18,111.87 196.21,111.87 196.58,112.24 198.83,112.24 203.61,107.46 v1(203.61,105.09) 203.61,102.54 201.6,100.53 200.66,100.53 199.24,99.11 198.87,99.11 UV1.B41
FBB_MA4_BA2_L: length 41.5
  TOP w0.089: UV8.K11 v3(191.45,120.68)
  IN1 w0.089: 193.45,121.06 191.83,121.06 v3(191.45,120.68)
  IN1 w0.119: 193.45,121.06 193.59,120.92 193.75,120.92 193.95,121.11 194.13,121.11 194.29,120.96 194.29,120.78 194.09,120.58 194.09,120.41 194.67,119.84 195.56,119.84 195.74,120.02 195.74,120.15 196.01,120.42 196.45,120.42 196.85,120.02 196.85,119.51 197.56,118.8 197.56,114.69 197.84,114.42 197.84,114.25 197.67,114.08 197.67,113.91 197.84,113.75 198.01,113.75 198.17,113.91 198.34,113.91 198.7,113.55 198.7,113.31 198.58,113.19 198.2,113.19 198.08,113.07 198.08,112.83 198.2,112.71 198.58,112.71 198.7,112.59 198.7,112.01 200.66,110.05 200.66,109.06 203.32,106.39 203.32,101.44 203.32,98.99 v3(203.54,98.76)
  BOTTOM w0.157: UV1.C35 198,95.18 199.39,95.18 200.88,96.66 202.01,96.66 203.11,97.75 203.11,98.31 203.54,98.75 v3(203.54,98.76)
FBB_MA5_BA1_H: length 32.7
  BOTTOM w0.157: UV9.H10 190.52,120.28 189.92,119.67 189.92,114.4 192.89,111.43 v1(195.1,111.43) 196.39,111.43 196.69,111.74 198.44,111.74 203.18,107 203.18,102.81 201.33,100.97 200.67,100.97 199.28,99.58 UV1.A41
FBB_MA5_BA1_L: length 39.5
  TOP w0.089: UV8.K10 v3(190.65,120.68)
  IN1 w0.089: v3(190.65,120.68) 191.02,120.3 193.81,120.3
  IN1 w0.119: v3(203.54,98.13) 202.92,98.76 202.92,101.27 202.91,106.31 202.24,106.98 202.07,106.98 201.87,106.78 201.7,106.78 201.53,106.94 201.53,107.11 201.74,107.32 201.74,107.49 201.57,107.66 201.4,107.66 201.19,107.45 201.02,107.45 200.85,107.62 200.85,107.79 201.06,108 201.06,108.16 200.89,108.33 200.72,108.33 200.52,108.13 200.35,108.13 200.18,108.3 200.18,108.46 200.38,108.67 200.38,108.84 200.25,108.97 200.25,109.88 197.73,112.4 197.73,113.25 197.15,113.83 197.15,118.6 196.92,118.84 195.96,118.84 195.32,119.48 194.64,119.48 193.81,120.3
  BOTTOM w0.157: v3(203.54,98.13) 203.54,97.57 v1(202.35,96.37) 202.2,96.22 200.91,96.22 199.46,94.78 UV1.A35
FBB_MA6_MA11_H: length 30.9
  IN1 w0.119: v3(188.67,119.67) 188.89,119.67 190.15,118.41 190.77,118.41 191.3,117.88 191.71,117.88 191.84,117.76 191.84,117.27 192.05,117.06 192.47,117.06 192.66,116.87 192.66,114.84 192.83,114.67 193.33,114.67 193.46,114.54 193.46,112.24 196.19,109.51 198.05,109.51 v3(198.12,109.44)
  BOTTOM w0.089: v3(188.67,119.67) 188.06,120.28 UV9.H5
  BOTTOM w0.157: UV1.C42 198,100.78 198.6,100.78 198.9,101.08 199.22,101.08 200.53,102.39 200.53,102.85 201.43,103.75 201.43,105.79 198.12,109.09 v3(198.12,109.44)
FBB_MA6_MA11_L: length 37.7
  TOP w0.089: UV8.K5 187.43,120.28 188.6,119.11 v3(188.67,119.11)
  IN1 w0.119: v3(188.67,119.11) 189.75,118.03 190.76,118.03 191.06,117.73 191.06,117.31 191.29,117.08 191.68,117.08 191.85,116.92 191.85,115.33 192.34,114.84 192.34,112.78 196,109.13 197.46,109.13 201.53,105.05 201.53,97.22 201.78,96.97 202.38,96.38 202.38,94.62 201.61,93.86 v3(200.44,93.86)
  BOTTOM w0.089: 199.76,93.18 v3(200.44,93.86)
  BOTTOM w0.102: UV1.A33 199.76,93.18
FBB_MA7_MA8_H: length 32.5
  IN1 w0.089: 190.21,118.68 188.67,120.23
  IN1 w0.119: v3(197.86,109.98) 196.3,109.98 194.09,112.18 194.09,113.27 193.8,113.56 193.8,115.2 193.45,115.56 193.45,116.96 193.32,117.08 192.83,117.08 192.66,117.25 192.66,118.47 192.45,118.68 190.21,118.68 ; 188.67,120.23 v3(188.67,120.25)
  BOTTOM w0.089: v3(188.67,120.25) 188.34,120.58 186.55,120.58 UV9.H4
  BOTTOM w0.157: v3(197.86,109.98) 198.22,109.98 v1(198.88,109.32) 199.01,109.18 199.01,108.84 200.83,107.02 200.92,107.02 201.87,106.08 201.87,103.35 199.29,100.78 199,100.78 198.6,100.38 UV1.B42
FBB_MA7_MA8_L: length 39.2
  TOP w0.089: v3(188.67,118.54) 187.27,119.94 186.59,119.94 UV8.K4
  IN1 w0.119: v3(188.67,118.54) 188.67,118.27 189.87,117.06 190.95,117.06 191.06,116.94 191.06,115.41 191.84,114.63 191.84,112.71 195.83,108.72 197.33,108.72 201.11,104.94 201.11,97.06 201.3,96.88 201.3,96.71 201.1,96.51 201.1,96.33 201.26,96.17 201.44,96.17 201.64,96.37 201.8,96.37 202.03,96.15 202.03,94.77 201.47,94.21 200.7,94.21 v3(200.47,94.44)
  BOTTOM w0.102: UV1.B33 198.79,93.56 199.58,93.56 v3(200.46,94.44)
FBB_MA12_RFU_H: length 29.1
  IN1 w0.089: 192.81,119.66 189.92,119.66 189.25,120.33 189.25,120.82 189.09,120.98 v3(188.66,121.41)
  IN1 w0.119: 192.81,119.66 193.13,119.35 193.13,118.31 194.21,117.23 194.86,117.23 195.14,116.95 195.14,112.51 196.85,110.8 v3(196.99,110.8)
  BOTTOM w0.089: UV9.J5 187.85,121.08 188.18,121.41 v3(188.66,121.41)
  BOTTOM w0.157: v3(196.99,110.8) 196.8,110.61 196.8,109.18 199.19,106.79 199.19,106.54 200.6,105.12 200.6,103.65 199.82,102.87 199.82,102.47 199.32,101.98 UV1.A44
FBB_MA12_RFU_L: length 38
  TOP w0.089: v3(187.45,121.48) UV8.J5
  IN1 w0.089: v3(187.45,121.48) 188.29,120.63 188.29,118.33
  IN1 w0.119: v3(201.46,95.29) 201.46,95.47 201.11,95.82 200.7,96.23 200.7,104.82 197.23,108.29 195.67,108.29 190.13,113.83 190.13,116.49 188.29,118.33
  BOTTOM w0.102: UV1.A32 200.29,92.38
  BOTTOM w0.13: 200.29,92.38 201.11,93.2
  BOTTOM w0.157: v3(201.46,95.29) 201.46,94.66 201.36,94.55 201.36,93.45 201.11,93.2
FBB_RAS#_H: length 25.6
  IN1 w0.089: v3(185.85,122.28) 185.85,121.42 187.87,119.4 187.87,117.97 188.68,117.15
  IN1 w0.119: 188.68,117.15 189.46,116.38 189.46,113.34 195.39,107.41 196.24,107.41 199.59,104.06 v3(199.59,103.93)
  BOTTOM w0.089: UV9.L3 v3(185.85,122.28)
  BOTTOM w0.13: v3(199.59,103.93) 199.23,103.58 UV1.A46
FBB_RAS#_L: length 55.1
  TOP w0.089: UV8.G3 v3(185.05,123.08)
  IN1 w0.119: v3(204.86,98.88) 205.01,98.88 205.68,99.55 205.68,101.82 205.37,102.13 205.37,107.22 202.7,109.88 202.7,117.77 200.05,120.42 200.05,122.51 197.94,124.63 193.61,124.63 193.28,124.29 191.05,124.29 190.72,123.96 188.43,123.96 187.97,123.49 185.46,123.49 v3(185.05,123.08)
  BOTTOM w0.157: v3(204.86,98.88) 205.3,98.44 205.3,97.06 v1(202.77,94.53) 201.85,93.6 201.85,92.02 201.54,91.72 201.49,91.72 201.19,91.42 200.3,91.42 199.65,90.78 UV1.A30
FBB_RST#_H: length 31.3
  BOTTOM w0.157: UV9.J2 184.26,120.69 182.93,120.69 182.21,119.97 182.21,113.83 183.17,112.87 183.66,112.87 184.43,112.09 187,112.09 v1(187.55,111.54) 189.24,109.86 189.68,109.86 RV112.1 192.61,106.92 195.83,106.92 195.96,106.79 196.39,106.36 196.39,105.67 196.48,105.58 196.95,105.58 197.18,105.36 197.18,104.89 197.3,104.76 198.57,104.76 198.8,104.53 198.8,103.98 UV1.B46
FBB_RST#_L: length 44.2
  TOP w0.089: UV8.J2 v3(185.05,121.48)
  IN1 w0.089: 188.57,116.39 187.62,117.33 186.99,117.33 186.22,118.1 186.22,120.3 v3(185.05,121.48)
  IN1 w0.119: 188.57,116.39 188.57,112.2 194.78,105.98 195.8,105.98 196.01,105.77 196.01,100.6 198.97,97.64 198.97,95.58 199.53,95.02 199.53,90.91 200.22,90.22 200.62,90.22 v3(201.11,90.72)
  BOTTOM w0.089: v3(201.11,90.72) 200.66,90.26 199.49,90.26 UV1.A29
  BOTTOM w0.157: RV111.1 201.78,91.22 v1(201.77,91.23) 201.63,91.23 v3(201.11,90.72)
FBB_WCK0: length 49
  TOP w0.089: v3(188.35,125.96) 188.3,126.01 188.09,126.01 188.03,125.95 188.03,125.19 187.42,124.58 186.83,124.58 186.69,124.73 186.69,124.93 186.55,125.08 UV8.D4
  IN2 w0.119: v3(195.6,91.98) 195.32,92.26 195.32,92.41 195.59,92.67 197.93,92.67 198.59,93.33 198.59,99.6 199.39,100.4 199.39,103.5 198.76,104.13 198.76,109.99 196.95,111.8 196.95,120.16 196.09,121.02 196.09,122.49 194.76,123.82 189.95,123.82 188.06,125.72 188.06,125.94 188.08,125.96 v3(188.35,125.96)
  BOTTOM w0.11: UV1.F32 v3(195.6,91.98)
FBB_WCK0_N: length 48.6
  TOP w0.089: UV8.D5 186.88,124.91 186.88,124.8 186.91,124.77 187.34,124.77 187.84,125.26 187.84,126.03 188.09,126.28 v3(188.09,126.46)
  IN2 w0.119: v3(194.8,91.98) 195.11,92.29 195.11,92.49 195.5,92.88 197.84,92.88 198.38,93.42 198.38,99.69 199.18,100.49 199.18,103.42 198.55,104.04 198.55,109.9 196.74,111.71 196.74,120.07 195.88,120.93 195.88,122.41 194.67,123.61 189.87,123.61 187.85,125.63 187.85,126.21 v3(188.09,126.46)
  BOTTOM w0.11: v3(194.8,91.98) UV1.G32
FBB_WCK1: length 44.1
  TOP w0.14: v3(190.65,115.88) 190.48,115.71 189.69,115.71 187.97,117.43 186.6,117.43 UV8.P4
  IN4 w0.112: v3(190.65,115.88) 190.84,115.69 191.1,115.69 191.41,115.37 192.15,115.37 192.43,115.09 192.43,112.87 196.05,109.25 196.05,108.93 195.55,108.42 195.55,108.25 195.77,108.03 195.95,108.03 196.45,108.53 196.78,108.53 197.14,108.17 197.14,107.84 196.37,107.08 196.37,106.9 196.59,106.68 196.77,106.68 196.88,106.79 197.53,107.45 197.86,107.45 199.19,106.12 199.19,103.67 199.46,103.41 199.46,102.33 199.22,102.1 198.72,102.1 198.61,101.99 198.61,101.65 198.72,101.54 199.22,101.54 199.46,101.31 199.46,100.8 199.22,100.57 197.81,100.57 197.69,100.44 197.69,100.14 197.81,100.01 199.52,100.01 199.77,99.76 199.77,97.64 199.52,97.4 194.74,97.4 193.97,96.63 193.97,96.01 v3(194,95.98)
  BOTTOM w0.11: UV1.G36 v3(194,95.98)
FBB_WCK1_N: length 44
  TOP w0.14: v3(190.65,115.08) 190.69,115.12 190.69,115.41 190.63,115.47 189.59,115.47 187.87,117.18 187.15,117.18 UV8.P5
  IN4 w0.112: v3(193.2,95.98) 193.47,95.98 193.76,96.27 193.76,96.71 194.65,97.6 199.43,97.6 199.56,97.73 199.56,99.68 199.43,99.81 197.73,99.81 197.48,100.05 197.48,100.53 197.73,100.78 199.14,100.78 199.25,100.89 199.25,101.22 199.14,101.33 198.63,101.33 198.4,101.57 198.4,102.07 198.63,102.31 199.14,102.31 199.25,102.42 199.25,103.32 198.99,103.58 198.99,106.03 197.78,107.24 197.62,107.24 197.02,106.65 196.85,106.47 196.5,106.47 196.16,106.81 196.16,107.16 196.93,107.93 196.93,108.09 196.69,108.32 196.54,108.32 196.04,107.82 195.69,107.82 195.35,108.16 195.35,108.51 195.85,109.01 195.85,109.17 192.23,112.79 192.23,115 192.06,115.17 191.33,115.17 191.01,115.48 190.78,115.48 190.65,115.35 v3(190.65,115.08)
  BOTTOM w0.11: v3(193.2,95.98) 193.2,95.74 193.36,95.58 UV1.H36
FBB_WCK2: length 29.7
  IN2 w0.119: v3(190,99.98) 190.29,99.68 190.5,99.68 190.96,100.14 190.96,106 190.69,106.27 190.69,111.27 189.46,112.5 189.46,121.72 188.08,123.1 188.08,123.79 187.1,124.77 187.1,125.02 v3(186.65,125.48)
  BOTTOM w0.089: UV9.P4 v3(186.65,125.48)
  BOTTOM w0.11: v3(190,99.98) 190.28,99.98 190.4,100.1 UV1.M42
FBB_WCK2_N: length 29.7
  IN2 w0.119: v3(190,99.18) 190,99.2 190.28,99.47 190.59,99.47 191.17,100.05 191.17,106.09 190.9,106.35 190.9,111.35 189.67,112.59 189.67,121.8 188.31,123.17 188.31,123.89 187.33,124.87 187.33,125.36 v3(187.45,125.48)
  BOTTOM w0.089: UV9.P5 v3(187.45,125.48)
  BOTTOM w0.11: UV1.M41 v3(190,99.18)
FBB_WCK3: length 21.1
  IN1 w0.119: v3(186.65,116.68) 187.02,116.3 187.02,114.91 186.32,114.2 186.32,113.84 185.97,113.49 185.97,112.87 188.56,110.28 188.56,110.11 188.06,109.62 188.06,109.27 188.44,108.89 188.79,108.89 189.28,109.39 189.45,109.39 192.34,106.5 192.34,105.86 193.3,104.9 193.3,103.71 193.64,103.37 193.64,103.08 193.44,102.88 193.44,102.62 v3(193.2,102.38)
  BOTTOM w0.089: UV9.D4 v3(186.65,116.68)
  BOTTOM w0.11: UV1.H45 v3(193.2,102.38)
FBB_WCK3_N: length 21.2
  IN1 w0.119: v3(194,102.38) 193.74,102.38 193.65,102.47 193.65,102.8 193.85,102.99 193.85,103.46 193.51,103.8 193.51,104.98 192.55,105.94 192.55,106.59 189.54,109.6 189.19,109.6 188.7,109.1 188.53,109.1 188.28,109.36 188.28,109.53 188.77,110.02 188.77,110.36 186.18,112.95 186.18,113.4 186.53,113.75 186.53,114.11 187.23,114.82 187.23,116.47 v3(187.45,116.68)
  BOTTOM w0.089: UV9.D5 v3(187.45,116.68)
  BOTTOM w0.11: v3(194,102.38) UV1.H44
FBB_WE#_H: length 26.7
  IN1 w0.119: v3(199.72,108.76) 199.72,109.81 197.64,111.89 197.32,112.21 197.32,113.08 196.75,113.66 196.75,118.01 196.4,118.36 195.8,118.36 195.39,118.77 v3(195.33,118.77)
  BOTTOM w0.157: UV9.G12 193.04,119.87 194.69,119.87 195.33,119.23 v3(195.33,118.77) ; UV1.A42 199.35,100.53 199.4,100.53 200.72,101.84 200.97,101.84 v1(201.69,102.56) 202.3,103.17 202.3,106.26 199.8,108.76 v3(199.72,108.76)
FBB_WE#_L: length 41.7
  TOP w0.089: 195.21,120.14 195.04,119.97 193.2,119.97 192.7,119.48 UV8.L12
  TOP w0.157: 195.21,120.14 v3(195.32,120.26)
  IN1 w0.119: v3(204.85,98.26) 204.7,98.26 204.28,98.68 204.28,99.28 203.73,99.83 203.73,101.61 203.73,106.63 201.07,109.3 201.07,110.22 200.37,110.92 200.37,111.09 201,111.72 201,111.9 200.84,112.06 200.66,112.06 200.03,111.43 199.86,111.43 199.05,112.24 199.05,113.7 197.97,114.77 197.97,118.97 197.42,119.51 197.42,120.13 196.3,121.25 195.46,121.25 195.32,121.12 v3(195.32,120.26)
  BOTTOM w0.157: v3(204.85,98.26) v1(204.12,97.53) 202.38,95.79 200.84,95.79 199.45,94.39 198.79,94.39 UV1.B35
