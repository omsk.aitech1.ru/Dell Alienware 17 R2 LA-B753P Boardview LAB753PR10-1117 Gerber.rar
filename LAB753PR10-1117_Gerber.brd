# Allegro board LAB753PR10-1117_Gerber.brd (continued)
## Nets (continued)
GND: C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C27.2 C29.2 C256.2 C257.2 C258.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C2498.2 C2506.2 C2507.2 C2508.2 C2509.2 CA1.1 CA3.2 CA4.1 CA5.2 CA9.1 CA10.1 CA11.1 CA14.1 CA29.2 CA30.2 CA31.2 CA32.2 CA33.2 CA69.2 CA70.2 CA71.2 CA94.2 CA95.2 CA96.2 CA97.2 CA99.2 CA112.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CE1.2 CE2.2 CE3.2 CE4.1 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE22.2 CE23.2 CE24.2 CE25.2 CE26.2 CE27.2 CE28.2 CE29.2 CE30.2 CE31.1 CE32.1 CE34.2 CE36.2 CE37.2 CE38.2 CE40.1 CE41.2 CE42.2 CE43.2 CE44.2 CE45.2 CE46.2 CE48.2 CE50.2 CE51.2 CE52.2 CE53.2 CE55.1 CE56.2 CE57.2 CE58.2 CE59.2 CE60.2 CF4.2 CF5.2 CF6.2 CH1.1 CH2.1 CH3.1 CH4.1 CH5.2 CH6.2 CH7.2 CH8.1 CH9.1 CH10.2 CH11.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH28.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH100.2 CH101.2 CI1.2 CI2.2 CI4.2 CI5.2 CI10.2 CI11.2 CI24.2 CI25.2 CI26.2 CI27.2 CI28.2 CI29.2 CI40.2 CI41.2 CL3.2 CL4.2 CL5.2 CL6.2 CL7.2 CL8.1 CL9.1 CL11.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.2 CL23.2 CL24.2 CL25.2 CL27.2 CL28.2 CL29.2 CL30.1 CL31.2 CL32.1 CL33.2 CL34.1 CL35.2 CL36.1 CL37.2 CL38.1 CL39.2 CL40.2 CL41.2 CL42.2 CM9.2 CM10.1 CM11.1 CM12.2 CM13.2 CM14.2 CM15.2 CM16.2 CM17.2 CM18.2 CM19.2 CM20.2 CM21.2 CM23.2 CM24.1 CM25.1 CM26.2 CM27.2 CM28.1 CM29.2 CM30.2 CM31.2 CM32.2 CM33.2 CM34.2 CM35.2 CM36.2 CM70.2 CMOS1.1 CN1.2 CN2.2 CN3.2 CN4.2 CN6.2 CN7.2 CN8.2 CN17.2 CN18.2 CN19.2 CN20.2 CN21.2 CN22.2 CN23.2 CN24.2 CN25.2 CN26.2 CN35.2 CN36.2 CN37.2 CN38.2 CN39.2 CN40.2 CN41.2 CN42.2 CN51.2 CN52.2 CPU1.A8 CPU1.A11 CPU1.A15 CPU1.A19 CPU1.A22 CPU1.A26 CPU1.A30 CPU1.A33 CPU1.A37 CPU1.A40 CPU1.A44 CPU1.A49 CPU1.A50 CPU1.AA1 CPU1.AA2 CPU1.AA3 CPU1.AA4 CPU1.AA5 CPU1.AA7 CPU1.AA48 CPU1.AB5 CPU1.AB7 CPU1.AB9 CPU1.AB48 CPU1.AB50 CPU1.AB51 CPU1.AB52 CPU1.AB53 CPU1.AB54 CPU1.AC5 CPU1.AC7 CPU1.AC48 CPU1.AC50 CPU1.AD7 CPU1.AD9 CPU1.AD48 CPU1.AD50 CPU1.AD51 CPU1.AD54 CPU1.AE1 CPU1.AE2 CPU1.AE3 CPU1.AE4 CPU1.AE5 CPU1.AE7 CPU1.AE48 CPU1.AE50 CPU1.AF5 CPU1.AF6 CPU1.AF7 CPU1.AG5 CPU1.AG7 CPU1.AG9 CPU1.AG48 CPU1.AG50 CPU1.AG51 CPU1.AG52 CPU1.AG53 CPU1.AG54 CPU1.AH1 CPU1.AH2 CPU1.AH3 CPU1.AH4 CPU1.AH5 CPU1.AH7 CPU1.AH48 CPU1.AH50 CPU1.AJ48 CPU1.AJ49 CPU1.AJ50 CPU1.AJ51 CPU1.AJ54 CPU1.AK5 CPU1.AK7 CPU1.AK9 CPU1.AK48 CPU1.AK49 CPU1.AK50 CPU1.AL1 CPU1.AL4 CPU1.AL5 CPU1.AL7 CPU1.AL48 CPU1.AM5 CPU1.AM7 CPU1.AM50 CPU1.AM51 CPU1.AM52 CPU1.AM53 CPU1.AM54 CPU1.AN1 CPU1.AN2 CPU1.AN3 CPU1.AN4 CPU1.AN5 CPU1.AN7 CPU1.AN48 CPU1.AN49 CPU1.AN50 CPU1.AP7 CPU1.AP49 CPU1.AP50 CPU1.AP51 CPU1.AP54 CPU1.AR5 CPU1.AR7 CPU1.AR8 CPU1.AR9 CPU1.AR12 CPU1.AR14 CPU1.AR16 CPU1.AR18 CPU1.AR20 CPU1.AR22 CPU1.AR24 CPU1.AR26 CPU1.AR48 CPU1.AR50 CPU1.AT1 CPU1.AT4 CPU1.AT5 CPU1.AT6 CPU1.AT8 CPU1.AT9 CPU1.AT10 CPU1.AT12 CPU1.AT15 CPU1.AT16 CPU1.AT18 CPU1.AT20 CPU1.AT22 CPU1.AT25 CPU1.AT26 CPU1.AT29 CPU1.AT33 CPU1.AT35 CPU1.AT37 CPU1.AT39 CPU1.AT40 CPU1.AT42 CPU1.AT43 CPU1.AT45 CPU1.AT46 CPU1.AT47 CPU1.AT49 CPU1.AT50 CPU1.AT51 CPU1.AT52 CPU1.AT53 CPU1.AT54 CPU1.AU5 CPU1.AU9 CPU1.AU13 CPU1.AU18 CPU1.AU22 CPU1.AU25 CPU1.AU29 CPU1.AU30 CPU1.AU33 CPU1.AU37 CPU1.AU42 CPU1.AV1 CPU1.AV2 CPU1.AV3 CPU1.AV4 CPU1.AV5 CPU1.AV9 CPU1.AV13 CPU1.AV18 CPU1.AV22 CPU1.AV25 CPU1.AV29 CPU1.AV33 CPU1.AV42 CPU1.AV50 CPU1.AW5 CPU1.AW9 CPU1.AW13 CPU1.AW18 CPU1.AW37 CPU1.AW42 CPU1.AW43 CPU1.AW45 CPU1.AW46 CPU1.AW47 CPU1.AW49 CPU1.AW50 CPU1.AW51 CPU1.AW54 CPU1.AY9 CPU1.AY13 CPU1.AY22 CPU1.AY25 CPU1.AY29 CPU1.AY33 CPU1.AY37 CPU1.AY42 CPU1.AY50 CPU1.B4 CPU1.B8 CPU1.B11 CPU1.B15 CPU1.B19 CPU1.B22 CPU1.B26 CPU1.B30 CPU1.B33 CPU1.B37 CPU1.B40 CPU1.B44 CPU1.B49 CPU1.B51 CPU1.BA1 CPU1.BA4 CPU1.BA5 CPU1.BA9 CPU1.BA13 CPU1.BA18 CPU1.BA22 CPU1.BA25 CPU1.BA29 CPU1.BA33 CPU1.BA37 CPU1.BA42 CPU1.BA50 CPU1.BA51 CPU1.BA52 CPU1.BA53 CPU1.BA54 CPU1.BB1 CPU1.BB5 CPU1.BB6 CPU1.BB7 CPU1.BB9 CPU1.BB10 CPU1.BB11 CPU1.BB12 CPU1.BB14 CPU1.BB15 CPU1.BB16 CPU1.BB17 CPU1.BB18 CPU1.BB20 CPU1.BB23 CPU1.BB25 CPU1.BB28 CPU1.BB32 CPU1.BB33 CPU1.BB37 CPU1.BB38 CPU1.BB39 CPU1.BB41 CPU1.BB42 CPU1.BB43 CPU1.BB44 CPU1.BB46 CPU1.BB47 CPU1.BB48 CPU1.BB49 CPU1.BB54 CPU1.BC3 CPU1.BC5 CPU1.BC7 CPU1.BC10 CPU1.BC12 CPU1.BC15 CPU1.BC18 CPU1.BC21 CPU1.BC22 CPU1.BC26 CPU1.BC30 CPU1.BC33 CPU1.BC36 CPU1.BC38 CPU1.BC41 CPU1.BC43 CPU1.BC46 CPU1.BC48 CPU1.BC50 CPU1.BC52 CPU1.BD2 CPU1.BD5 CPU1.BD10 CPU1.BD15 CPU1.BD18 CPU1.BD36 CPU1.BD41 CPU1.BD46 CPU1.BD51 CPU1.BD53 CPU1.BE10 CPU1.BE15 CPU1.BE36 CPU1.BE41 CPU1.BE46 CPU1.BF5 CPU1.BF6 CPU1.BF7 CPU1.BF10 CPU1.BF12 CPU1.BF15 CPU1.BF18 CPU1.BF22 CPU1.BF26 CPU1.BF30 CPU1.BF33 CPU1.BF36 CPU1.BF38 CPU1.BF41 CPU1.BF43 CPU1.BF46 CPU1.BF48 CPU1.BF49 CPU1.BF50 CPU1.C4 CPU1.C8 CPU1.C11 CPU1.C15 CPU1.C19 CPU1.C22 CPU1.C26 CPU1.C30 CPU1.C33 CPU1.C37 CPU1.C40 CPU1.C44 CPU1.C49 CPU1.C52 CPU1.C53 CPU1.D2 CPU1.D8 CPU1.D11 CPU1.D15 CPU1.D19 CPU1.D22 CPU1.D26 CPU1.D30 CPU1.D33 CPU1.D37 CPU1.D40 CPU1.D44 CPU1.D49 CPU1.E8 CPU1.E11 CPU1.E15 CPU1.E16 CPU1.E17 CPU1.E19 CPU1.E20 CPU1.E21 CPU1.E22 CPU1.E24 CPU1.E25 CPU1.E26 CPU1.E30 CPU1.E33 CPU1.E37 CPU1.E40 CPU1.E44 CPU1.E49 CPU1.E51 CPU1.E52 CPU1.E53 CPU1.E54 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F5 CPU1.F26 CPU1.F30 CPU1.F33 CPU1.F37 CPU1.F40 CPU1.F44 CPU1.F49 CPU1.F51 CPU1.F52 CPU1.F54 CPU1.G1 CPU1.G7 CPU1.G8 CPU1.G9 CPU1.G11 CPU1.G13 CPU1.G16 CPU1.G18 CPU1.G19 CPU1.G20 CPU1.G23 CPU1.G25 CPU1.G26 CPU1.G30 CPU1.G33 CPU1.G37 CPU1.G40 CPU1.G44 CPU1.G49 CPU1.G52 CPU1.G54 CPU1.H7 CPU1.H44 CPU1.H49 CPU1.H51 CPU1.H52 CPU1.H53 CPU1.H54 CPU1.J7 CPU1.J44 CPU1.J49 CPU1.J51 CPU1.J54 CPU1.K1 CPU1.K2 CPU1.K3 CPU1.K4 CPU1.K5 CPU1.K6 CPU1.K7 CPU1.L7 CPU1.L9 CPU1.L48 CPU1.M7 CPU1.M48 CPU1.M50 CPU1.M52 CPU1.M54 CPU1.N7 CPU1.N48 CPU1.P1 CPU1.P2 CPU1.P3 CPU1.P4 CPU1.P5 CPU1.P6 CPU1.P7 CPU1.P9 CPU1.P48 CPU1.P50 CPU1.P52 CPU1.P54 CPU1.R7 CPU1.R48 CPU1.T48 CPU1.U1 CPU1.U2 CPU1.U3 CPU1.U4 CPU1.U5 CPU1.U6 CPU1.U7 CPU1.U48 CPU1.U50 CPU1.U52 CPU1.U54 CPU1.V7 CPU1.V9 CPU1.V48 CPU1.V50 CPU1.W7 CPU1.W48 CPU1.W50 CPU1.W52 CPU1.W54 CPU1.Y7 CPU1.Y9 CPU1.Y48 CR1.2 CR2.2 CR3.1 CR4.2 CR5.2 CR6.2 CR7.2 CR8.2 CR9.2 CR12.2 CR13.2 CR14.2 CT2.2 CT3.2 CT4.1 CT5.2 CT6.2 CT7.2 CT8.2 CU26.2 CU28.2 CU29.2 CV5.2 CV9.2 CV10.2 CV14.2 CV16.2 CV17.2 CV18.2 CV19.2 CV21.2 CV23.2 CV34.2 CV35.2 CV47.2 CV54.2 CV73.1 CV74.1 CV75.2 CV76.2 CV80.2 CV81.1 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.1 CV90.1 CV91.2 CV92.2 CV93.1 CV94.1 CV95.2 CV96.2 CV97.2 CV98.1 CV99.1 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV110.2 CV111.1 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV129.2 CV130.2 CV131.2 CV132.2 CV133.2 CV134.2 CV135.2 CV136.2 CV137.2 CV138.2 CV139.1 CV140.1 CV141.2 CV142.2 CV143.2 CV144.2 CV145.2 CV146.2 CV147.2 CV148.2 CV149.2 CV150.1 CV151.1 CV152.1 CV153.2 CV154.2 CV155.2 CV156.2 CV157.1 CV158.1 CV159.2 CV160.2 CV161.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV167.2 CV168.2 CV169.2 CV170.2 CV171.2 CV172.2 CV173.2 CV174.2 CV175.2 CV178.2 CV179.2 CV180.2 CV181.2 CV182.2 CV184.2 CV185.2 CV186.2 CV187.2 CV188.2 CV189.2 CV190.2 CV191.2 CV192.2 CV193.2 CV194.2 CV195.2 CV198.2 CV199.2 CV200.2 CV201.2 CV202.2 CV203.2 CV204.2 CV205.2 CV206.2 CV207.2 CV208.2 CV209.2 CV210.2 CV211.2 CV212.2 CV213.2 CV214.2 CV215.2 CV216.2 CV217.2 CV218.2 CV219.2 CV220.2 CV221.2 CV222.2 CV223.2 CV224.2 CV225.2 CV226.2 CV227.2 CV228.2 CV229.2 CV230.2 CV231.2 CV232.2 CV233.2 CV234.2 CV235.2 CV236.2 CV237.2 CV238.2 CV239.2 CV240.2 CV241.2 CV242.2 CV243.2 CV244.2 CV245.2 CV246.2 CV247.2 CV248.2 CV249.2 CV250.2 CV252.2 CV253.2 CV254.2 CV255.2 CV256.2 CV257.2 CV258.2 CV259.2 CV260.2 CV261.2 CV262.2 CV263.2 CV264.2 CV265.2 CV266.2 CV267.2 CV268.2 CV269.2 CV270.2 CV271.2 CV272.2 CV273.2 CV274.2 CV275.2 CV276.2 CV277.2 CV278.2 CV279.2 CV280.2 CV281.2 CV282.2 CV283.2 CV284.2 CV285.2 CV286.2 CV287.2 CV288.2 CV289.2 CV290.2 CV291.2 CV292.2 CV293.2 CV294.2 CV295.2 CV296.2 CV297.2 CV298.2 CV299.2 CV300.2 CV301.2 CV302.2 CV303.2 CV304.2 CV305.2 CV306.2 CV307.2 CV308.2 CV309.2 CV310.2 CV311.2 CV312.2 CV313.2 CV314.2 CV315.2 CV317.2 CV318.2 CV319.2 CV320.2 CV321.2 CV322.2 CV323.2 CV324.2 CV325.2 CV326.2 CV327.2 CV328.2 CV329.2 CV330.2 CV331.2 CV332.2 CV333.2 CV334.2 CV335.2 CV338.2 CV339.2 CV364.2 CV365.2 CV366.2 CV367.2 CV368.2 CV369.2 CV372.2 CV373.2 CV374.2 CV375.2 CV376.2 CV377.2 CV379.2 CV380.2 CV394.2 CV396.2 CV397.1 CV398.2 CV408.2 CV411.2 CV412.2 CV413.2 CV414.2 CV415.2 CV422.2 CV423.2 CV424.2 CV425.2 CV426.2 CV427.2 CV428.2 CV429.2 CV1025.2 CZ6.2 DE2.1 DI2.1 DI3.3 DI4.1 DI5.3 DV2.1 H2.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) JCDRA.5 JCDRA.8 JCDRA.11 JCDRA.14 JCDRA.17 JCDRA.20 JCDRA.23 JCDRA.29 JCDRA.32 JCDRA.35 JCDRA.38 JCDRA.41 JCDRA.44 JCDRA.47 JCDRA.48 JCDRA.49 JCDRA.50 JCR.2 JCR.9 JCR.16 JCR.17 JCR.21 JCR.23 JCR.24 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDP1.1 JDP1.7 JDP1.8 JDP1.13 JDP1.14 JDP1.19 JDP1.21 JDP1.22 JDP1.23 JDP1.24 JEDP1.3 JEDP1.6 JEDP1.9 JEDP1.12 JEDP1.15 JEDP1.20 JEDP1.21 JEDP1.22 JEDP1.31 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JELC1.4 JELC1.5 JELC1.6 JELC1.7 JELC1.8 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.11 JHDD1.13 JHDD1.17 JHDD1.19 JHDD1.20 JHDD1.21 JHDD1.22 JHDD1.23 JHDD1.24 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO.8 JIO.11 JIO.17 JIO.41 JIO.42 JIO.43 JIO.44 JKB1.1 JKB1.31 JKB1.32 JKB2.17 JKB2.18 JKB2.19 JKB2.20 JKB3.1 JKB3.7 JKB3.8 JKB3.9 JKB3.10 JKBBL1.1 JKBBL1.2 JKBBL1.21 JKBBL1.22 JLAN.14 JLAN.15 JLOGO1.7 JLOGO1.11 JLOGO1.12 JLOGO1.13 JLOGO1.14 JPWR1.20 JPWR1.23 JPWR1.31 JPWR1.32 JPWR1.33 JPWR1.34 JPWR1.35 JPWR1.36 JRTC1.2 JRTC1.3 JRTC1.4 JSPK.5 JSPK.6 JSSD1.3 JSSD1.5 JSSD1.11 JSSD1.13 JSSD1.19 JSSD1.25 JSSD1.31 JSSD1.37 JSSD1.43 JSSD1.49 JSSD1.63 JSSD1.65 JSSD1.67 JSSD1.68 JSSD1.69 JSSD2.3 JSSD2.5 JSSD2.11 JSSD2.13 JSSD2.19 JSSD2.25 JSSD2.31 JSSD2.37 JSSD2.43 JSSD2.49 JSSD2.63 JSSD2.65 JSSD2.67 JSSD2.68 JSSD2.69 JSSD3.3 JSSD3.5 JSSD3.11 JSSD3.13 JSSD3.19 JSSD3.25 JSSD3.31 JSSD3.37 JSSD3.43 JSSD3.49 JSSD3.63 JSSD3.65 JSSD3.67 JSSD3.68 JSSD3.69 JSSD4.3 JSSD4.5 JSSD4.11 JSSD4.13 JSSD4.19 JSSD4.25 JSSD4.31 JSSD4.37 JSSD4.43 JSSD4.49 JSSD4.63 JSSD4.65 JSSD4.67 JSSD4.68 JSSD4.69 JTRONF.9 JTRONF.10 JTRONF.11 JTRONF.12 JTRONF.13 JTRONF.14 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JWLAN1.1 JWLAN1.7 JWLAN1.18 JWLAN1.25 JWLAN1.31 JWLAN1.37 JWLAN1.43 JWLAN1.49 JWLAN1.55 JWLAN1.61 JWLAN1.67 JWLAN1.68 JWLAN1.69 LE2.1 PBATT1.8 PBATT1.10 PBATT1.11 PBATT1.12 PBATT1.13 PC1.2 PC2.2 PC3.2 PC4.2 PC6.2 PC7.2 PC8.2 PC9.2 PC11.2 PC12.2 PC13.1 PC15.2 PC16.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC200.2 PC201.2 PC202.2 PC203.2 PC205.2 PC206.2 PC207.1 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC316.2 PC317.2 PC318.2 PC405.2 PC406.2 PC408.2 PC409.2 PC500.1 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC509.1 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC518.2 PC525.1 PC526.1 PC527.1 PC530.2 PC531.2 PC533.2 PC534.2 PC535.2 PC536.2 PC537.2 PC541.1 PC546.1 PC547.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC606.2 PC607.2 PC608.2 PC609.2 PC613.2 PC614.2 PC615.2 PC616.2 PC617.2 PC618.2 PC621.2 PC622.2 PC626.2 PC627.2 PC628.2 PC629.2 PC634.2 PC652.2 PC655.2 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC662.2 PC666.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.1 PC709.2 PC710.2 PC711.1 PC712.2 PC713.2 PC714.2 PC715.2 PC716.1 PC718.1 PC719.2 PC720.1 PC721.2 PC724.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC927.2 PC928.2 PC929.2 PC930.2 PC931.2 PC932.2 PC933.2 PC934.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC945.2 PC946.2 PC947.2 PC948.2 PC949.2 PC950.2 PC951.2 PC952.2 PC953.2 PC954.2 PC955.2 PC956.2 PC957.2 PC958.2 PC959.2 PC960.2 PC961.2 PC962.2 PC963.2 PC964.2 PC965.2 PC966.2 PC967.2 PC968.2 PC969.2 PC970.2 PC971.2 PC972.2 PC973.2 PC974.2 PC975.2 PC976.2 PC977.2 PC978.2 PC979.2 PC980.2 PC981.2 PC982.2 PC983.2 PC984.2 PC985.2 PC986.2 PC987.2 PC988.2 PC989.2 PC990.2 PC991.2 PC992.2 PC993.2 PC994.2 PC995.2 PC996.2 PC997.2 PC998.2 PC999.2 PC1000.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PD1.1 PD2.1 PD3.1 PH500.2 PJPDC1.6 PJPDC1.7 PJPDC1.8 PJPDC1.9 PQ2.3 PQ4.3 PQ8.3 PQ101.1 PQ101.2 PQ101.3 PQ103.1 PQ103.2 PQ103.3 PQ201.1 PQ201.2 PQ201.3 PQ301.1 PQ301.2 PQ301.3 PQ302.1 PQ302.2 PQ302.3 PQ501.3 PQ501.4 PQ501.5 PQ502.3 PQ502.4 PQ502.5 PQ503.3 PQ503.4 PQ503.5 PQ504.3 PQ504.4 PQ504.5 PQ505.3 PQ505.4 PQ505.5 PQ506.3 PQ506.4 PQ506.5 PQ605.3 PQ605.4 PQ605.5 PQ606.3 PQ606.4 PQ606.5 PQ607.3 PQ607.4 PQ607.5 PQ608.3 PQ608.4 PQ608.5 PQ609.3 PQ609.4 PQ609.5 PQ610.3 PQ611.3 PQ611.4 PQ611.5 PQ706.1 PQ706.2 PQ706.3 PQ710.1 PQ710.4 PR9.1 PR26.1 PR28.1 PR103.1 PR104.2 PR105.1 PR106.1 PR107.2 PR116.2 PR207.2 PR303.1 PR306.2 PR308.2 PR310.2 PR311.2 PR312.1 PR403.2 PR406.2 PR507.1 PR509.1 PR512.1 PR513.2 PR521.2 PR528.2 PR529.1 PR541.2 PR554.2 PR558.1 PR602.2 PR618.2 PR624.1 PR631.2 PR649.1 PR685.2 PR700.1 PR711.2 PR715.2 PR719.2 PR730.1 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU301.11 PU401.4 PU401.9 PU500.33 PU501.4 PU501.9 PU600.25 PU601.6 PU601.9 PU602.11 PU700.22 PU700.29 Q28.1 Q28.4 Q29.1 Q29.4 Q30.1 Q30.4 Q31.1 Q31.4 Q32.1 Q32.4 Q33.1 Q33.4 Q34.1 Q34.4 Q35.1 Q35.4 Q36.1 Q36.4 Q37.1 Q37.4 Q38.1 Q38.4 Q39.1 Q39.4 Q40.3 Q41.3 Q2410.3 Q2411.1 Q2411.4 Q2412.1 Q2412.4 Q2413.1 Q2413.4 QA14.1 QA14.4 QC1.3 QE1.3 QE3.3 QE4.3 QE6.3 QE7.3 QE9.3 QE10.3 QE12.1 QE14.3 QL3.3 QM2.1 QM2.4 QV2.3 QV21.3 QV23.3 QV24.3 QV25.3 R3.2 R176.2 R180.2 RA53.1 RA55.1 RA57.1 RA80.2 RA85.2 RA86.2 RA87.2 RA111.1 RA112.2 RA129.1 RA130.1 RA131.1 RA132.1 RA133.1 RC18.1 RC21.2 RC22.2 RC23.2 RC30.2 RC35.2 RC36.1 RC37.2 RC38.1 RC39.1 RC40.1 RC41.1 RC42.1 RC43.1 RC52.1 RC55.2 RD3.1 RD4.2 RD7.1 RD8.1 RD9.1 RD10.2 RD13.1 RD14.2 RD16.1 RE27.2 RE29.2 RE30.2 RE31.2 RE33.2 RE34.2 RE36.2 RE37.2 RE41.2 RE42.2 RE44.2 RE66.1 RE72.1 RE75.2 RE80.2 RE81.2 RE82.1 RE83.2 RH4.2 RH18.2 RH20.1 RH24.2 RH25.2 RH26.2 RH27.2 RH38.1 RH39.1 RH51.2 RH54.1 RH57.1 RH67.1 RH69.2 RH70.1 RH71.2 RH79.2 RH103.2 RH109.2 RH122.2 RH132.2 RH133.2 RH135.1 RH138.2 RH139.2 RH155.2 RH158.2 RH161.2 RL3.2 RL4.1 RM6.1 RM17.1 RM21.1 RM23.1 RM25.1 RM29.2 RM31.2 RM38.2 RM42.2 RM62.1 RM64.2 RM65.1 RM69.1 RM70.1 RM72.1 RM73.2 RM75.1 RM78.1 RM82.1 RM84.1 RM87.2 RM88.1 RN16.1 RN17.2 RN18.2 RN19.2 RN20.2 RN21.2 RN22.2 RN23.2 RN30.1 RN31.1 RN34.1 RN35.1 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH2.5 RPH2.6 RR2.1 RV1.2 RV8.2 RV14.2 RV16.2 RV17.2 RV18.1 RV36.2 RV37.2 RV38.1 RV41.1 RV49.2 RV51.2 RV57.1 RV58.1 RV59.2 RV66.2 RV67.2 RV68.1 RV69.2 RV78.1 RV79.1 RV107.2 RV108.2 RV111.2 RV112.2 RV115.2 RV116.2 RV118.2 RV119.2 RV120.2 RV121.2 RV125.2 RV132.2 RV133.2 RV134.2 RV135.2 RV136.2 RV140.2 RV145.2 RV146.2 RV149.2 RV151.2 RV153.2 RV156.2 RV158.2 RV159.2 RV160.2 RV161.2 RV166.2 RV171.2 RV185.2 RV187.2 RV188.2 RV190.2 RV196.2 RV198.2 RV202.2 RV204.2 RV209.2 RV213.2 RV215.1 RV216.1 RV221.1 RV223.1 RV224.1 RV226.1 RV228.1 RV232.1 RV241.1 RV293.1 RV295.2 RV297.2 RV299.2 RV301.2 RV305.2 RV510.2 RV511.2 RV512.2 RV513.2 RV533.1 RV546.2 SW1.1 SW1.2 SW1.5 SW1.6 SW2.1 SW2.2 SW2.5 SW2.6 U17.11 U17.15 U18.11 U18.15 U2407.6 U2410.5 UA1.1 UA1.8 UA1.13 UA1.14 UA1.17 UA1.18 UA1.21 UA1.49 UA1.57 UA4.4 UA4.17 UA4.20 UA4.21 UA4.24 UA4.33 UA5.4 UA5.9 UC1.3 UE1.3 UE2.4 UE3.7 UE3.18 UE3.23 UE3.33 UE4.7 UE4.18 UE4.23 UE4.33 UE5.11 UE5.24 UE5.35 UE5.94 UE5.113 UE6.12 UE6.25 UE7.3 UE8.7 UE8.18 UE8.23 UE8.33 UE9.2 UH1.A2 UH1.A4 UH1.A5 UH1.A41 UH1.A43 UH1.A44 UH1.AA4 UH1.AA16 UH1.AA20 UH1.AA22 UH1.AA28 UH1.AB8 UH1.AB12 UH1.AB34 UH1.AB38 UH1.AC2 UH1.AC44 UH1.AD6 UH1.AD8 UH1.AD14 UH1.AD16 UH1.AD18 UH1.AD30 UH1.AD32 UH1.AD40 UH1.AE16 UH1.AE28 UH1.AF8 UH1.AF38 UH1.AG2 UH1.AG16 UH1.AG26 UH1.AG28 UH1.AG44 UH1.AJ6 UH1.AJ8 UH1.AJ16 UH1.AJ18 UH1.AJ20 UH1.AJ22 UH1.AJ24 UH1.AJ34 UH1.AJ38 UH1.AK14 UH1.AK16 UH1.AK24 UH1.AK43 UH1.AK45 UH1.AL2 UH1.AL8 UH1.AL12 UH1.AL34 UH1.AL38 UH1.AM14 UH1.AM16 UH1.AM24 UH1.AM26 UH1.AM28 UH1.AM30 UH1.AM32 UH1.AN8 UH1.AN36 UH1.AN40 UH1.AN42 UH1.AP13 UH1.AP24 UH1.AP31 UH1.AP43 UH1.AR2 UH1.AT10 UH1.AT15 UH1.AT17 UH1.AT20 UH1.AT26 UH1.AT29 UH1.AT36 UH1.AT38 UH1.AT43 UH1.AV6 UH1.AV7 UH1.AV13 UH1.AV22 UH1.AV24 UH1.AV31 UH1.AV33 UH1.AV40 UH1.AW2 UH1.AY7 UH1.AY10 UH1.AY15 UH1.AY20 UH1.AY26 UH1.AY29 UH1.AY36 UH1.B1 UH1.B2 UH1.B7 UH1.B11 UH1.B15 UH1.B19 UH1.B23 UH1.B27 UH1.B31 UH1.B35 UH1.B39 UH1.B44 UH1.B45 UH1.BA1 UH1.BA40 UH1.BB25 UH1.BB42 UH1.BC1 UH1.BC16 UH1.BC22 UH1.BC28 UH1.BD1 UH1.BD2 UH1.BD7 UH1.BD11 UH1.BD15 UH1.BD19 UH1.BD31 UH1.BD35 UH1.BD39 UH1.BD44 UH1.BD45 UH1.BE2 UH1.BE3 UH1.BE5 UH1.BE41 UH1.C45 UH1.D1 UH1.D4 UH1.D25 UH1.D42 UH1.E1 UH1.E45 UH1.F15 UH1.F20 UH1.F29 UH1.F33 UH1.F43 UH1.G2 UH1.G8 UH1.G38 UH1.G44 UH1.H7 UH1.H10 UH1.H13 UH1.H17 UH1.H22 UH1.H24 UH1.H26 UH1.H31 UH1.H36 UH1.H40 UH1.K10 UH1.K15 UH1.K20 UH1.K29 UH1.K33 UH1.K39 UH1.L2 UH1.L44 UH1.M17 UH1.M22 UH1.M24 UH1.M31 UH1.N6 UH1.N10 UH1.N12 UH1.N35 UH1.N39 UH1.P22 UH1.P24 UH1.P26 UH1.P28 UH1.P30 UH1.P32 UH1.P43 UH1.P45 UH1.R2 UH1.R8 UH1.R12 UH1.R14 UH1.R16 UH1.R34 UH1.R38 UH1.R44 UH1.T43 UH1.U6 UH1.U10 UH1.U16 UH1.U28 UH1.U34 UH1.U38 UH1.U39 UH1.U42 UH1.V14 UH1.V16 UH1.V26 UH1.V43 UH1.W2 UH1.W44 UH1.Y8 UH1.Y14 UH1.Y16 UH1.Y24 UH1.Y28 UH1.Y34 UH1.Y36 UH1.Y40 UH2.3 UH3.3 UH4.4 UH5.1 UI2.2 UI3.2 UL1.27 UL1.41 UL2.2 UM1.2 UM3.3 UM4.6 UM4.15 UM4.19 UM7.3 UM8.25 UM8.55 UN1.3 UN1.13 UN1.21 UN2.5 UN2.10 UN2.12 UN2.13 UN2.15 UN2.16 UR1.33 UT2.4 UT2.8 UT2.11 UT2.18 UT2.25 UU5.3 UV1.A2 UV1.A3 UV1.A47 UV1.A48 UV1.AA15 UV1.AA17 UV1.AA19 UV1.AA21 UV1.AA23 UV1.AA25 UV1.AA27 UV1.AA29 UV1.AA31 UV1.AB2 UV1.AB4 UV1.AB5 UV1.AB8 UV1.AB9 UV1.AB11 UV1.AB14 UV1.AB16 UV1.AB18 UV1.AB20 UV1.AB22 UV1.AB24 UV1.AB26 UV1.AB28 UV1.AB30 UV1.AB32 UV1.AB39 UV1.AB41 UV1.AB42 UV1.AB45 UV1.AB46 UV1.AB48 UV1.AC15 UV1.AC17 UV1.AC19 UV1.AC21 UV1.AC23 UV1.AC25 UV1.AC27 UV1.AC29 UV1.AC31 UV1.AD14 UV1.AD16 UV1.AD18 UV1.AD20 UV1.AD22 UV1.AD24 UV1.AD26 UV1.AD28 UV1.AD30 UV1.AD32 UV1.AE2 UV1.AE4 UV1.AE5 UV1.AE8 UV1.AE9 UV1.AE11 UV1.AE15 UV1.AE17 UV1.AE19 UV1.AE21 UV1.AE23 UV1.AE25 UV1.AE27 UV1.AE29 UV1.AE31 UV1.AE39 UV1.AE41 UV1.AE42 UV1.AE45 UV1.AE46 UV1.AE48 UV1.AF14 UV1.AF16 UV1.AF18 UV1.AF20 UV1.AF22 UV1.AF24 UV1.AF26 UV1.AF28 UV1.AF30 UV1.AF32 UV1.AG15 UV1.AG17 UV1.AG19 UV1.AG21 UV1.AG23 UV1.AG25 UV1.AG27 UV1.AG29 UV1.AG31 UV1.AH2 UV1.AH4 UV1.AH5 UV1.AH8 UV1.AH9 UV1.AH11 UV1.AH14 UV1.AH16 UV1.AH18 UV1.AH20 UV1.AH22 UV1.AH24 UV1.AH26 UV1.AH28 UV1.AH30 UV1.AH32 UV1.AH39 UV1.AH41 UV1.AH42 UV1.AH45 UV1.AH46 UV1.AH48 UV1.AJ15 UV1.AJ17 UV1.AJ19 UV1.AJ21 UV1.AJ23 UV1.AJ25 UV1.AJ27 UV1.AJ29 UV1.AJ31 UV1.AK14 UV1.AK16 UV1.AK18 UV1.AK20 UV1.AK22 UV1.AK24 UV1.AK26 UV1.AK28 UV1.AK30 UV1.AK32 UV1.AL2 UV1.AL4 UV1.AL5 UV1.AL8 UV1.AL9 UV1.AL11 UV1.AL15 UV1.AL17 UV1.AL19 UV1.AL21 UV1.AL23 UV1.AL25 UV1.AL27 UV1.AL29 UV1.AL31 UV1.AL39 UV1.AL41 UV1.AL42 UV1.AL45 UV1.AL46 UV1.AL48 UV1.AM14 UV1.AM16 UV1.AM18 UV1.AM20 UV1.AM22 UV1.AM24 UV1.AM26 UV1.AM28 UV1.AM30 UV1.AP2 UV1.AP4 UV1.AP5 UV1.AP8 UV1.AP9 UV1.AP11 UV1.AP41 UV1.AP42 UV1.AP45 UV1.AP46 UV1.AP48 UV1.AT42 UV1.AU2 UV1.AU4 UV1.AU5 UV1.AU8 UV1.AU9 UV1.AU11 UV1.AU45 UV1.AU46 UV1.AU48 UV1.AW13 UV1.AW16 UV1.AW19 UV1.AW22 UV1.AW24 UV1.AW25 UV1.AW29 UV1.AW31 UV1.AW34 UV1.AY2 UV1.AY4 UV1.AY5 UV1.AY8 UV1.AY46 UV1.AY48 UV1.B1 UV1.B2 UV1.B7 UV1.B10 UV1.B13 UV1.B16 UV1.B19 UV1.B22 UV1.B25 UV1.B28 UV1.B31 UV1.B34 UV1.B37 UV1.B40 UV1.B43 UV1.B45 UV1.B48 UV1.B49 UV1.BA13 UV1.BA16 UV1.BA19 UV1.BA22 UV1.BA25 UV1.BA28 UV1.BA31 UV1.BA34 UV1.BB8 UV1.BB10 UV1.BB13 UV1.BB16 UV1.BB19 UV1.BB21 UV1.BB22 UV1.BB23 UV1.BB25 UV1.BB26 UV1.BB28 UV1.BB29 UV1.BB31 UV1.BB32 UV1.BB34 UV1.BB35 UV1.BB36 UV1.BC2 UV1.BC4 UV1.BC5 UV1.BC48 UV1.BE2 UV1.BE4 UV1.BE7 UV1.BE10 UV1.BE13 UV1.BE16 UV1.BE19 UV1.BE21 UV1.BE24 UV1.BE27 UV1.BE30 UV1.BE33 UV1.BE36 UV1.BE37 UV1.BF5 UV1.BF7 UV1.BF10 UV1.BF13 UV1.BF16 UV1.BF19 UV1.BF22 UV1.BF23 UV1.BF24 UV1.BF25 UV1.BF26 UV1.BF27 UV1.BF28 UV1.BF29 UV1.BF30 UV1.BF31 UV1.BF32 UV1.BF33 UV1.BF34 UV1.BF35 UV1.BF36 UV1.BF37 UV1.BG1 UV1.BH1 UV1.BH2 UV1.BH5 UV1.BH7 UV1.BH10 UV1.BH13 UV1.BH16 UV1.BH19 UV1.BH22 UV1.BH25 UV1.BH28 UV1.BH31 UV1.BH34 UV1.BH37 UV1.BJ2 UV1.BJ3 UV1.C1 UV1.C3 UV1.C49 UV1.D4 UV1.D7 UV1.D10 UV1.D13 UV1.D16 UV1.D19 UV1.D22 UV1.D25 UV1.D28 UV1.D31 UV1.D34 UV1.D37 UV1.D40 UV1.D43 UV1.E5 UV1.E7 UV1.E10 UV1.E13 UV1.E16 UV1.E19 UV1.E22 UV1.E25 UV1.E28 UV1.E31 UV1.E34 UV1.E37 UV1.E40 UV1.E43 UV1.E46 UV1.E48 UV1.F6 UV1.G2 UV1.G4 UV1.G5 UV1.G45 UV1.G46 UV1.G48 UV1.H8 UV1.H10 UV1.H13 UV1.H16 UV1.H19 UV1.H22 UV1.H25 UV1.H28 UV1.H31 UV1.H34 UV1.H37 UV1.H40 UV1.J13 UV1.J16 UV1.J19 UV1.J22 UV1.J25 UV1.J28 UV1.J31 UV1.J34 UV1.J37 UV1.K2 UV1.K4 UV1.K5 UV1.K8 UV1.K42 UV1.K45 UV1.K46 UV1.K48 UV1.L13 UV1.L16 UV1.L19 UV1.L22 UV1.L25 UV1.L28 UV1.L31 UV1.L34 UV1.L37 UV1.N2 UV1.N4 UV1.N5 UV1.N8 UV1.N9 UV1.N11 UV1.N39 UV1.N41 UV1.N42 UV1.N45 UV1.N46 UV1.N48 UV1.P14 UV1.P16 UV1.P18 UV1.P20 UV1.P22 UV1.P24 UV1.P26 UV1.P28 UV1.P30 UV1.P32 UV1.R15 UV1.R17 UV1.R19 UV1.R21 UV1.R23 UV1.R25 UV1.R27 UV1.R29 UV1.R31 UV1.T2 UV1.T4 UV1.T5 UV1.T8 UV1.T9 UV1.T11 UV1.T14 UV1.T16 UV1.T18 UV1.T20 UV1.T22 UV1.T24 UV1.T26 UV1.T28 UV1.T30 UV1.T32 UV1.T39 UV1.T41 UV1.T42 UV1.T45 UV1.T46 UV1.T48 UV1.U15 UV1.U17 UV1.U19 UV1.U21 UV1.U23 UV1.U25 UV1.U27 UV1.U29 UV1.U31 UV1.V14 UV1.V16 UV1.V18 UV1.V20 UV1.V22 UV1.V24 UV1.V26 UV1.V28 UV1.V30 UV1.V32 UV1.W2 UV1.W4 UV1.W5 UV1.W8 UV1.W9 UV1.W11 UV1.W15 UV1.W17 UV1.W19 UV1.W21 UV1.W23 UV1.W25 UV1.W27 UV1.W29 UV1.W31 UV1.W39 UV1.W41 UV1.W42 UV1.W45 UV1.W46 UV1.W48 UV1.Y14 UV1.Y16 UV1.Y18 UV1.Y20 UV1.Y22 UV1.Y24 UV1.Y26 UV1.Y28 UV1.Y30 UV1.Y32 UV2.2 UV3.8 UV3.15 UV4.15 UV4.35 UV4.41 UV5.2 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV7.A1 UV7.A3 UV7.A12 UV7.A14 UV7.B5 UV7.B10 UV7.C1 UV7.C3 UV7.C4 UV7.C11 UV7.C12 UV7.C14 UV7.D10 UV7.E1 UV7.E3 UV7.E12 UV7.E14 UV7.F5 UV7.F10 UV7.G5 UV7.G10 UV7.H1 UV7.H2 UV7.H13 UV7.H14 UV7.K1 UV7.K2 UV7.K13 UV7.K14 UV7.L5 UV7.L10 UV7.M5 UV7.M10 UV7.N1 UV7.N3 UV7.N12 UV7.N14 UV7.P10 UV7.R1 UV7.R3 UV7.R4 UV7.R11 UV7.R12 UV7.R14 UV7.T5 UV7.T10 UV7.U1 UV7.U3 UV7.U12 UV7.U14 UV8.A1 UV8.A3 UV8.A12 UV8.A14 UV8.B5 UV8.B10 UV8.C1 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.C14 UV8.D10 UV8.E1 UV8.E3 UV8.E12 UV8.E14 UV8.F5 UV8.F10 UV8.G5 UV8.G10 UV8.H1 UV8.H2 UV8.H13 UV8.H14 UV8.K1 UV8.K2 UV8.K13 UV8.K14 UV8.L5 UV8.L10 UV8.M5 UV8.M10 UV8.N1 UV8.N3 UV8.N12 UV8.N14 UV8.P10 UV8.R1 UV8.R3 UV8.R4 UV8.R11 UV8.R12 UV8.R14 UV8.T5 UV8.T10 UV8.U1 UV8.U3 UV8.U12 UV8.U14 UV9.A1 UV9.A3 UV9.A12 UV9.A14 UV9.B5 UV9.B10 UV9.C1 UV9.C3 UV9.C4 UV9.C11 UV9.C12 UV9.C14 UV9.D10 UV9.E1 UV9.E3 UV9.E12 UV9.E14 UV9.F5 UV9.F10 UV9.G5 UV9.G10 UV9.H1 UV9.H2 UV9.H13 UV9.H14 UV9.K1 UV9.K2 UV9.K13 UV9.K14 UV9.L5 UV9.L10 UV9.M5 UV9.M10 UV9.N1 UV9.N3 UV9.N12 UV9.N14 UV9.P10 UV9.R1 UV9.R3 UV9.R4 UV9.R11 UV9.R12 UV9.R14 UV9.T5 UV9.T10 UV9.U1 UV9.U3 UV9.U12 UV9.U14 UV10.4 UV11.11 UV11.15 UV12.A1 UV12.A3 UV12.A12 UV12.A14 UV12.B5 UV12.B10 UV12.C1 UV12.C3 UV12.C4 UV12.C11 UV12.C12 UV12.C14 UV12.D10 UV12.E1 UV12.E3 UV12.E12 UV12.E14 UV12.F5 UV12.F10 UV12.G5 UV12.G10 UV12.H1 UV12.H2 UV12.H13 UV12.H14 UV12.K1 UV12.K2 UV12.K13 UV12.K14 UV12.L5 UV12.L10 UV12.M5 UV12.M10 UV12.N1 UV12.N3 UV12.N12 UV12.N14 UV12.P10 UV12.R1 UV12.R3 UV12.R4 UV12.R11 UV12.R12 UV12.R14 UV12.T5 UV12.T10 UV12.U1 UV12.U3 UV12.U12 UV12.U14 UV13.A1 UV13.A3 UV13.A12 UV13.A14 UV13.B5 UV13.B10 UV13.C1 UV13.C3 UV13.C4 UV13.C11 UV13.C12 UV13.C14 UV13.D10 UV13.E1 UV13.E3 UV13.E12 UV13.E14 UV13.F5 UV13.F10 UV13.G5 UV13.G10 UV13.H1 UV13.H2 UV13.H13 UV13.H14 UV13.K1 UV13.K2 UV13.K13 UV13.K14 UV13.L5 UV13.L10 UV13.M5 UV13.M10 UV13.N1 UV13.N3 UV13.N12 UV13.N14 UV13.P10 UV13.R1 UV13.R3 UV13.R4 UV13.R11 UV13.R12 UV13.R14 UV13.T5 UV13.T10 UV13.U1 UV13.U3 UV13.U12 UV13.U14 UV14.3 UV15.A1 UV15.A3 UV15.A12 UV15.A14 UV15.B5 UV15.B10 UV15.C1 UV15.C3 UV15.C4 UV15.C11 UV15.C12 UV15.C14 UV15.D10 UV15.E1 UV15.E3 UV15.E12 UV15.E14 UV15.F5 UV15.F10 UV15.G5 UV15.G10 UV15.H1 UV15.H2 UV15.H13 UV15.H14 UV15.K1 UV15.K2 UV15.K13 UV15.K14 UV15.L5 UV15.L10 UV15.M5 UV15.M10 UV15.N1 UV15.N3 UV15.N12 UV15.N14 UV15.P10 UV15.R1 UV15.R3 UV15.R4 UV15.R11 UV15.R12 UV15.R14 UV15.T5 UV15.T10 UV15.U1 UV15.U3 UV15.U12 UV15.U14 UV16.A1 UV16.A3 UV16.A12 UV16.A14 UV16.B5 UV16.B10 UV16.C1 UV16.C3 UV16.C4 UV16.C11 UV16.C12 UV16.C14 UV16.D10 UV16.E1 UV16.E3 UV16.E12 UV16.E14 UV16.F5 UV16.F10 UV16.G5 UV16.G10 UV16.H1 UV16.H2 UV16.H13 UV16.H14 UV16.K1 UV16.K2 UV16.K13 UV16.K14 UV16.L5 UV16.L10 UV16.M5 UV16.M10 UV16.N1 UV16.N3 UV16.N12 UV16.N14 UV16.P10 UV16.R1 UV16.R3 UV16.R4 UV16.R11 UV16.R12 UV16.R14 UV16.T5 UV16.T10 UV16.U1 UV16.U3 UV16.U12 UV16.U14 UV17.2 UV18.2 UV19.3 UV20.3 UV22.5 YH2.2 YH2.4 YL1.2 YL1.4 YV1.2 YV1.4
V1N: PL503.2 PR516.1 PR546.2 PR556.1
V2N: PL502.2 PR518.1 PR544.1 PR555.2
V3N: PL501.2 PR515.2 PR547.2 PR557.2
VCC_PGOOD: PR522.2 PU500.3
VCCSENSE: PC520.1 PC541.2 PC545.1 PR537.1 RC44.2 RC45.2
VCCSENSE_R: CPU1.C50 RC45.1
VCCSENSE_VGA: PR627.1 RV532.1 UV1.AY23
VDD_1.35V: PC212.1 PR201.1 PR203.2 PU200.11
VDD_SW: CA4.2 CA5.1 LA9.2 UA1.10 UA1.11
VDDQ_PLL: CA3.1 LA10.2 UA1.16 UA1.19
VIN: PC3.1 PC4.1 PC722.1 PC723.1 PD101.2 PD700.3 PL1.2 PL3.2 PQ700.1 PQ701.5 PQ707.5 PR716.1 PR729.2 PR732.1
VIN1N: CV409.1 RV542.2 UV20.11
VIN1P: CV409.2 RV540.2 UV20.12
VIN2N: CV410.1 RV544.2 UV20.14
VIN2P: CV410.2 RV543.2 UV20.15
VSSSENSE: PC545.2 PC546.2 PU500.13 R3.1 RC46.2
VSSSENSE_R: CPU1.D50 RC46.1
VSSSENSE_VGA: PR622.1 RV533.2 UV1.AW23
+EC_VCCA: CE33.1 LE1.2 UE5.67
+FB_PLLAVDD: CV148.1 CV364.1 CV365.1 CV366.1 CV367.1 LV14.1 UV1.AA11 UV1.AJ39 UV1.L26 UV1.L36
+FBA_VREFC: CV301.1 CV303.1 RV189.2 RV194.2 RV196.1 UV6.J14 UV7.J14
+FBA_VREFD: CV302.1 CV304.1 RV190.1 RV193.2 RV195.2 UV6.A10 UV6.U10 UV7.A10 UV7.U10
+FBB_VREFC: CV305.1 CV307.1 RV197.2 RV200.2 RV202.1 UV8.J14 UV9.J14
+FBB_VREFD: CV306.1 CV308.1 RV198.1 RV199.2 RV201.2 UV8.A10 UV8.U10 UV9.A10 UV9.U10
+FBC_VREFC: CV179.1 CV300.1 RV143.2 RV145.1 RV164.2 UV12.J14 UV13.J14
+FBC_VREFD: CV178.1 CV299.1 RV142.2 RV144.2 RV158.1 UV12.A10 UV12.U10 UV13.A10 UV13.U10
+FBD_VREFC: CV309.1 CV311.1 RV203.2 RV206.2 RV209.1 UV15.J14 UV16.J14
+FBD_VREFD: CV310.1 CV312.1 RV205.2 RV207.2 RV213.1 UV15.A10 UV15.U10 UV16.A10 UV16.U10
+GVDD: CA100.1 RA91.1 RA113.1 UA4.2
+HDMI_5V_OUT: CV47.1 JHDMI1.18 UV5.3
+INV_PWR_SRC: CV14.1 CV375.1 JEDP1.38 JEDP1.39 JEDP1.40 QV1.1 QV1.2 QV1.5 QV1.6
+LAN_IO: CL11.1 CL12.1 CL13.1 CL14.1 CL15.1 CL16.1 CL17.1 LL1.1 RL1.1 RL2.1 RL8.2 RL14.1 UL1.1 UL1.16 UL2.1
+LCDVDD: LV8.1 UV17.1
+LCDVDD_CONN: CV9.1 CV10.1 CV17.1 CV18.1 CV373.1 JEDP1.25 JEDP1.26 LV8.2
+PAVDD: CA98.1 RA109.1 UA4.12
+PCH_DCPRTC: CH49.1 UH1.P14 UH1.P16
+PCH_USB_DCPSUS2: CH53.1 RH142.2 UH1.Y35
+PCH_VCC: CH70.1 CH71.1 RH150.2 UH1.AP45
+PCH_VCCCFUSE: CH65.1 RH143.2 RH148.1 UH1.P18 UH1.P20
+PCH_VCCCLK: CH59.1 CH60.1 CH61.1 CH62.1 CH63.1 CH64.1 RH147.2 UH1.AA30 UH1.AA32 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AE30 UH1.AE32 UH1.AG30 UH1.AG32 UH1.Y32
+PCH_VCCCLK3_3: CH66.1 CH67.1 CH68.1 CH69.1 RH149.2 UH1.L26 UH1.L29 UH1.M26 UH1.M29 UH1.U32 UH1.V32
+PCH_VCCDSW: RH140.2 UH1.U14
+PCH_VCCDSW3_3: CH38.1 RH36.1 RH58.1 RH141.2 RH145.2 RH152.2 RH156.2 UH1.A16
+PCH_VCCDSW_R: CH37.1 RH140.1
+PCH_VCCSST: CH42.1 UH1.AA14
+PCH_VPROC: CH55.1 CH56.1 CH57.1 RH146.1 UH1.AJ12 UH1.AJ14
+RBIAS: RL3.1 UL1.10
+RTC_CELL: CH50.1 CH51.1 CH52.1 PD5.1 RA123.1 RH3.1 RH12.1 RH13.1 RH15.1 RH65.2 UH1.A6
+SA_DIMM_VREFDQ: C9.1 CPU1.AR6 RD6.1
+SB_DIMM_VREFDQ: CD38.1 CPU1.AN6 RD12.1
+SM_VREF: CD21.1 CPU1.AM6 RD2.1
+USB3_VCCA: CI10.1 CI11.1 CI40.1 JUSB1.1 UI2.1
+USB3_VCCB: CI24.1 CI25.1 CI41.1 JUSB2.1 UI3.1
+V_TP: RT4.2 RT5.2 RT6.1 UT1.5
+VCOMP_OUT: CPU1.AK6 RC1.1 RC32.1
+VGA_CORE: CV150.2 CV151.2 CV152.2 CV157.2 CV158.2 CV159.1 CV317.1 CV318.1 CV319.1 CV320.1 CV321.1 CV322.1 CV323.1 CV324.1 CV325.1 CV326.1 CV327.1 CV328.1 CV329.1 CV330.1 CV331.1 CV332.1 CV333.1 CV334.1 CV335.1 CV379.1 CV380.1 CV411.1 CV412.1 CV413.1 CV414.1 CV415.1 CV1025.1 PC904.1 PC907.1 PC908.1 PC909.1 PC927.1 PC928.1 PC929.1 PC930.1 PC931.1 PC932.1 PC933.1 PC934.1 PC944.1 PC945.1 PC946.1 PC947.1 PC948.1 PC949.1 PC950.1 PC951.1 PC952.1 PC953.1 PC954.1 PC955.1 PC956.1 PC957.1 PC958.1 PC959.1 PC960.1 PC961.1 PC962.1 PC963.1 PC964.1 PC965.1 PC966.1 PC967.1 PC968.1 PC969.1 PC970.1 PC999.1 PC1000.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PL601.1 PL602.1 PL603.1 PR629.1 RV532.2 UV1.AA14 UV1.AA16 UV1.AA18 UV1.AA20 UV1.AA22 UV1.AA24 UV1.AA26 UV1.AA28 UV1.AA30 UV1.AA32 UV1.AB15 UV1.AB17 UV1.AB19 UV1.AB21 UV1.AB23 UV1.AB25 UV1.AB27 UV1.AB29 UV1.AB31 UV1.AC14 UV1.AC16 UV1.AC18 UV1.AC20 UV1.AC22 UV1.AC24 UV1.AC26 UV1.AC28 UV1.AC30 UV1.AC32 UV1.AD15 UV1.AD17 UV1.AD19 UV1.AD21 UV1.AD23 UV1.AD25 UV1.AD27 UV1.AD29 UV1.AD31 UV1.AE14 UV1.AE16 UV1.AE18 UV1.AE20 UV1.AE22 UV1.AE24 UV1.AE26 UV1.AE28 UV1.AE30 UV1.AE32 UV1.AF15 UV1.AF17 UV1.AF19 UV1.AF21 UV1.AF23 UV1.AF25 UV1.AF27 UV1.AF29 UV1.AF31 UV1.AG14 UV1.AG16 UV1.AG18 UV1.AG20 UV1.AG22 UV1.AG24 UV1.AG26 UV1.AG28 UV1.AG30 UV1.AG32 UV1.AH15 UV1.AH17 UV1.AH19 UV1.AH21 UV1.AH23 UV1.AH25 UV1.AH27 UV1.AH29 UV1.AH31 UV1.AJ14 UV1.AJ16 UV1.AJ18 UV1.AJ20 UV1.AJ22 UV1.AJ24 UV1.AJ26 UV1.AJ28 UV1.AJ30 UV1.AJ32 UV1.AK15 UV1.AK17 UV1.AK19 UV1.AK21 UV1.AK23 UV1.AK25 UV1.AK27 UV1.AK29 UV1.AK31 UV1.AL14 UV1.AL16 UV1.AL18 UV1.AL20 UV1.AL22 UV1.AL24 UV1.AL26 UV1.AL28 UV1.AL30 UV1.AL32 UV1.AM15 UV1.AM17 UV1.AM19 UV1.AM21 UV1.AM23 UV1.AM25 UV1.AM27 UV1.AM29 UV1.AM31 UV1.AM32 UV1.AN39 UV1.AP39 UV1.AR39 UV1.AR40 UV1.AR41 UV1.AT39 UV1.AT40 UV1.AT41 UV1.AU39 UV1.AU41 UV1.AU42 UV1.AV41 UV1.AV42 UV1.AV43 UV1.AV44 UV1.AW35 UV1.AW36 UV1.AW37 UV1.AW41 UV1.AW42 UV1.AW43 UV1.AW44 UV1.AW45 UV1.AY36 UV1.AY42 UV1.AY45 UV1.BA36 UV1.BA37 UV1.BA38 UV1.BA39 UV1.BA42 UV1.BA43 UV1.BA44 UV1.BA45 UV1.BA46 UV1.BB37 UV1.BB38 UV1.BB39 UV1.BB40 UV1.BB41 UV1.BB42 UV1.BB43 UV1.BB44 UV1.BB45 UV1.BB46 UV1.BB47 UV1.BC38 UV1.BC39 UV1.BC41 UV1.BC42 UV1.BC45 UV1.BC46 UV1.BD38 UV1.BD39 UV1.BD41 UV1.BD42 UV1.BD44 UV1.BD45 UV1.BD46 UV1.BD47 UV1.BD48 UV1.BD49 UV1.BE38 UV1.BE39 UV1.BE40 UV1.BE41 UV1.BE42 UV1.BE43 UV1.BE44 UV1.BE45 UV1.BE46 UV1.BE47 UV1.BE48 UV1.BE49 UV1.BF38 UV1.BF39 UV1.BF40 UV1.BF41 UV1.BF42 UV1.BF43 UV1.BF44 UV1.BF45 UV1.BF46 UV1.BF47 UV1.BF48 UV1.BF49 UV1.BG39 UV1.BG41 UV1.BG42 UV1.BG44 UV1.BG45 UV1.BG46 UV1.BG47 UV1.BG48 UV1.BG49 UV1.BH39 UV1.BH40 UV1.BH41 UV1.BH42 UV1.BH43 UV1.BH44 UV1.BH45 UV1.BH46 UV1.BH47 UV1.BH48 UV1.BH49 UV1.BJ39 UV1.BJ41 UV1.BJ42 UV1.BJ44 UV1.BJ45 UV1.BJ46 UV1.BJ47 UV1.BJ48 UV1.P15 UV1.P17 UV1.P19 UV1.P21 UV1.P23 UV1.P25 UV1.P27 UV1.P29 UV1.P31 UV1.R14 UV1.R16 UV1.R18 UV1.R20 UV1.R22 UV1.R24 UV1.R26 UV1.R28 UV1.R30 UV1.R32 UV1.T15 UV1.T17 UV1.T19 UV1.T21 UV1.T23 UV1.T25 UV1.T27 UV1.T29 UV1.T31 UV1.U14 UV1.U16 UV1.U18 UV1.U20 UV1.U22 UV1.U24 UV1.U26 UV1.U28 UV1.U30 UV1.U32 UV1.V15 UV1.V17 UV1.V19 UV1.V21 UV1.V23 UV1.V25 UV1.V27 UV1.V29 UV1.V31 UV1.W14 UV1.W16 UV1.W18 UV1.W20 UV1.W22 UV1.W24 UV1.W26 UV1.W28 UV1.W30 UV1.W32 UV1.Y15 UV1.Y17 UV1.Y19 UV1.Y21 UV1.Y23 UV1.Y25 UV1.Y27 UV1.Y29 UV1.Y31
+VREF_CA: C14.1 C15.1 CD19.1 CD20.1 JDIMM1.126 JDIMM2.126 RD1.1 RD2.2 RD3.2
+VREF_DQ_DIMMA: CD1.1 CD2.1 JDIMM1.1 RD5.1 RD6.2 RD9.2
+VREF_DQ_DIMMB: CD24.1 CD25.1 JDIMM2.1 RD11.1 RD12.2 RD13.2
A52_B52: CPU1.A52 CPU1.B52
A53_B53: CPU1.A53 CPU1.B53
AC/DC: RA101.1 UA6.16
AC_BATT#: RV61.2 RV93.1 UV1.AV4 UV19.4
ACDET_CHG: PC719.1 PR716.2 PR719.1 PU700.6
ACDRV_CHG: PR705.2 PU700.4
ACIN: CE40.2 DH1.1 PR714.2 PR715.1 PR731.1 PU700.5 QE4.2 UE5.110 UV19.1
ACIN#: QE4.1 RE17.2 UE1.24
ACIN_D: DH1.2 RH152.1 UH1.E6
AD0: RE33.1 UE8.31
AD0_1: RE27.1 UE4.31
AD0_2: RE43.2 UE3.31
AD1: RE34.1 UE8.32
AD1_1: RE26.2 UE4.32
AD1_2: RE40.2 UE3.32
AD2: RE35.2 UE8.1
AD2_1: RE29.1 UE4.1
AD2_2: RE42.1 UE3.1
AD3: RE36.1 UE8.2
AD3_1: RE30.1 UE4.2
AD3_2: RE44.1 UE3.2
AD_BID0: CE28.1 RE64.1 RE66.2 UE5.66
ADP_I: PR23.2 PR717.1 UE5.65
ADPIN: PC1.1 PC2.1 PJPDC1.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PL1.1 PL3.1
ALERT#: PR503.1 PR506.2 PU500.32
ALIEN_LED_B_DRV#: JLOGO1.10 UE3.5
ALIEN_LED_G_DRV#: JLOGO1.9 UE3.4
ALIEN_LED_R_DRV#: JLOGO1.8 UE3.3
AM0: RA85.1 UA4.10
AM1: RA86.1 UA4.9
AM2: RA87.1 UA4.8
AMD#_NV: RE19.1 UE6.22
AMD#_NV_R: RE19.2 UE1.17
AMGND: CA70.1 CA98.2 CA100.2 RA53.2 RA54.2 RA116.2 RA117.1
AMP_LEFT: CA105.1 JIO.40 UA1.23
AMP_LEFT-1: CA105.2 RA118.1
AMP_LEFT_C: CA103.2 RA140.2 UA4.6
AMP_RIGHT: CA106.1 JIO.39 UA1.22
AMP_RIGHT-1: CA106.2 RA119.1
AMP_RIGHT_C: CA104.2 RA139.2 UA4.31
AOAC_WLAN: UE5.85 UM1.4
AUD_HP_OUT_L_C: RA50.1 UA3.9
AUD_HP_OUT_L_CN: JIO.35 RA50.2
B3_A3: CPU1.A3 CPU1.B3
B54_C54: CPU1.B54 CPU1.C54
B+: CV15.1 PC10.1 PC15.1 PC16.1 PJP203.1 PJP301.2 PL100.1 PL504.2 PL701.1 PQ3.4 PQ703.5 PR12.1 PR603.4 PR702.4 QV1.4 RV9.1
B+_BIAS: JIO.27 LA7.1 PC11.1 PQ3.1 PQ3.2 PQ3.5 PQ3.6 R179.2 RA109.2
BAT_ALERT: PBATT1.9 PD3.3
BATDRV_CHG: PQ703.4 PU700.18
BATT+: PC6.1 PC7.1 PC712.1 PC713.1 PC714.1 PL4.1 PL5.1 PQ703.1 PQ703.2 PQ703.3 PR712.4 PU700.17
BATT++: PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PC8.1 PC9.1 PD700.2 PL4.2 PL5.2
BATT_CHG_LED: QE7.1 RE23.2 UE1.25
BATT_CHG_LED#: QE7.2 UE5.90
BATT_LOW_LED: QE6.1 RE21.2 UE1.22
BATT_LOW_LED#: QE6.2 UE5.93
BATT_PRS: PBATT1.7 PR22.1
BATT_TEMP: CE35.2 PC14.1 PR15.2 PR16.1 PR727.1 UE5.63
BBS_BIT1: RH71.1 UH1.C10
BE1_BD1: CPU1.BD1 CPU1.BE1
BE2_BF2: CPU1.BE2 CPU1.BF2
BE3_BF3: CPU1.BE3 CPU1.BF3
BE52_BF52: CPU1.BE52 CPU1.BF52
BE53_BF53: CPU1.BE53 CPU1.BF53
BE54_BD54: CPU1.BD54 CPU1.BE54
BEEP#: CA67.1 UE5.23
BKOFF#: DV1.2 UE5.105
BOOT1: PR550.2 PU500.18
BOOT2: PR534.2 PU500.27
BOOT3: PR502.2 PU501.2
BOOT_1.35V: PR200.2 PU200.18
BSNL: CA108.1 UA4.19
BSNR: CA110.1 UA4.22
BSPL: CA107.1 UA4.15
BSPR: CA109.1 UA4.26
BST_1.35V: PC204.1 PR200.1
BST_3V: PR108.2 PU100.9
BST_5V: PR109.1 PU100.17
BST_+1.05VSP: PR302.1 PU300.10
BST_+1.35VS_VGAP: PR309.1 PU301.10
BT_LED#: JWLAN1.6 QN4.3 RN25.2
BT_OFF#: JWLAN1.46 RH59.2 UH1.G17
BTST_CHG: PR708.2 PU700.25
BUF_CLK1: RM24.2 UM4.3
BUF_CLK+: RM22.2 UM4.2
BUF_SM_CLK: RM35.1 RM36.2 UM4.11
BUF_SM_DAT: RM30.1 RM37.2 UM4.10
C1_C2: CPU1.C1 CPU1.C2
C3_B2: CPU1.B2 CPU1.C3
CALDERA_ PWRGD: JCDRA.2 RM42.1 UE6.15
CALDERA_ON: JCDRA.1 RM41.2 UE5.108 UM7.2
CALDERA_PRSNT#: JCDRA.21 RM5.2 RM61.1 UE1.28 UE6.5
CALDERA_RST#: RM6.2 UE6.16 UM3.1
CAPS_LED#: JPWR1.28 UE5.91
CDCLK_REQ#: RH80.2 UH1.V3 UR1.2
CDR_BTN#: JCDRA.26 RM17.2 UE5.120
CDR_I2C_CLK: JCDRA.45 RM46.1 RM89.2
CDR_I2C_DAT: JCDRA.46 RM45.1 RM90.2
CDR_ON_ELC: UE1.27 UM7.4
CDR_TXRX_GOOD: UE5.71 UM7.1
CDRA_LED RED: JCDRA.28 QM3.1
CDRA_LED RED_R: QM2.5 UE5.126
CDRA_LED RED_R_R: QM3.3 RM93.2
CDRA_LED WHITE: JCDRA.27 QM1.1
CDRA_LED WHITE_R: QM2.2 UE5.21
CDRA_LED WHITE_R#: QM1.2 QM2.6 RM92.2
CDRA_LED WHITE_R_R: QM1.3 RM91.2
CDRA_RST#: JCDRA.22 UM3.4
CE_EN_R: JEDP1.18 RV36.1
CFG0: CPU1.AG49 T102.1(TP-1)
CFG1: CPU1.AD49 T103.1(TP-1)
CFG2: CPU1.AC49 RC36.2 T104.1(TP-1)
CFG3: CPU1.AE49 T105.1(TP-1)
CFG4: CPU1.Y50 RC37.1 T106.1(TP-1)
CFG5: CPU1.AB49 RC42.2 T108.1(TP-1)
CFG6: CPU1.V51 RC41.2 T107.1(TP-1)
CFG7: CPU1.W51 RC43.2 T109.1(TP-1)
CFG8: CPU1.Y49 T111.1(TP-1)
CFG9: CPU1.Y54 T113.1(TP-1)
CFG10: CPU1.Y53 T110.1(TP-1)
CFG11: CPU1.W53 T112.1(TP-1)
CFG12: CPU1.U53 T116.1(TP-1)
CFG13: CPU1.V54 T117.1(TP-1)
CFG14: CPU1.R53 T114.1(TP-1)
CFG15: CPU1.R52 T115.1(TP-1)
CFG16: CPU1.Y52 T119.1(TP-1)
CFG17: CPU1.V53 T120.1(TP-1)
CFG18: CPU1.Y51 T121.1(TP-1)
CFG19: CPU1.V52 T122.1(TP-1)
CFG_RCOMP: CPU1.R54 RC39.2
CHG: PL700.2 PR712.1
CHG_B+: PC703.1 PC704.1 PC705.1 PC706.1 PL701.2 PQ704.5
CLK_BUF_BCLK: RPH1.3 UH1.AT24
CLK_BUF_BCLK#: RPH1.4 UH1.AR24
CLK_BUF_CKSSCD: RH155.1 UH1.BC6
CLK_BUF_CKSSCD#: RH122.1 UH1.BE6
CLK_BUF_DMI: RPH1.2 UH1.AW24
CLK_BUF_DMI#: RPH1.1 UH1.AY24
CLK_BUF_DOT96: RPH2.4 UH1.G33
CLK_BUF_DOT96#: RPH2.3 UH1.H33
CLK_CPU_DMI: CPU1.AA6 UH1.AF40
CLK_CPU_DMI#: CPU1.AB6 UH1.AF39
CLK_CPU_DPLL: CPU1.AE6 UH1.AF36
CLK_CPU_DPLL#: CPU1.AC6 UH1.AF35
CLK_CPU_SSC_DPLL: CPU1.Y6 UH1.AJ39
CLK_CPU_SSC_DPLL#: CPU1.V6 UH1.AJ40
CLK_PCH_14M: RH79.1 UH1.F45
CLK_PCI0: RH87.1 UH1.D44
CLK_PCI1: RH89.1 UH1.E44
CLK_PCI2: T96.1(TP-1) UH1.B42
CLK_PCI3: T95.1(TP-1) UH1.F41
CLK_PCI4: T83.1(TP-1) UH1.A40
CLK_PCI_LPBACK: RH87.2 UH1.D17
CLK_PCI_LPC: CH72.1 RE89.2 RH89.2 UE5.12
CLK_PCIE_CD: UH1.AF45 UR1.5
CLK_PCIE_CD#: UH1.AF43 UR1.6
CLK_PCIE_DGPU: RM22.1 UH1.Y38
CLK_PCIE_DGPU#: RM24.1 UH1.Y39
CLK_PCIE_DGPU#_C: CM99.2 JCDRA.34
CLK_PCIE_DGPU_C: CM98.2 JCDRA.33
CLK_PCIE_LAN: UH1.AB45 UL1.33
CLK_PCIE_LAN#: UH1.AB43 UL1.32
CLK_PCIE_WLAN: LM2.1 RM39.1 UH1.AD45
CLK_PCIE_WLAN#: LM2.4 RM40.1 UH1.AD43
CLK_PCIE_WLAN#_R: JWLAN1.41 LM2.3 RM40.2
CLK_PCIE_WLAN_R: JWLAN1.39 LM2.2 RM39.2
CLK_PEG_GPU: UH1.AB36 UV1.BD20
CLK_PEG_GPU#: UH1.AB35 UV1.BC20
CLK_REQ#: QV12.3 RV62.1 UV1.BB20
CLK_SMB: PBATT1.5 PR19.1
CLKREQ#_DGPU: RH76.1 UE5.19 UH1.U4 UM4.17
CLKREQ#_GPU: QV12.1 RH74.1 RV531.2 UH1.AF6
CMSRC_CHG: PR706.2 PU700.3
COMP: PC525.2 PR539.2 PU500.7
CPU_B+: PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC530.1 PC531.1 PC533.1 PC534.1 PC535.1 PC536.1 PC537.1 PL504.1 PQ501.2 PQ502.2 PQ503.2 PQ504.2 PQ505.2 PQ506.2 PR526.2
CPU_DPB_CTRLCLK_R: JHDMI1.15 RV31.1 UV4.32
CPU_DPB_CTRLDAT_R: JHDMI1.16 RV32.1 UV4.33
CPU_EDP_AUX: CPU1.F14 CV12.2
CPU_EDP_AUX#: CPU1.F15 CV13.2
CPU_EDP_HPD: JEDP1.16 QC1.2 RC35.1
CPU_EDP_TX0N: CPU1.C14 CV2.2
CPU_EDP_TX0P: CPU1.D14 CV1.2
CPU_EDP_TX1N: CPU1.A12 CV4.2
CPU_EDP_TX1P: CPU1.B12 CV3.2
CPU_EDP_TX2N: CPU1.C12 CV6.2
CPU_EDP_TX2P: CPU1.D12 CV8.2
CPU_EDP_TX3N: CPU1.A14 CV11.2
CPU_EDP_TX3P: CPU1.B14 CV7.2
CPU_FAN_FB: DF1.2 RF1.1 UE5.28
CPU_FAN_PWM: JFAN1.2 RF2.1 UE5.26
CPU_HDMI_N0: CPU1.C24 CV43.2
CPU_HDMI_N1: CPU1.A25 CV41.2
CPU_HDMI_N2: CPU1.C25 CV38.2
CPU_HDMI_N3: CPU1.A24 CV45.2
CPU_HDMI_P0: CPU1.D24 CV42.2
CPU_HDMI_P1: CPU1.B25 CV39.2
CPU_HDMI_P2: CPU1.D25 CV37.2
CPU_HDMI_P3: CPU1.B24 CV44.2
CPU_MDP_N0: CPU1.C21 CV27.1
CPU_MDP_N1: CPU1.A21 CV30.1
CPU_MDP_N2: CPU1.C20 CV33.1
CPU_MDP_N3: CPU1.A20 CV31.1
CPU_MDP_P0: CPU1.D21 CV26.1
CPU_MDP_P1: CPU1.B21 CV28.1
CPU_MDP_P2: CPU1.D20 CV32.1
CPU_MDP_P3: CPU1.B20 CV29.1
CPU_PLTRST#: CPU1.L54 UH1.AU4
CPU_PWR_DEBUG: CPU1.F19 RC50.1 RC52.2
CR_GPIO: RR4.8 UR1.28
CR_WAKE#: RR4.7 UR1.32
CRX_N8: JCDRA.16 UM8.42
CRX_N9: JCDRA.19 UM8.37
CRX_N10: JCDRA.25 UM8.39
CRX_N11: JCDRA.31 UM8.44
CRX_P8: JCDRA.15 UM8.43
CRX_P9: JCDRA.18 UM8.38
CRX_P10: JCDRA.24 UM8.40
CRX_P11: JCDRA.30 UM8.45
CS1: PR106.2 PU100.1
CS2: PR105.2 PU100.5
CS_1.35V: PR201.2 PU200.13
CSON_1: PC717.2 PC721.1 PR712.3 PR723.2
CSOP_1: PC716.2 PC717.1 PR712.2 PR722.2
CSSN_1: PR702.3 PR704.1
CSSN_2: PC708.2 PC709.1 PR704.2 PU700.1
CSSN_B+: PR603.2 RV542.1
CSSN_VGA: PR604.2 RV544.1
CSSP_1: PR702.2 PR703.1
CSSP_2: PC707.2 PC708.1 PR703.2 PU700.2
CSSP_B+: PR603.3 RV540.1
CSSP_VGA: PR604.3 RV543.1
CTL1: JIO.23 UE6.7
CTL2: JIO.14 UE6.8
DAT_SMB: PBATT1.6 PR21.1
DBC_EN: RV46.1 UE5.89
DBC_EN_R: JEDP1.19 RV14.1 RV46.2
DDR3_DRAMRST#: CC28.1 JDIMM1.30 JDIMM2.30 R1.2 RC12.1
DDR_A_BS0: CPU1.BC20 JDIMM1.109
DDR_A_BS1: CPU1.BD21 JDIMM1.108
DDR_A_BS2: CPU1.BD32 JDIMM1.79
DDR_A_CAS#: CPU1.BE21 JDIMM1.115
DDR_A_D0: CPU1.AH54 JDIMM1.5
DDR_A_D1: CPU1.AH52 JDIMM1.7
DDR_A_D2: CPU1.AK51 JDIMM1.15
DDR_A_D3: CPU1.AK54 JDIMM1.17
DDR_A_D4: CPU1.AH53 JDIMM1.4
DDR_A_D5: CPU1.AH51 JDIMM1.6
DDR_A_D6: CPU1.AK52 JDIMM1.16
DDR_A_D7: CPU1.AK53 JDIMM1.18
DDR_A_D8: CPU1.AN54 JDIMM1.21
DDR_A_D9: CPU1.AN52 JDIMM1.23
DDR_A_D10: CPU1.AR51 JDIMM1.33
DDR_A_D11: CPU1.AR53 JDIMM1.35
DDR_A_D12: CPU1.AN53 JDIMM1.22
DDR_A_D13: CPU1.AN51 JDIMM1.24
DDR_A_D14: CPU1.AR52 JDIMM1.34
DDR_A_D15: CPU1.AR54 JDIMM1.36
DDR_A_D16: CPU1.AV52 JDIMM1.39
DDR_A_D17: CPU1.AV53 JDIMM1.41
DDR_A_D18: CPU1.AY52 JDIMM1.51
DDR_A_D19: CPU1.AY51 JDIMM1.53
DDR_A_D20: CPU1.AV51 JDIMM1.40
DDR_A_D21: CPU1.AV54 JDIMM1.42
DDR_A_D22: CPU1.AY54 JDIMM1.50
DDR_A_D23: CPU1.AY53 JDIMM1.52
DDR_A_D24: CPU1.AY47 JDIMM1.57
DDR_A_D25: CPU1.AY49 JDIMM1.59
DDR_A_D26: CPU1.BA47 JDIMM1.67
DDR_A_D27: CPU1.BA45 JDIMM1.69
DDR_A_D28: CPU1.AY45 JDIMM1.56
DDR_A_D29: CPU1.AY43 JDIMM1.58
DDR_A_D30: CPU1.BA49 JDIMM1.68
DDR_A_D31: CPU1.BA43 JDIMM1.70
DDR_A_D32: CPU1.BF14 JDIMM1.129
DDR_A_D33: CPU1.BC14 JDIMM1.131
DDR_A_D34: CPU1.BC11 JDIMM1.141
DDR_A_D35: CPU1.BF11 JDIMM1.143
DDR_A_D36: CPU1.BE14 JDIMM1.130
DDR_A_D37: CPU1.BD14 JDIMM1.132
DDR_A_D38: CPU1.BD11 JDIMM1.140
DDR_A_D39: CPU1.BE11 JDIMM1.142
DDR_A_D40: CPU1.BC9 JDIMM1.147
DDR_A_D41: CPU1.BE9 JDIMM1.149
DDR_A_D42: CPU1.BE6 JDIMM1.157
DDR_A_D43: CPU1.BC6 JDIMM1.159
DDR_A_D44: CPU1.BD9 JDIMM1.146
DDR_A_D45: CPU1.BF9 JDIMM1.148
DDR_A_D46: CPU1.BE5 JDIMM1.158
DDR_A_D47: CPU1.BD6 JDIMM1.160
DDR_A_D48: CPU1.BB4 JDIMM1.163
DDR_A_D49: CPU1.BC2 JDIMM1.165
DDR_A_D50: CPU1.AW3 JDIMM1.175
DDR_A_D51: CPU1.AW2 JDIMM1.177
DDR_A_D52: CPU1.BB3 JDIMM1.164
DDR_A_D53: CPU1.BB2 JDIMM1.166
DDR_A_D54: CPU1.AW4 JDIMM1.174
DDR_A_D55: CPU1.AW1 JDIMM1.176
DDR_A_D56: CPU1.AU3 JDIMM1.181
DDR_A_D57: CPU1.AU1 JDIMM1.183
DDR_A_D58: CPU1.AR1 JDIMM1.191
DDR_A_D59: CPU1.AR4 JDIMM1.193
DDR_A_D60: CPU1.AU2 JDIMM1.180
DDR_A_D61: CPU1.AU4 JDIMM1.182
DDR_A_D62: CPU1.AR2 JDIMM1.192
DDR_A_D63: CPU1.AR3 JDIMM1.194
DDR_A_DQS0: CPU1.AJ53 JDIMM1.12
DDR_A_DQS1: CPU1.AP52 JDIMM1.29
DDR_A_DQS2: CPU1.AW53 JDIMM1.47
DDR_A_DQS3: CPU1.BA46 JDIMM1.64
DDR_A_DQS4: CPU1.BE12 JDIMM1.137
DDR_A_DQS5: CPU1.BD7 JDIMM1.154
DDR_A_DQS6: CPU1.BA2 JDIMM1.171
DDR_A_DQS7: CPU1.AT3 JDIMM1.188
DDR_A_DQS#0: CPU1.AJ52 JDIMM1.10
DDR_A_DQS#1: CPU1.AP53 JDIMM1.27
DDR_A_DQS#2: CPU1.AW52 JDIMM1.45
DDR_A_DQS#3: CPU1.AY46 JDIMM1.62
DDR_A_DQS#4: CPU1.BD12 JDIMM1.135
DDR_A_DQS#5: CPU1.BE7 JDIMM1.152
DDR_A_DQS#6: CPU1.BA3 JDIMM1.169
DDR_A_DQS#7: CPU1.AT2 JDIMM1.186
DDR_A_MA0: CPU1.BD28 JDIMM1.98
DDR_A_MA1: CPU1.BD27 JDIMM1.97
DDR_A_MA2: CPU1.BF28 JDIMM1.96
DDR_A_MA3: CPU1.BE28 JDIMM1.95
DDR_A_MA4: CPU1.BF32 JDIMM1.92
DDR_A_MA5: CPU1.BC27 JDIMM1.91
DDR_A_MA6: CPU1.BF27 JDIMM1.90
DDR_A_MA7: CPU1.BC28 JDIMM1.86
DDR_A_MA8: CPU1.BE27 JDIMM1.89
DDR_A_MA9: CPU1.BC32 JDIMM1.85
DDR_A_MA10: CPU1.BD20 JDIMM1.107
DDR_A_MA11: CPU1.BF31 JDIMM1.84
DDR_A_MA12: CPU1.BC31 JDIMM1.83
DDR_A_MA13: CPU1.BE20 JDIMM1.119
DDR_A_MA14: CPU1.BE32 JDIMM1.80
DDR_A_MA15: CPU1.BE31 JDIMM1.78
DDR_A_RAS#: CPU1.BF20 JDIMM1.110
DDR_A_WE#: CPU1.BF21 JDIMM1.113
DDR_B_BS0: CPU1.AY23 JDIMM2.109
DDR_B_BS1: CPU1.BA23 JDIMM2.108
DDR_B_BS2: CPU1.BA36 JDIMM2.79
DDR_B_CAS#: CPU1.AV20 JDIMM2.115
DDR_B_D0: CPU1.AC54 JDIMM2.5
DDR_B_D1: CPU1.AC52 JDIMM2.7
DDR_B_D2: CPU1.AE51 JDIMM2.15
DDR_B_D3: CPU1.AE54 JDIMM2.17
DDR_B_D4: CPU1.AC53 JDIMM2.4
DDR_B_D5: CPU1.AC51 JDIMM2.6
DDR_B_D6: CPU1.AE52 JDIMM2.16
DDR_B_D7: CPU1.AE53 JDIMM2.18
DDR_B_D8: CPU1.AU47 JDIMM2.21
DDR_B_D9: CPU1.AU49 JDIMM2.23
DDR_B_D10: CPU1.AV43 JDIMM2.33
DDR_B_D11: CPU1.AV45 JDIMM2.35
DDR_B_D12: CPU1.AU43 JDIMM2.22
DDR_B_D13: CPU1.AU45 JDIMM2.24
DDR_B_D14: CPU1.AV47 JDIMM2.34
DDR_B_D15: CPU1.AV49 JDIMM2.36
DDR_B_D16: CPU1.BC49 JDIMM2.39
DDR_B_D17: CPU1.BE49 JDIMM2.41
DDR_B_D18: CPU1.BD47 JDIMM2.51
DDR_B_D19: CPU1.BC47 JDIMM2.53
DDR_B_D20: CPU1.BD49 JDIMM2.40
DDR_B_D21: CPU1.BD50 JDIMM2.42
DDR_B_D22: CPU1.BE47 JDIMM2.50
DDR_B_D23: CPU1.BF47 JDIMM2.52
DDR_B_D24: CPU1.BE44 JDIMM2.57
DDR_B_D25: CPU1.BD44 JDIMM2.59
DDR_B_D26: CPU1.BC42 JDIMM2.67
DDR_B_D27: CPU1.BF42 JDIMM2.69
DDR_B_D28: CPU1.BF44 JDIMM2.56
DDR_B_D29: CPU1.BC44 JDIMM2.58
DDR_B_D30: CPU1.BD42 JDIMM2.68
DDR_B_D31: CPU1.BE42 JDIMM2.70
DDR_B_D32: CPU1.BA16 JDIMM2.129
DDR_B_D33: CPU1.AU16 JDIMM2.131
DDR_B_D34: CPU1.BA15 JDIMM2.141
DDR_B_D35: CPU1.AV15 JDIMM2.143
DDR_B_D36: CPU1.AY16 JDIMM2.130
DDR_B_D37: CPU1.AV16 JDIMM2.132
DDR_B_D38: CPU1.AY15 JDIMM2.140
DDR_B_D39: CPU1.AU15 JDIMM2.142
DDR_B_D40: CPU1.AU12 JDIMM2.147
DDR_B_D41: CPU1.AY12 JDIMM2.149
DDR_B_D42: CPU1.BA10 JDIMM2.157
DDR_B_D43: CPU1.AU10 JDIMM2.159
DDR_B_D44: CPU1.AV12 JDIMM2.146
DDR_B_D45: CPU1.BA12 JDIMM2.148
DDR_B_D46: CPU1.AY10 JDIMM2.158
DDR_B_D47: CPU1.AV10 JDIMM2.160
DDR_B_D48: CPU1.AU8 JDIMM2.163
DDR_B_D49: CPU1.BA8 JDIMM2.165
DDR_B_D50: CPU1.AV6 JDIMM2.175
DDR_B_D51: CPU1.BA6 JDIMM2.177
DDR_B_D52: CPU1.AV8 JDIMM2.164
DDR_B_D53: CPU1.AY8 JDIMM2.166
DDR_B_D54: CPU1.AU6 JDIMM2.174
DDR_B_D55: CPU1.AY6 JDIMM2.176
DDR_B_D56: CPU1.AM2 JDIMM2.181
DDR_B_D57: CPU1.AM3 JDIMM2.183
DDR_B_D58: CPU1.AK1 JDIMM2.191
DDR_B_D59: CPU1.AK4 JDIMM2.193
DDR_B_D60: CPU1.AM1 JDIMM2.180
DDR_B_D61: CPU1.AM4 JDIMM2.182
DDR_B_D62: CPU1.AK2 JDIMM2.192
DDR_B_D63: CPU1.AK3 JDIMM2.194
DDR_B_DQS0: CPU1.AD53 JDIMM2.12
DDR_B_DQS1: CPU1.AV46 JDIMM2.29
DDR_B_DQS2: CPU1.BE48 JDIMM2.47
DDR_B_DQS3: CPU1.BE43 JDIMM2.64
DDR_B_DQS4: CPU1.AW15 JDIMM2.137
DDR_B_DQS5: CPU1.AW12 JDIMM2.154
DDR_B_DQS6: CPU1.AW6 JDIMM2.171
DDR_B_DQS7: CPU1.AL3 JDIMM2.188
DDR_B_DQS#0: CPU1.AD52 JDIMM2.10
DDR_B_DQS#1: CPU1.AU46 JDIMM2.27
DDR_B_DQS#2: CPU1.BD48 JDIMM2.45
DDR_B_DQS#3: CPU1.BD43 JDIMM2.62
DDR_B_DQS#4: CPU1.AW16 JDIMM2.135
DDR_B_DQS#5: CPU1.AW10 JDIMM2.152
DDR_B_DQS#6: CPU1.AW8 JDIMM2.169
DDR_B_DQS#7: CPU1.AL2 JDIMM2.186
DDR_B_MA0: CPU1.BA30 JDIMM2.98
DDR_B_MA1: CPU1.AW30 JDIMM2.97
DDR_B_MA2: CPU1.AY30 JDIMM2.96
DDR_B_MA3: CPU1.AV30 JDIMM2.95
DDR_B_MA4: CPU1.AW32 JDIMM2.92
DDR_B_MA5: CPU1.AY32 JDIMM2.91
DDR_B_MA6: CPU1.AT30 JDIMM2.90
DDR_B_MA7: CPU1.AV32 JDIMM2.86
DDR_B_MA8: CPU1.BA32 JDIMM2.89
DDR_B_MA9: CPU1.AU32 JDIMM2.85
DDR_B_MA10: CPU1.AU23 JDIMM2.107
DDR_B_MA11: CPU1.AY35 JDIMM2.84
DDR_B_MA12: CPU1.AW35 JDIMM2.83
DDR_B_MA13: CPU1.AU20 JDIMM2.119
DDR_B_MA14: CPU1.AW36 JDIMM2.80
DDR_B_MA15: CPU1.BA35 JDIMM2.78
DDR_B_RAS#: CPU1.AV23 JDIMM2.110
DDR_B_WE#: CPU1.AW23 JDIMM2.113
DDR_CKE0_DIMMA: CPU1.BE34 JDIMM1.73
DDR_CKE1_DIMMA: CPU1.BF34 JDIMM1.74
DDR_CKE2_DIMMB: CPU1.AU36 JDIMM2.73
DDR_CKE3_DIMMB: CPU1.AU35 JDIMM2.74
DDR_CS0_DIMMA#: CPU1.BE16 JDIMM1.114
DDR_CS1_DIMMA#: CPU1.BC17 JDIMM1.121
DDR_CS2_DIMMB#: CPU1.BA20 JDIMM2.114
DDR_CS3_DIMMB#: CPU1.AY19 JDIMM2.121
DDR_HVREF_RST_PCH: RH100.2 UH1.N8
DEMA0: RM68.2 RM83.2 RM88.2 UM8.49
DEMA1: RM63.2 RM65.2 RM67.2 UM8.50
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: JIO.20 RA44.1 UE6.2
DEW1: RN7.1 RN18.1 UN1.16
DEW2: RN6.1 RN17.1 UN1.6
DGPU_HOLD_RST#: RE98.1 RV58.2 RV530.2 UH1.C12 UV14.1
DGPU_PEX_RST#: DV8.1 RV39.2 RV40.1 RV59.1 RV208.2
DGPU_PEX_RST#_R: RV40.2 UV1.BE20
DGPU_PRSNT#: RH134.2 RH135.2 UH1.AT7
DGPU_PWR_EN: PR615.2 RH44.2 RV538.2 UH1.A12 UV11.3
DGPU_PWROK: RH151.2 UE6.19 UH1.C16
DH_1.35V: PQ200.4 PU200.17
DH_CHG: PQ704.4 PU700.26
DIR_SEL: RA101.2 UA6.6
DISP_CEC: JDP1.6 RV18.2
DISP_CLK_AUXP_CONN: JDP1.16 RV16.1 UV3.4
DISP_DAT_AUXN_CONN: JDP1.18 RV15.1 UV3.7
DISPOFF#: DV1.1 JEDP1.37 RV1.1
DL_1.35V: PQ201.4 PU200.15
DL_CHG: PQ706.4 PU700.23
DMI_CRX_PTX_N0: CPU1.AB2 UH1.BD21
DMI_CRX_PTX_N1: CPU1.AB3 UH1.BE20
DMI_CRX_PTX_N2: CPU1.AC3 UH1.BD17
DMI_CRX_PTX_N3: CPU1.AC1 UH1.BE18
DMI_CRX_PTX_P0: CPU1.AB1 UH1.BB21
DMI_CRX_PTX_P1: CPU1.AB4 UH1.BC20
DMI_CRX_PTX_P2: CPU1.AC4 UH1.BB17
DMI_CRX_PTX_P3: CPU1.AC2 UH1.BC18
DMI_CTX_PRX_N0: CPU1.AF2 UH1.AW22
DMI_CTX_PRX_N1: CPU1.AF4 UH1.AR20
DMI_CTX_PRX_N2: CPU1.AG4 UH1.AP17
DMI_CTX_PRX_N3: CPU1.AG2 UH1.AV20
DMI_CTX_PRX_P0: CPU1.AF1 UH1.AY22
DMI_CTX_PRX_P1: CPU1.AF3 UH1.AP20
DMI_CTX_PRX_P2: CPU1.AG3 UH1.AR17
DMI_CTX_PRX_P3: CPU1.AG1 UH1.AW20
DMI_IREF: RH144.2 UH1.BE16
DMI_RCOMP: RH42.2 UH1.AY17
DP_CBL_DET: JDP1.4 RV17.1 UH1.F17 UV3.1
DSWODVREN: RH65.1 RH70.2 UH1.C8
EAPD#: DA15.2 UA1.52 UE6.6
EC_AC_BAT#: RV93.2 UE6.9 UV19.2
EC_ESB_CLK: RE93.2 UE5.17 UE6.1
EC_ESB_DAT: RE94.2 UE5.18 UE6.4
EC_LID_OUT#: RH127.2 UE5.101
EC_MUTE#: DA15.3 UE5.83
EC_ON: PD100.2 UE5.112
EC_RST#: CE37.1 RE68.1 UE5.37
EC_RX: JWLAN1.32 UE5.31
EC_SCI#: UE5.20 UH1.G15
EC_SMB_CK1: PR18.2 PR721.1 RE90.4 UE5.77
EC_SMB_CK2: QH3.1 QV13.3 RE90.2 RM67.1 RM89.1 U2407.10 U2410.8 UE5.79
EC_SMB_DA1: PR20.2 PR720.1 RE90.3 UE5.78
